# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ0: length 86
  TOP w0.102: v2(132.11,81.26) 132.11,80.88 131.99,80.76 131.73,80.76 131.6,80.88 131.6,81.43 131.89,81.72 132.45,81.72 132.58,81.84 132.58,82.56 132.7,82.68 132.87,82.68 132.99,82.56 132.99,80.87 132.86,80.74 132.53,80.74 132.4,80.62 JDIMM2.7
  IN03 w0.13: v2(148.04,133.63) 145.2,133.63 132.46,120.88 132.46,120.3 126.59,114.43 126.59,113.62 124.68,111.71 124.68,90.15 125.22,89.61 125.92,89.61 126.27,89.26 126.27,88.03 128.64,85.66 128.64,82.1 129.48,81.26 v2(132.11,81.26)
  BOTTOM w0.076: U1.BR6 149.93,133.95 148.99,133.95 148.86,134.08 148.49,134.08 v2(148.04,133.63)
  BOTTOM w0.102: v2(132.11,81.26) 132.79,81.26 133.76,82.24 133.76,86.31 134.07,86.62 JDIMM1.7
M_A_DQ1: length 91.1
  TOP w0.102: JDIMM2.4 131.65,85.59 131.36,85.3 130.69,85.3 130.59,85.4 130.59,86.72 130.49,86.82 130.28,86.82 130.18,86.72 130.18,85.4 130.08,85.3 128.65,85.3 128.53,85.18 128.53,84.98 128.72,84.79 131.99,84.79 v2(132.11,84.92)
  IN03 w0.13: v2(146.64,132.3) 144.74,132.3 133.5,121.06 133.5,120.32 127.35,114.18 127.35,113.36 125.44,111.46 125.44,111.13 125.6,110.98 125.6,110.62 125.44,110.46 125.44,110.1 125.6,109.95 125.6,109.58 125.44,109.43 125.44,109.06 125.6,108.91 125.6,108.54 125.44,108.39 125.44,108.03 125.6,107.87 125.6,107.51 125.44,107.36 125.44,91.6 127.63,89.41 127.63,89.24 127.38,88.99 127.38,88.82 130.12,86.08 130.56,86.08 130.91,86.44 132.2,86.44 132.53,86.11 132.53,85.12 132.33,84.92 v2(132.11,84.92)
  BOTTOM w0.076: v2(146.64,132.3) 146.64,133.36 147.68,134.41 U1.BT6
  BOTTOM w0.102: v2(132.11,84.92) 129.25,84.92 128.62,84.28 128.62,82.63 130.79,80.46 133.18,80.46 133.32,80.32 JDIMM1.4
M_A_DQ2: length 84.5
  TOP w0.102: JDIMM2.20 135.65,86.58 135.92,86.31 136.24,86.31 136.58,85.97 136.58,83.04 v2(136.18,82.63)
  IN03 w0.13: v2(146.67,129.99) 145.28,129.99 136.21,120.93 136.21,120.11 129.64,113.53 129.64,112.45 128.06,110.87 128.06,96.65 129.38,95.33 129.38,93.3 131.62,91.06 131.62,88.78 131.83,88.56 132.67,88.56 135.05,86.18 135.05,81.36 135.81,80.6 136.25,80.6 136.38,80.73 136.38,81.33 136.51,81.46 136.77,81.46 136.9,81.33 136.9,80.73 137.02,80.6 137.28,80.6 137.48,80.8 137.48,82.22 136.87,82.83 136.38,82.83 v2(136.18,82.63)
  BOTTOM w0.076: U1.BP3 150.18,131.86 149.87,131.86 149.68,131.67 149.66,131.64 149.66,131.27 149.66,131.19 149.6,131.12
  BOTTOM w0.102: JDIMM1.20 137.32,80.64 136.8,81.16 135.45,81.16 135.15,81.46 135.15,82.12 135.66,82.63 v2(136.18,82.63)
  BOTTOM w0.14: v2(146.67,129.99) 146.79,129.87 148.35,129.87 149.6,131.12
M_A_DQ3: length 83.6
  TOP w0.102: v2(136.18,83.9) 135.77,83.49 135.77,81.36 135.9,81.23 JDIMM2.21
  IN03 w0.13: v2(147.81,131.03) 147.81,130.47 146.88,129.54 145.26,129.54 136.62,120.91 136.62,120.01 130.05,113.44 130.05,112.34 128.44,110.72 128.44,110.44 128.57,110.31 129.02,110.31 129.15,110.18 129.15,109.92 129.02,109.79 128.57,109.79 128.44,109.66 128.44,109.4 128.57,109.27 129.02,109.27 129.15,109.14 129.15,108.89 129.02,108.76 128.57,108.76 128.44,108.63 128.44,108.37 128.57,108.24 129.02,108.24 129.15,108.11 129.15,107.85 129.02,107.72 128.57,107.72 128.44,107.59 128.44,107.33 128.57,107.2 129.02,107.2 129.15,107.07 129.15,106.81 129.02,106.68 128.57,106.68 128.44,106.55 128.44,106.29 128.57,106.17 129.02,106.17 129.15,106.04 129.15,105.78 129.02,105.65 128.57,105.65 128.44,105.52 128.44,105.26 128.57,105.13 129.02,105.13 129.15,105 129.15,104.74 129.02,104.61 128.57,104.61 128.44,104.48 128.44,104.22 128.57,104.1 129.02,104.1 129.15,103.97 129.15,103.71 129.02,103.58 128.57,103.58 128.44,103.45 128.44,96.83 129.8,95.47 129.8,93.36 129.98,93.18 130.17,93.18 131.25,94.26 131.43,94.26 131.61,94.07 131.61,93.89 130.53,92.81 130.53,92.63 132.02,91.14 132.02,90.29 132.15,90.16 132.43,90.16 132.56,90.03 132.56,89.11 132.68,88.98 132.99,88.98 133.12,88.85 133.12,88.59 135.38,86.32 135.38,83.79 135.51,83.67 136.05,83.67 136.18,83.79 v2(136.18,83.9)
  BOTTOM w0.076: 149.13,131.75 149.52,131.75 U1.BR3
  BOTTOM w0.102: JDIMM1.21 137.57,86.78 137.19,86.4 137.19,84.09 137,83.9 v2(136.18,83.9)
  BOTTOM w0.14: 149.13,131.75 148.41,131.03 v2(147.81,131.03)
M_A_DQ4: length 86.6
  TOP w0.102: JDIMM2.3 131.4,80.47 131.28,80.6 131.05,80.6 130.94,80.7 130.94,81.18 130.84,81.28 130.64,81.28 130.54,81.18 130.54,80.7 130.44,80.6 129.97,80.6 129.74,80.83 129.74,81.36 130.12,81.74 130.55,81.74 130.7,81.59 131.11,81.59 131.67,82.15 v2(132.11,82.15)
  IN03 w0.13: v2(132.11,82.15) 132.51,82.15 132.87,82.51 132.87,86.25 132.34,86.77 130.04,86.77 128.06,88.75 128.06,88.93 128.25,89.12 128.25,89.3 126.09,91.45 126.09,105.46 125.9,105.66 125.9,105.98 126.09,106.18 126.09,106.5 125.9,106.69 125.9,107.02 126.09,107.21 126.09,111.58 127.73,113.21 127.73,114.05 134.03,120.35 134.03,121.16 144.72,131.85 v2(146.19,131.85)
  BOTTOM w0.076: U1.BN5 150.95,133.77 150.95,134.23 150.6,134.58 149.72,134.58 149.59,134.72 148.99,134.72 148.92,134.66 147.63,134.66 146.19,133.22 v2(146.19,131.85)
  BOTTOM w0.102: v2(132.11,82.15) 132.12,82.15 132.77,82.79 132.77,84.88 132.23,85.42 132,85.42 131.69,85.73 131.69,86.16 131.87,86.34 132.79,86.34 133.07,86.62 JDIMM1.3
M_A_DQ5: length 89.4
  TOP w0.102: JDIMM2.8 132.65,86.6 132.81,86.44 133.83,86.44 133.95,86.31 133.95,86.08 133.83,85.96 133.12,85.96 133.01,85.85 133.01,85.71 133.12,85.6 133.82,85.6 133.92,85.5 133.92,85.37 133.82,85.27 133.14,85.27 133.04,85.17 133.04,85.07 133.27,84.84 133.27,84.71 132.99,84.43 132.99,84.13 132.88,84.03 132.74,84.03 132.63,84.13 132.63,86.19 132.51,86.31 132.24,86.31 132.11,86.19 v2(132.11,85.93)
  IN03 w0.13: v2(132.11,85.93) 131.87,85.93 131.11,85.17 130.14,85.17 126.87,88.45 126.87,89.56 126.05,90.38 125.87,90.38 125.55,90.07 125.37,90.07 125.19,90.26 125.19,90.44 125.5,90.75 125.5,90.93 125.06,91.37 125.06,111.59 126.97,113.49 126.97,114.3 132.96,120.3 132.96,120.96 145.18,133.18 v2(147.59,133.18)
  BOTTOM w0.076: U1.BP6 150.47,134.3 149.74,134.3 149.54,134.1 149.19,134.1 149.05,134.25 148.3,134.25 148.12,134.06 147.8,134.06 147.59,133.86 v2(147.59,133.18)
  BOTTOM w0.102: v2(132.11,85.93) 132.46,85.93 133.26,85.13 133.26,82.5 132.47,81.72 131.83,81.72 131.6,81.49 131.6,81.11 131.9,80.81 133.81,80.81 134.32,80.3 JDIMM1.8
M_A_DQ6: length 84.1
  TOP w0.102: v2(134.27,82.63) 134.7,83.06 134.7,86.52 134.65,86.57 JDIMM2.16
  IN03 w0.076: v2(148.25,131.48) 147.69,131.48 147.23,131.02
  IN03 w0.13: 147.23,131.02 147.07,131.02 146.38,130.33 145.18,130.33 135.81,120.96 135.81,120.21 129.25,113.66 129.25,112.6 127.68,111.03 127.68,96.52 129,95.2 129,93.2 131.26,90.94 131.26,88.62 131.66,88.23 132.53,88.23 134.72,86.04 134.72,80.98 134.59,80.85 133.33,80.85 133.2,80.98 133.2,81.36 133.33,81.49 133.72,81.49 133.85,81.61 133.85,82.05 133.72,82.17 133.33,82.17 133.2,82.3 133.2,82.74 133.33,82.86 134.14,82.86 134.27,82.74 v2(134.27,82.63)
  BOTTOM w0.076: v2(148.25,131.48) 148.25,132.02 148.58,132.34 148.83,132.34 148.93,132.44 149.7,132.44 149.76,132.5 150.3,132.5 150.46,132.67 150.72,132.67 150.97,132.41 150.97,132.21 150.67,131.91 U1.BP2
  BOTTOM w0.102: JDIMM1.16 136.32,80.72 136.19,80.85 134.72,80.85 134.49,81.07 134.49,81.38 134.69,81.58 134.69,82.22 134.28,82.63 v2(134.27,82.63)
M_A_DQ7: length 85.4
  TOP w0.102: v2(136.18,85.17) 135.47,84.46 135.47,81.16 134.9,80.59 JDIMM2.17
  IN03 w0.13: v2(136.18,85.17) 135.86,85.17 135.73,85.3 135.73,86.44 133.47,88.7 133.47,89.59 133.06,90 133.06,90.25 132.45,90.87 132.45,91.38 132.87,91.81 132.87,91.99 132.69,92.18 132.51,92.18 132.07,91.74 131.89,91.74 131.09,92.54 131.09,92.72 132.18,93.8 132.18,93.98 131.34,94.82 131.16,94.82 130.5,94.15 130.32,94.15 130.13,94.34 130.13,94.52 130.79,95.18 130.79,95.36 129.51,96.65 129.51,97.26 129.38,97.39 128.93,97.39 128.8,97.52 128.8,97.78 128.93,97.91 129.38,97.91 129.51,98.04 129.51,98.3 129.38,98.43 128.93,98.43 128.8,98.56 128.8,98.81 128.93,98.94 129.38,98.94 129.51,99.07 129.51,99.33 129.38,99.46 128.93,99.46 128.8,99.59 128.8,99.85 128.93,99.98 129.38,99.98 129.51,100.11 129.51,100.37 129.38,100.5 128.93,100.5 128.8,100.63 128.8,100.89 128.93,101.02 129.38,101.02 129.51,101.15 129.51,101.41 129.38,101.53 128.93,101.53 128.8,101.66 128.8,101.92 128.93,102.05 129.38,102.05 129.51,102.18 129.51,102.44 129.38,102.57 128.93,102.57 128.8,102.7 128.8,102.96 128.93,103.09 129.38,103.09 129.51,103.22 129.51,111.28 130.45,112.22 130.45,113.33 137,119.88 137,120.86 145.14,128.99 v2(145.65,128.99)
  BOTTOM w0.097: 150.21,130.25 150.34,130.38 150.68,130.38 150.97,130.68 150.97,131.83 151.25,132.1 U1.BN3
  BOTTOM w0.102: v2(136.18,85.17) 136.39,85.17 136.58,84.98 136.58,84.29 136.67,84.2 136.8,84.2 136.89,84.29 136.89,85.47 136.76,85.6 136.46,85.6 136.37,85.69 136.37,85.82 136.46,85.91 136.79,85.91 136.89,86 136.89,86.14 136.79,86.24 136.32,86.24 136.25,86.31 136.25,86.46 136.57,86.78 JDIMM1.17
  BOTTOM w0.14: v2(145.65,128.99) 146.04,128.6 148.56,128.6 150.21,130.25
M_A_DQ8: length 78.3
  TOP w0.102: v2(138.34,85.17) 138.28,85.22 138.06,85.22 137.93,85.09 137.93,84.24 137.84,84.15 137.71,84.15 137.62,84.24 137.62,85.3 137.7,85.37 137.88,85.37 137.98,85.47 137.98,85.61 137.88,85.7 137.7,85.7 137.62,85.77 137.62,85.96 137.7,86.03 137.83,86.03 137.92,86.12 137.92,86.28 137.83,86.36 137.54,86.36 137.45,86.45 137.45,86.57 137.65,86.78 JDIMM2.28
  IN03 w0.13: v2(152.95,132.44) 152.37,131.85 150.72,131.85 146.04,127.18 145.13,127.18 138.79,120.84 138.79,119.57 131.95,112.73 131.95,107.22 131.13,106.4 131.13,101.67 131.26,101.54 131.71,101.54 131.84,101.41 131.84,101.14 131.71,101.02 131.26,101.02 131.13,100.89 131.13,100.63 131.26,100.5 131.84,100.5 131.97,100.37 131.97,100.11 131.84,99.98 131.26,99.98 131.13,99.85 131.13,99.59 131.26,99.46 131.84,99.46 131.97,99.34 131.97,99.07 131.84,98.94 131.26,98.94 131.13,98.82 131.13,98.56 131.26,98.43 131.39,98.43 131.52,98.3 131.52,98.04 131.39,97.91 131.26,97.91 131.13,97.78 131.13,97.13 135.07,93.19 135.07,92.52 134.77,92.22 134.77,91.05 135.42,90.39 135.42,88.5 137.89,86.04 137.89,85.61 v2(138.34,85.17)
  BOTTOM w0.102: JDIMM1.28 139.32,80.67 139.1,80.89 139.1,84.41 v2(138.34,85.17)
  BOTTOM w0.14: v2(152.95,132.44) 152.63,132.77 U1.BL4
M_A_DQ9: length 77
  TOP w0.102: v2(138.34,83.9) 138.28,83.85 137.54,83.85 137.32,84.07 137.32,86.11 136.65,86.78 JDIMM2.24
  IN03 w0.13: v2(138.34,83.9) 138.16,83.72 137.84,83.72 137.54,84.03 137.54,85.92 135.09,88.36 135.09,90.18 134.39,90.88 134.39,92.31 134.69,92.62 134.69,93.07 130.68,97.08 130.68,107.13 130.81,107.26 131.36,107.26 131.49,107.38 131.49,107.65 131.36,107.78 130.81,107.78 130.68,107.91 130.68,108.16 130.81,108.29 131.46,108.29 131.59,108.42 131.59,108.68 131.46,108.81 130.81,108.81 130.68,108.94 130.68,110.85 131.58,111.75 131.58,112.87 138.43,119.72 138.43,120.97 145,127.54 145.89,127.54 150.67,132.31 152.17,132.31 v2(152.95,133.09)
  BOTTOM w0.102: JDIMM1.24 138.32,81.09 138.79,81.56 138.79,83.47 138.36,83.9 v2(138.34,83.9)
  BOTTOM w0.14: v2(152.95,133.09) 152.63,133.42 U1.BL5
M_A_DQ10: length 77.4
  TOP w0.102: v2(142.27,83.9) 142.22,83.85 141.54,83.85 141.19,84.19 141.19,84.92 140.88,85.23 140.88,85.98 140.15,86.71 JDIMM2.38
  IN03 w0.076: v2(150.5,129.34) 150.5,128.46 147.97,125.94 147.64,125.94
  IN03 w0.13: 147.64,125.94 146.96,125.25 146.81,125.25 141.3,119.74 141.3,118.66 135.4,112.77 135.4,99.52 135.53,99.39 135.88,99.39 136.01,99.26 136.01,99 135.88,98.87 135.53,98.87 135.4,98.74 135.4,98.49 135.53,98.36 135.88,98.36 136.01,98.23 136.01,97.97 135.88,97.84 135.53,97.84 135.4,97.71 135.4,97.45 135.53,97.32 135.88,97.32 136.01,97.19 136.01,96.93 135.88,96.8 135.53,96.8 135.4,96.67 135.4,96.35 138.78,92.97 138.78,91.27 138.68,91.16 138.33,91.16 138.2,91.03 138.2,90.77 138.33,90.64 138.68,90.64 138.76,90.56 138.76,88.3 141.17,85.89 141.17,85.17 141.3,85.04 141.67,85.04 141.8,84.91 141.8,84.65 141.67,84.52 141.3,84.52 141.17,84.39 141.17,84.14 141.3,84.01 141.44,84.01 141.57,83.88 141.57,83.62 141.44,83.49 141.3,83.49 141.17,83.36 141.17,82.21 141.38,81.99 141.6,81.99 141.83,82.23 141.83,83.57 142.16,83.9 v2(142.27,83.9)
  BOTTOM w0.076: U1.BL2 152.51,130.72 151.13,129.34 v2(150.5,129.34)
  BOTTOM w0.102: JDIMM1.38 141.82,80.91 142.69,81.78 142.69,83.48 v2(142.27,83.9)
M_A_DQ11: length 78.2
  TOP w0.102: v2(142.27,85.17) 142.06,85.17 141.85,84.97 141.85,84.45 141.76,84.36 141.62,84.36 141.52,84.45 141.52,85.22 141.62,85.32 141.73,85.32 141.83,85.42 141.83,85.6 141.75,85.68 141.29,85.68 141.22,85.75 141.22,85.96 141.32,86.06 141.66,86.06 141.78,86.18 141.78,86.35 141.66,86.47 141.25,86.47 141.15,86.57 JDIMM2.42
  IN03 w0.076: 147.77,125.66 148.03,125.66 151.4,129.03 v2(151.4,130.23)
  IN03 w0.13: 147.77,125.66 141.66,119.54 141.66,118.51 136.39,113.25 136.39,111.85 136.26,111.72 136.09,111.72 135.96,111.59 135.96,111.34 136.09,111.21 136.26,111.21 136.39,111.08 136.39,110.89 136.26,110.76 135.89,110.76 135.76,110.63 135.76,110.37 135.89,110.24 136.26,110.24 136.39,110.11 136.39,109.85 136.26,109.72 135.89,109.72 135.76,109.59 135.76,109.33 135.89,109.2 136.26,109.2 136.39,109.07 136.39,108.82 136.26,108.69 135.89,108.69 135.76,108.56 135.76,108.3 135.89,108.17 136.26,108.17 136.39,108.04 136.39,107.78 136.26,107.65 135.89,107.65 135.76,107.52 135.76,107.26 135.89,107.13 136.26,107.13 136.39,107 136.39,106.74 136.26,106.61 135.89,106.61 135.76,106.48 135.76,106.22 135.89,106.1 136.26,106.1 136.39,105.97 136.39,105.71 136.26,105.58 135.89,105.58 135.76,105.45 135.76,105.19 135.89,105.06 136.26,105.06 136.39,104.93 136.39,104.67 136.26,104.54 135.89,104.54 135.76,104.41 135.76,104.15 135.89,104.02 136.26,104.02 136.39,103.89 136.39,103.63 136.26,103.5 135.89,103.5 135.76,103.37 135.76,103.12 135.89,102.99 136.26,102.99 136.39,102.86 136.39,102.6 136.26,102.47 135.94,102.47 135.81,102.34 135.81,102.08 135.94,101.95 136.26,101.95 136.39,101.82 136.39,101.56 136.26,101.43 135.94,101.43 135.81,101.3 135.81,101.05 135.94,100.92 136.26,100.92 136.39,100.79 136.39,100.53 136.26,100.4 135.94,100.4 135.81,100.27 135.81,100.01 135.94,99.88 136.26,99.88 136.39,99.75 136.39,95.87 139.12,93.15 139.12,88.42 141.83,85.7 141.83,85.36 142.01,85.17 v2(142.27,85.17)
  BOTTOM w0.102: v2(142.27,85.17) 142.27,85.11 142.68,84.7 142.68,83.92 143,83.61 143,81.45 142.82,81.27 JDIMM1.42
  BOTTOM w0.14: v2(151.4,130.23) 151.98,130.82 U1.BM1
M_A_DQ12: length 77.7
  TOP w0.102: v2(140.37,82.63) 140.21,82.63 139.96,82.88 139.31,82.88 138.82,82.39 138.82,81.8 138.55,81.54 138.12,81.54 137.9,81.32 JDIMM2.29
  IN03 w0.13: v2(140.37,82.63) 139.94,82.2 139.06,82.2 138.76,82.5 138.76,85.98 138.51,86.23 138.17,86.23 135.76,88.64 135.76,90.53 135.2,91.09 135.2,92.18 135.43,92.41 135.43,93.34 132.33,96.44 132.33,101.43 131.52,102.24 131.52,106.25 132.33,107.06 132.33,112.6 139.11,119.38 139.11,120.65 145.31,126.85 146.25,126.85 150.21,130.81 152.14,130.81 152.44,131.12 152.44,131.13 153.56,132.24 v2(153.76,132.44)
  BOTTOM w0.102: JDIMM1.29 139.57,83.05 139.99,82.63 v2(140.37,82.63)
  BOTTOM w0.14: U1.BK4 v2(153.76,132.44)
M_A_DQ13: length 77.3
  TOP w0.102: JDIMM2.25 136.9,80.55 137.03,80.67 137.46,80.67 137.59,80.8 137.59,81.08 137.46,81.21 137.11,81.21 136.98,81.33 136.98,81.61 137.11,81.74 137.43,81.74 137.56,81.87 137.56,82.48 137.71,82.63 v2(138.34,82.63)
  IN03 w0.13: v2(138.34,82.63) 138.32,82.63 137,83.95 137,85.98 134.69,88.29 134.69,89.94 133.85,90.78 133.85,93.4 130.3,96.96 130.3,110.98 131.22,111.9 131.22,113.02 138.07,119.87 138.07,121.07 145.05,128.04 145.41,128.04 146.53,129.16 147.06,129.16 151.48,133.58 153.25,133.58 v2(153.74,133.09)
  BOTTOM w0.102: JDIMM1.25 138.57,86.61 137.93,85.97 137.93,83.04 v2(138.34,82.63)
  BOTTOM w0.14: U1.BK5 v2(153.74,133.09)
M_A_DQ14: length 78
  TOP w0.102: v2(142.27,82.63) 141.88,82.63 141.65,82.86 141.65,83.11 141.57,83.19 141.37,83.19 141.22,83.04 141.22,81.61 140.66,81.05 140.66,80.65 140.89,80.42 140.9,80.42 JDIMM2.41
  IN03 w0.076: v2(150.05,128.89) 150.05,128.33 147.96,126.24 147.49,126.24
  IN03 w0.13: v2(142.27,82.63) 142.87,82.63 143.07,82.43 143.07,81.11 142.69,80.72 142.33,80.72 142.2,80.85 142.2,81.33 142.08,81.46 141.75,81.46 141.62,81.33 141.62,81.08 141.5,80.95 140.94,80.95 140.81,81.08 140.81,85.78 137.87,88.72 137.87,91.59 137.99,91.72 138.32,91.72 138.45,91.85 138.45,92.11 138.32,92.24 137.99,92.24 137.87,92.37 137.87,93.38 135.02,96.23 135.02,112.89 140.94,118.81 140.94,119.87 146.68,125.61 146.86,125.61 147.49,126.24
  BOTTOM w0.076: v2(150.05,128.89) 151.01,128.89 152.91,130.79 U1.BK1
  BOTTOM w0.102: v2(142.27,82.63) 141.87,83.04 141.87,86.12 142.01,86.26 142.16,86.26 142.57,86.67 JDIMM1.41
M_A_DQ15: length 80.6
  TOP w0.102: JDIMM2.37 139.9,80.5 139.8,80.6 139.41,80.6 139.31,80.7 139.31,80.91 139.41,81.01 139.8,81.01 139.9,81.11 139.9,81.34 140.1,81.54 140.66,81.54 140.88,81.75 140.88,84.78 140.48,85.17 v2(140.37,85.17)
  IN03 w0.13: v2(140.37,85.17) 140.37,85.75 137.51,88.61 137.51,93.23 134.66,96.08 134.66,96.43 134.53,96.56 134.43,96.56 134.3,96.69 134.3,96.95 134.43,97.08 134.53,97.08 134.66,97.21 134.66,97.47 134.53,97.6 134.43,97.6 134.3,97.73 134.3,97.99 134.43,98.12 134.53,98.12 134.66,98.25 134.66,98.5 134.53,98.63 134.43,98.63 134.3,98.76 134.3,99.02 134.43,99.15 134.53,99.15 134.66,99.28 134.66,99.54 134.53,99.67 134.43,99.67 134.3,99.8 134.3,100.06 134.43,100.19 134.53,100.19 134.66,100.32 134.66,100.58 134.53,100.71 134.43,100.71 134.3,100.84 134.3,101.1 134.43,101.23 134.53,101.23 134.66,101.35 134.66,101.61 134.53,101.74 134.43,101.74 134.3,101.87 134.3,102.13 134.43,102.26 134.53,102.26 134.66,102.39 134.66,102.65 134.53,102.78 134.43,102.78 134.3,102.91 134.3,103.17 134.43,103.3 134.53,103.3 134.66,103.43 134.66,103.69 134.53,103.82 134.43,103.82 134.3,103.95 134.3,104.2 134.43,104.33 134.53,104.33 134.66,104.46 134.66,104.72 134.53,104.85 134.43,104.85 134.3,104.98 134.3,105.24 134.43,105.37 134.53,105.37 134.66,105.5 134.66,105.76 134.53,105.89 134.43,105.89 134.3,106.02 134.3,106.28 134.43,106.41 134.53,106.41 134.66,106.54 134.66,106.8 134.53,106.92 134.43,106.92 134.3,107.05 134.3,107.31 134.43,107.44 134.53,107.44 134.66,107.57 134.66,107.83 134.53,107.96 134.43,107.96 134.3,108.09 134.3,108.35 134.43,108.48 134.53,108.48 134.66,108.61 134.66,108.87 134.53,109 134.43,109 134.3,109.13 134.3,109.39 134.43,109.52 134.53,109.52 134.66,109.65 134.66,109.9 134.53,110.03 134.43,110.03 134.3,110.16 134.3,110.42 134.43,110.55 134.53,110.55 134.66,110.68 134.66,110.94 134.53,111.07 134.43,111.07 134.3,111.2 134.3,111.46 134.43,111.59 134.53,111.59 134.66,111.72 134.66,111.98 134.53,112.11 134.43,112.11 134.3,112.24 134.3,112.5 134.43,112.62 134.53,112.62 134.66,112.75 134.66,113.04 140.58,118.96 140.58,119.99 146.48,125.89 146.65,125.89 147.41,126.64 v2(147.8,126.64)
  BOTTOM w0.076: U1.BK2 153.63,131.18 153.63,130.22
  BOTTOM w0.102: JDIMM1.37 141.57,86.62 141.47,86.52 139.97,86.52 139.87,86.43 139.87,86.16 139.98,86.06 141.4,86.06 141.52,85.93 141.52,85.5 141.4,85.37 141.24,85.37 141.01,85.6 140,85.6 139.87,85.48 139.87,85.3 140,85.17 v2(140.37,85.17)
  BOTTOM w0.14: v2(147.8,126.64) 150.05,126.64 150.41,127 153.63,130.22
M_A_DQ16: length 74.2
  TOP w0.102: v2(144.18,84.53) 143.8,84.15 143.33,84.15 143,84.48 143,85.42 143.1,85.52 143.66,85.52 143.76,85.62 143.76,85.82 143.66,85.93 143.1,85.93 143,86.03 143,86.34 143.15,86.49 JDIMM2.50
  IN03 w0.076: 148.25,125.1 152.34,129.18 v2(153.48,129.18)
  IN03 w0.13: v2(144.18,84.53) 144.18,84.5 143.58,83.9 143.3,83.9 143.07,84.13 143.07,84.47 143.2,84.6 143.55,84.6 143.68,84.73 143.68,84.98 143.55,85.11 143.2,85.11 143.07,85.24 143.07,86.12 142.07,87.13 141.59,87.13 139.95,88.77 139.95,93.75 137.56,96.13 137.56,112.8 142.73,117.97 142.73,119.57 148.25,125.1
  BOTTOM w0.076: U1.BG4 154.87,132.77 154.78,132.68 154.78,131.39 154.63,131.24 154.63,130.61 154.98,130.26 154.98,129.91 154.26,129.18
  BOTTOM w0.102: v2(144.18,84.53) 144.42,84.53 144.6,84.36 144.6,83.32 145.23,82.68 145.23,80.8 144.82,80.39 JDIMM1.50
  BOTTOM w0.14: 154.26,129.18 v2(153.48,129.18)
M_A_DQ17: length 74.3
  TOP w0.102: v2(144.18,83.26) 143.25,83.26 142.69,83.82 142.69,86.24 142.15,86.78 JDIMM2.46
  IN03 w0.076: 147.9,125.33 148.19,125.33 152.5,129.63 v2(153.93,129.63)
  IN03 w0.13: v2(144.18,83.26) 143.15,83.26 142.72,83.7 142.72,86.01 141.95,86.77 141.47,86.77 139.61,88.63 139.61,93.58 137.18,96.01 137.18,112.93 142.37,118.12 142.37,119.8 147.9,125.33
  BOTTOM w0.076: U1.BG5 154.48,132.82 154.48,130.54 154.77,130.25 154.77,129.94 154.47,129.63 v2(153.93,129.63)
  BOTTOM w0.102: v2(144.18,83.26) 144.58,82.86 144.58,82.36 144.69,82.26 144.82,82.26 144.93,82.15 144.93,81.95 144.82,81.85 144.69,81.85 144.58,81.75 144.58,81.54 144.69,81.44 144.82,81.44 144.93,81.34 144.93,81.14 144.82,81.04 143.94,81.04 143.82,80.91 JDIMM1.46
M_A_DQ18: length 74.4
  TOP w0.102: v2(146.21,82.38) 146.21,82.5 146.34,82.62 147.03,82.62 147.16,82.5 147.16,81.46 147.03,81.33 146.16,81.33 146.04,81.22 146.04,81.05 146.16,80.93 146.32,80.93 146.44,80.81 146.44,80.64 146.32,80.52 145.75,80.52 145.4,80.17 JDIMM2.59
  IN03 w0.13: v2(156.26,132.44) 155.16,131.35 155.16,129.92 152.11,126.88 152.11,125.5 145.39,118.78 145.39,117.22 140.79,112.61 140.79,102.06 141.37,101.48 141.37,95.73 143.38,93.72 143.38,88.7 143.89,88.19 144.47,88.19 146.66,86 146.66,82.44 147.12,81.97 147.12,81.82 147.01,81.72 146.87,81.72 v2(146.21,82.38)
  BOTTOM w0.102: v2(146.21,82.38) 146.65,82.38 147.66,83.38 147.66,86.19 147.07,86.78 JDIMM1.59
  BOTTOM w0.14: U1.BF4 155.93,132.77 v2(156.26,132.44)
M_A_DQ19: length 75.4
  TOP w0.102: JDIMM2.58 145.15,86.36 145.05,86.27 145.05,84.48 145.21,84.33 145.51,84.33 145.64,84.46 145.64,85.14 145.49,85.3 145.49,85.96 145.76,86.24 146.02,86.24 146.27,85.98 146.27,85.61 v2(146.21,85.55)
  IN03 w0.13: v2(156.26,133.09) 154.81,131.64 154.81,129.95 151.61,126.75 151.61,125.4 145.03,118.83 145.03,117.37 140.41,112.74 140.41,101.37 140.53,101.24 140.86,101.24 140.99,101.12 140.99,100.85 140.86,100.72 140.53,100.72 140.41,100.6 140.41,100.34 140.53,100.21 140.86,100.21 140.99,100.08 140.99,99.82 140.86,99.69 140.53,99.69 140.41,99.56 140.41,99.3 140.53,99.17 140.86,99.17 140.99,99.04 140.99,98.78 140.86,98.65 140.53,98.65 140.41,98.52 140.41,98.26 140.53,98.13 140.86,98.13 140.99,98.01 140.99,97.74 140.86,97.62 140.53,97.62 140.41,97.49 140.41,97.23 140.53,97.1 140.81,97.1 140.94,96.97 140.94,96.71 140.81,96.58 140.53,96.58 140.41,96.45 140.41,96.19 143.02,93.57 143.02,88.57 143.76,87.84 144.35,87.84 146.21,85.98 v2(146.21,85.55)
  BOTTOM w0.102: JDIMM1.58 146.82,80.51 145.7,81.63 145.7,85.08 146.17,85.55 v2(146.21,85.55)
  BOTTOM w0.14: U1.BF5 155.93,133.42 v2(156.26,133.09)
M_A_DQ20: length 77
  TOP w0.102: v2(144.18,85.8) 144.46,85.8 144.58,85.68 144.58,81.83 144.33,81.57 143.62,81.57 142.9,80.85 JDIMM2.49
  IN03 w0.076: 149.47,125.84 149.47,126.03 151.73,128.29 v2(152.58,128.29)
  IN03 w0.13: v2(144.18,85.8) 143.95,85.58 143.63,85.58 143.43,85.78 143.43,86.24 142.21,87.46 141.72,87.46 140.79,88.39 140.79,90.58 140.68,90.69 140.41,90.69 140.28,90.81 140.28,91.08 140.41,91.2 140.63,91.2 140.76,91.33 140.76,91.59 140.63,91.72 140.41,91.72 140.28,91.85 140.28,92.24 140.41,92.37 140.66,92.37 140.79,92.5 140.79,93.41 137.92,96.28 137.92,100.46 138.17,100.7 138.17,100.97 137.92,101.22 137.92,101.48 138.17,101.73 138.17,102 137.92,102.25 137.92,102.5 138.17,102.75 138.17,103.02 137.92,103.27 137.92,103.53 138.14,103.75 138.14,104.05 137.92,104.27 137.92,104.56 138.14,104.79 138.14,105.08 137.92,105.31 137.92,105.6 138.14,105.83 138.14,106.12 137.92,106.34 137.92,106.64 138.14,106.86 138.14,107.15 137.92,107.38 137.92,107.67 138.14,107.9 138.14,108.19 137.92,108.42 137.92,108.71 138.14,108.93 138.14,109.23 137.92,109.45 137.92,109.74 138.14,109.97 138.14,110.26 137.92,110.49 137.92,110.78 138.14,111.01 138.14,111.3 137.92,111.53 137.92,111.82 138.14,112.04 138.14,112.88 143.09,117.82 143.09,119.45 149.47,125.84
  BOTTOM w0.076: U1.BG2 155.07,131.21 154.78,130.92 154.78,130.68 155.19,130.27 155.19,129.83 154.21,128.85 153.74,128.85
  BOTTOM w0.102: v2(144.18,85.8) 144.36,85.98 144.49,85.98 144.62,85.86 144.62,84.89 144.9,84.61 144.9,83.59 145.03,83.47 145.28,83.47 145.38,83.57 145.38,84.59 145.11,84.86 145.11,85.82 144.57,86.37 JDIMM1.49
  BOTTOM w0.14: 153.74,128.85 153.17,128.29 v2(152.58,128.29)
M_A_DQ21: length 74
  TOP w0.102: JDIMM2.45 141.9,81.26 142.08,81.44 142.39,81.44 142.84,81.89 142.84,82.75 143.02,82.93 143.36,82.93 143.67,82.63 v2(144.18,82.63)
  IN03 w0.076: v2(152.13,127.84) 151.57,127.84 149.85,126.12 149.85,125.76
  IN03 w0.13: 149.85,125.76 143.45,119.35 143.45,117.67 138.53,112.75 138.53,96.18 141.12,93.59 141.12,88.53 141.86,87.79 142.35,87.79 143.91,86.23 144.35,86.23 144.65,85.93 144.65,81.61 144.42,81.39 143.91,81.39 143.61,81.69 143.61,82.3 143.94,82.63 v2(144.18,82.63)
  BOTTOM w0.076: U1.BG1 155.07,130.6 155.39,130.29 155.39,129.78 154.18,128.56 153.85,128.56
  BOTTOM w0.102: JDIMM1.45 143.57,86.75 143.22,86.41 143.22,85.27 143.77,84.72 143.77,83.04 v2(144.18,82.63)
  BOTTOM w0.14: 153.85,128.56 153.13,127.84 v2(152.13,127.84)
M_A_DQ22: length 74
  TOP w0.102: v2(148.37,83.65) 147.16,83.65 146.62,84.19 146.62,86.07 146.15,86.53 JDIMM2.62
  IN03 w0.13: v2(148.37,83.65) 147.67,83.65 147.32,84 147.32,86.28 144.6,89 144.6,90.54 144.47,90.67 144.2,90.67 144.07,90.8 144.07,91.06 144.2,91.19 144.47,91.19 144.6,91.32 144.6,91.58 144.47,91.71 144.2,91.71 144.07,91.84 144.07,92.1 144.2,92.23 144.44,92.23 144.6,92.38 144.6,93.52 142.13,95.98 142.13,102.52 142,102.65 141.73,102.65 141.6,102.78 141.6,103.04 141.73,103.17 142,103.17 142.13,103.3 142.13,103.55 142,103.68 141.68,103.68 141.55,103.81 141.55,104.07 141.68,104.2 142,104.2 142.13,104.33 142.13,104.59 142,104.72 141.68,104.72 141.55,104.85 141.55,105.11 141.68,105.24 142,105.24 142.13,105.37 142.13,105.63 142,105.75 141.68,105.75 141.55,105.88 141.55,106.14 141.68,106.27 142,106.27 142.13,106.4 142.13,106.66 142,106.79 141.68,106.79 141.55,106.92 141.55,107.18 141.68,107.31 142,107.31 142.13,107.44 142.13,107.7 142,107.83 141.68,107.83 141.55,107.96 141.55,108.22 141.68,108.35 142,108.35 142.13,108.48 142.13,112.94 146.11,116.92 146.11,118.69 153,125.58 153,126.93 155.8,129.72 155.8,130.03 v2(156.26,130.49)
  BOTTOM w0.076: U1.BF1 155.93,130.82 v2(156.26,130.49)
  BOTTOM w0.102: v2(148.37,83.65) 148.77,83.24 148.77,82.21 148.46,81.89 147.74,81.89 147.47,81.61 147.47,81.21 147.82,80.86 JDIMM1.62
M_A_DQ23: length 73.5
  TOP w0.102: v2(148.37,82.38) 148.13,82.38 147.97,82.53 147.97,82.91 147.85,83.04 147.59,83.04 147.47,82.91 147.47,81.23 146.4,80.17 JDIMM2.63
  IN03 w0.13: v2(156.26,131.14) 155.49,130.38 155.49,129.85 152.62,126.98 152.62,125.61 145.75,118.73 145.75,117.07 141.17,112.49 141.17,111.56 141.3,111.43 141.52,111.43 141.65,111.3 141.65,111.04 141.52,110.91 141.3,110.91 141.17,110.78 141.17,110.52 141.3,110.39 141.52,110.39 141.65,110.26 141.65,110 141.52,109.87 141.3,109.87 141.17,109.74 141.17,109.48 141.3,109.36 141.55,109.36 141.68,109.23 141.68,108.96 141.55,108.84 141.3,108.84 141.17,108.71 141.17,102.47 141.75,101.88 141.75,95.86 143.73,93.88 143.73,88.83 144.01,88.55 144.58,88.55 146.99,86.14 146.99,83.64 147.39,83.24 147.67,83.24 147.8,83.11 147.8,82.93 147.67,82.81 147.19,82.81 147.06,82.68 147.06,82.5 147.19,82.38 v2(148.37,82.38)
  BOTTOM w0.076: U1.BF2 155.93,131.47 v2(156.26,131.14)
  BOTTOM w0.102: v2(148.37,82.38) 147.96,82.78 147.96,86.16 148.07,86.27 JDIMM1.63
M_A_DQ24: length 74.5
  TOP w0.102: JDIMM2.66 147.15,86.6 147.48,86.27 148.05,86.27 148.17,86.15 148.17,85.93 148.05,85.8 147.47,85.8 147.35,85.69 147.35,84.53 147.48,84.41 147.73,84.41 147.86,84.53 147.86,85.04 147.99,85.16 148.24,85.16 148.37,85.04 v2(148.37,84.92)
  IN03 w0.13: v2(154.91,127.87) 154.35,127.87 153.61,127.14 153.61,125.56 146.87,118.81 146.87,116.6 142.92,112.65 142.92,100.43 143.05,100.3 143.53,100.3 143.65,100.17 143.65,99.91 143.53,99.78 143.05,99.78 142.92,99.65 142.92,99.39 143.05,99.26 143.53,99.26 143.65,99.13 143.65,98.87 143.53,98.74 143.05,98.74 142.92,98.61 142.92,98.35 143.05,98.23 143.53,98.23 143.65,98.1 143.65,97.83 143.53,97.71 143.05,97.71 142.92,97.58 142.92,97.32 143.05,97.19 143.53,97.19 143.65,97.06 143.65,96.8 143.53,96.67 143.05,96.67 142.92,96.54 142.92,96.22 145.46,93.68 145.46,92.48 145.84,92.1 145.84,90.34 145.43,89.93 145.43,88.69 145.9,88.23 146.06,88.23 148.28,86.01 148.6,86.01 148.84,85.77 148.84,85.12 148.63,84.92 v2(148.37,84.92)
  BOTTOM w0.076: U1.BD2 157.59,131.23 157.3,130.94 157.3,130.49 157.37,130.41 157.37,129.16 156.72,128.51 156.13,128.51 155.49,127.87 v2(154.91,127.87)
  BOTTOM w0.102: JDIMM1.66 148.82,80.15 149.17,80.5 149.17,81.82 149.56,82.21 149.56,83.72 v2(148.37,84.92)
M_A_DQ25: length 74.7
  TOP w0.102: v2(150.27,82.38) 149.47,82.38 148.77,83.07 148.77,85.98 148.15,86.6 JDIMM2.70
  IN03 w0.13: v2(154.46,127.42) 154.46,125.97 147.23,118.74 147.23,116.45 143.3,112.53 143.3,101.07 144.01,100.36 144.01,95.63 145.79,93.86 145.79,92.62 146.17,92.23 146.17,90.2 145.76,89.79 145.76,88.83 146.04,88.56 146.2,88.56 148.39,86.36 148.71,86.36 149.26,85.82 149.26,82.16 150.11,81.31 150.44,81.31 150.78,81.65 150.78,81.87 v2(150.27,82.38)
  BOTTOM w0.076: v2(154.46,127.42) 155.57,127.42 156.44,128.29 157.01,128.29 157.59,128.87 U1.BD1
  BOTTOM w0.102: JDIMM1.70 149.82,80.25 149.69,80.37 149.6,80.37 149.47,80.5 149.47,81.69 149.58,81.8 149.74,81.8 149.85,81.69 149.85,80.77 149.97,80.65 150.14,80.65 150.26,80.77 150.26,81.26 150.34,81.33 150.44,81.33 150.68,81.57 150.68,82.16 150.46,82.38 v2(150.27,82.38)
M_A_DQ26: length 73.1
  TOP w0.102: JDIMM2.80 150.65,86.78 151.16,86.27 151.16,84.01 152.17,83.01 v2(152.18,83.01)
  IN03 w0.13: v2(152.18,83.01) 151.91,83.01 151.76,83.16 151.76,86.11 149.83,88.04 149.83,89.13 149.7,89.26 149.3,89.26 149.17,89.39 149.17,89.65 149.3,89.78 149.7,89.78 149.83,89.91 149.83,92.54 149.57,92.79 149.57,93.04 149.83,93.3 149.83,93.53 149.63,93.72 149.45,93.72 149.09,93.36 148.9,93.36 148.72,93.54 148.72,93.73 149.08,94.09 149.08,94.27 147.49,95.86 147.49,96.33 147.36,96.45 147.17,96.45 147.04,96.58 147.04,96.84 147.17,96.97 147.36,96.97 147.49,97.1 147.49,97.36 147.36,97.49 147.17,97.49 147.04,97.62 147.04,97.88 147.17,98.01 147.36,98.01 147.49,98.14 147.49,98.4 147.36,98.53 147.17,98.53 147.04,98.66 147.04,98.92 147.17,99.05 147.36,99.05 147.49,99.18 147.49,99.43 147.36,99.56 147.17,99.56 147.04,99.69 147.04,99.95 147.17,100.08 147.36,100.08 147.49,100.21 147.49,100.53 147.36,100.66 147.19,100.66 147.06,100.79 147.06,101.04 147.19,101.17 147.36,101.17 147.49,101.3 147.49,103.51 147.42,103.58 147.29,103.58 147.16,103.71 147.16,103.89 147.34,104.07 147.34,104.3 147.16,104.47 147.16,113.16 149.89,115.89 149.89,118.28 157.58,125.96 157.58,131.24 v2(158.77,132.44)
  BOTTOM w0.102: v2(152.18,83.01) 152.29,83.01 152.78,82.53 152.78,81.72 152.22,81.16 151.78,81.16 151.68,81.06 151.68,80.85 151.78,80.75 152.22,80.75 152.32,80.65 JDIMM1.80
  BOTTOM w0.14: U1.BC4 158.45,132.77 v2(158.77,132.44)
M_A_DQ27: length 74
  TOP w0.102: JDIMM2.79 150.4,80.43 151.02,81.05 151.02,82.91 151.2,83.09 151.58,83.09 151.76,82.91 151.76,81.94 151.96,81.74 v2(152.18,81.74)
  IN03 w0.13: v2(158.77,133.09) 158.77,133.08 157.09,131.4 157.09,125.96 149.53,118.4 149.53,116.04 146.68,113.19 146.68,103.34 146.81,103.21 146.98,103.21 147.11,103.08 147.11,102.82 146.98,102.69 146.81,102.69 146.68,102.56 146.68,102.3 146.81,102.17 146.98,102.17 147.11,102.04 147.11,101.78 146.98,101.65 146.81,101.65 146.68,101.52 146.68,96.17 148.39,94.46 148.39,93.37 149.37,92.38 149.37,90.53 148.81,89.97 148.81,88.83 148.94,88.7 149.22,88.7 149.35,88.57 149.35,88.05 151.43,85.98 151.43,81.61 151.55,81.49 152.05,81.49 152.18,81.61 v2(152.18,81.74)
  BOTTOM w0.102: JDIMM1.79 152.07,86.04 151.77,85.74 151.77,82.15 v2(152.18,81.74)
  BOTTOM w0.14: U1.BC5 158.45,133.42 v2(158.77,133.09)
M_A_DQ28: length 76.2
  TOP w0.102: v2(150.27,85.55) 150.46,85.55 150.7,85.32 150.7,81.32 149.93,80.55 148.78,80.55 148.4,80.17 JDIMM2.71
  IN03 w0.13: v2(150.27,85.55) 150.27,85.74 148.99,87.03 148.67,87.03 146.96,88.74 146.96,93.75 144.77,95.94 144.77,102.54 144.49,102.82 144.17,102.82 144.04,102.95 144.04,103.46 144.17,103.58 144.37,103.58 144.49,103.71 144.49,104.23 144.37,104.36 144.25,104.36 144.06,104.55 144.06,108.64 144.77,109.35 144.77,109.58 144.64,109.71 144.29,109.71 144.16,109.84 144.16,110.1 144.29,110.23 144.64,110.23 144.77,110.36 144.77,110.62 144.64,110.75 144.29,110.75 144.16,110.88 144.16,111.14 144.29,111.27 144.64,111.27 144.77,111.4 144.77,111.65 144.64,111.78 144.29,111.78 144.16,111.91 144.16,112.17 144.29,112.3 144.64,112.3 144.77,112.43 144.77,112.98 147.95,116.16 147.95,118.67 155.21,125.93 155.21,127.06 156.56,128.41 156.56,128.92 v2(156.26,129.22)
  BOTTOM w0.076: U1.BD5 157.07,132.9 157.07,131.55 156.99,131.47 156.99,129.95 v2(156.26,129.22)
  BOTTOM w0.102: v2(150.27,85.55) 150.29,85.55 150.97,84.86 150.97,84.51 151.1,84.38 151.3,84.38 151.43,84.51 151.43,85.86 151.68,86.11 151.68,86.34 151.53,86.49 150.87,86.49 150.44,86.06 149.64,86.06 149.51,86.19 149.51,86.36 149.64,86.49 149.94,86.49 150.07,86.62 JDIMM1.71
M_A_DQ29: length 74.3
  TOP w0.102: JDIMM2.67 147.4,80.2 148.19,80.99 148.52,80.99 148.77,81.25 148.77,82.1 148.9,82.22 149.19,82.22 149.4,82.02 149.4,81.32 149.52,81.19 150.15,81.19 150.27,81.32 v2(150.27,81.74)
  IN03 w0.13: v2(150.27,81.74) 150.15,81.74 149.64,82.25 149.64,85.91 148.85,86.7 148.53,86.7 146.63,88.6 146.63,93.55 144.39,95.79 144.39,101.04 144.27,101.17 143.81,101.17 143.68,101.3 143.68,101.73 143.81,101.86 144.29,101.86 144.42,101.99 144.42,102.26 144.29,102.38 143.81,102.38 143.68,102.51 143.68,112.4 147.59,116.31 147.59,118.69 154.86,125.96 154.86,127.19 155.81,128.14 v2(155.81,128.77)
  BOTTOM w0.076: U1.BD4 157.3,132.47 157.3,131.26 157.14,131.11 157.14,129.44 156.47,128.77 v2(155.81,128.77)
  BOTTOM w0.102: v2(150.27,81.74) 150.26,81.74 149.87,82.13 149.87,84.89 149.07,85.69 JDIMM1.67
M_A_DQ30: length 75.2
  TOP w0.102: JDIMM2.83 151.4,80.34 152.69,81.63 152.69,85.04 v2(152.18,85.55)
  IN03 w0.13: v2(152.18,85.55) 152.18,86.16 150.34,88.01 150.34,88.45 150.69,88.81 150.69,89.91 150.57,90.03 150.29,90.03 150.17,90.16 150.17,90.38 150.29,90.5 150.67,90.5 150.79,90.63 150.79,90.86 150.67,90.99 150.29,90.99 150.16,91.11 150.16,91.32 150.29,91.44 150.67,91.44 150.79,91.57 150.79,91.77 150.67,91.9 150.29,91.9 150.16,92.03 150.16,92.24 150.29,92.37 150.67,92.37 150.79,92.5 150.79,93.07 147.87,95.99 147.87,96.35 148,96.47 148.28,96.47 148.41,96.6 148.41,96.8 148.28,96.93 148,96.93 147.87,97.06 147.87,97.3 148,97.43 148.3,97.43 148.43,97.56 148.43,97.82 148.3,97.95 148,97.95 147.87,98.08 147.87,98.34 148,98.47 148.3,98.47 148.43,98.6 148.43,98.86 148.3,98.99 148,98.99 147.87,99.12 147.87,99.38 148,99.51 148.3,99.51 148.43,99.63 148.43,99.89 148.3,100.02 148,100.02 147.87,100.15 147.87,100.41 148,100.54 148.3,100.54 148.43,100.67 148.43,100.93 148.3,101.06 148,101.06 147.87,101.19 147.87,101.45 148,101.58 148.3,101.58 148.43,101.71 148.43,101.97 148.3,102.1 148,102.1 147.87,102.23 147.87,102.48 148,102.61 148.3,102.61 148.43,102.74 148.43,103 148.3,103.13 148,103.13 147.87,103.26 147.87,103.52 148.06,103.71 148.18,103.71 148.3,103.84 148.3,104.17 148.18,104.3 147.87,104.3 147.64,104.53 147.64,113.14 150.25,115.74 150.25,118.13 158.06,125.94 158.06,129.78 v2(158.77,130.49)
  BOTTOM w0.102: v2(152.18,85.55) 152.18,85.53 152.74,84.97 153.74,84.97 153.87,85.09 153.87,85.27 153.74,85.4 152.95,85.4 152.83,85.52 152.83,85.7 152.95,85.83 153.74,85.83 153.87,85.96 153.87,86.16 153.74,86.29 153.2,86.29 153.08,86.41 153.08,87.57 JDIMM1.83
  BOTTOM w0.14: v2(158.77,130.49) 158.45,130.82 U1.BC1
M_A_DQ31: length 73.2
  TOP w0.102: JDIMM2.84 151.65,86.54 151.66,86.54 151.86,86.34 152.6,86.34 152.72,86.21 152.72,86.08 152.62,85.98 151.8,85.98 151.65,85.83 151.65,84.72 152.09,84.28 v2(152.18,84.28)
  IN03 w0.13: v2(152.18,84.28) 152.47,84.28 152.6,84.41 152.6,86.21 151.13,87.69 151.13,93.24 148.79,95.58 148.79,104.77 148.66,104.9 148.23,104.9 148.1,105.02 148.1,105.29 148.23,105.42 148.66,105.42 148.79,105.54 148.79,105.8 148.66,105.93 148.23,105.93 148.1,106.06 148.1,106.32 148.23,106.45 148.66,106.45 148.79,106.58 148.79,106.84 148.66,106.97 148.23,106.97 148.1,107.1 148.1,107.36 148.23,107.49 148.66,107.49 148.79,107.62 148.79,107.88 148.66,108.01 148.23,108.01 148.1,108.13 148.1,108.4 148.23,108.52 148.66,108.52 148.79,108.65 148.79,108.91 148.66,109.04 148.23,109.04 148.1,109.17 148.1,109.43 148.23,109.56 148.66,109.56 148.79,109.69 148.79,109.95 148.66,110.08 148.23,110.08 148.1,110.21 148.1,110.47 148.23,110.6 148.66,110.6 148.79,110.73 148.79,110.99 148.66,111.12 148.23,111.12 148.1,111.24 148.1,111.51 148.23,111.63 148.66,111.63 148.79,111.76 148.79,112.02 148.66,112.15 148.23,112.15 148.1,112.28 148.1,112.54 148.23,112.67 148.66,112.67 148.79,112.8 148.79,113.77 150.61,115.59 150.61,117.98 158.62,125.99 158.62,129.14 159.26,129.78 159.26,130.65 v2(158.77,131.14)
  BOTTOM w0.102: JDIMM1.84 153.32,80.47 153.13,80.66 153.13,83.33 v2(152.18,84.28)
  BOTTOM w0.14: U1.BC2 158.45,131.47 v2(158.77,131.14)
M_A_DQ32: length 72.1
  TOP w0.102: JDIMM2.174 176.15,86.64 176.28,86.51 176.63,86.51 177.44,85.71 178.33,85.71 178.83,85.2 178.83,82.99 179.69,82.12 v2(179.74,82.12)
  IN03 w0.13: v2(179.74,82.12) 178.71,82.12 178.51,82.32 178.51,94.27 181.17,96.94 181.17,110.54 181.32,110.7 181.32,116.44 181.23,116.53 180.79,116.53 180.66,116.66 180.66,116.92 180.79,117.05 181.15,117.05 181.27,117.17 181.27,117.44 181.15,117.56 180.77,117.56 180.64,117.69 180.64,117.96 180.77,118.08 181.15,118.08 181.27,118.21 181.27,118.47 181.15,118.6 180.77,118.6 180.64,118.73 180.64,118.99 180.77,119.12 181.04,119.12 181.17,119.25 181.17,119.67 174.75,126.09 v2(174.75,127.28)
  BOTTOM w0.076: U1.AB1 175.28,130.73 175.28,129.34 175.03,129.09 175.03,127.56 v2(174.75,127.28)
  BOTTOM w0.102: JDIMM1.174 177.82,80.38 177.96,80.52 178.2,80.52 178.3,80.62 178.3,81.44 178.4,81.54 178.61,81.54 178.71,81.44 178.71,80.62 178.81,80.52 178.94,80.52 179.07,80.65 179.07,80.76 179.17,80.86 179.31,80.86 179.43,80.98 179.43,81.14 179.31,81.26 179.31,81.5 179.22,81.59 179.07,81.59 178.66,82 178.66,82.23 178.79,82.36 179.61,82.36 179.74,82.23 v2(179.74,82.12)
M_A_DQ33: length 72
  TOP w0.102: v2(178.09,84.92) 177.38,84.2 177.38,81.65 176.68,80.95 175.69,80.95 174.9,80.17 JDIMM2.169
  IN03 w0.076: v2(174.3,127.73) 174.3,126.91 174.51,126.7 174.51,125.99
  IN03 w0.13: v2(178.09,84.92) 178.09,88.39 177.67,88.81 177.67,90.66 177.79,90.78 178.05,90.78 178.17,90.91 178.17,91.21 178.05,91.34 177.82,91.34 177.69,91.47 177.69,91.75 177.82,91.88 178.05,91.88 178.17,92 178.17,92.24 178.05,92.37 177.79,92.37 177.67,92.5 177.67,93.94 180.79,97.07 180.79,110.37 180.36,110.8 180.36,111.31 180.49,111.44 180.84,111.44 180.97,111.57 180.97,111.83 180.84,111.96 180.49,111.96 180.36,112.09 180.36,112.35 180.49,112.48 180.84,112.48 180.97,112.6 180.97,112.86 180.84,112.99 180.49,112.99 180.36,113.12 180.36,113.38 180.49,113.51 180.84,113.51 180.97,113.64 180.97,113.9 180.84,114.03 180.49,114.03 180.36,114.16 180.36,114.42 180.49,114.55 180.84,114.55 180.97,114.68 180.97,114.94 180.84,115.07 180.49,115.07 180.36,115.2 180.36,115.45 180.49,115.58 180.84,115.58 180.97,115.71 180.97,115.97 180.84,116.1 180.49,116.1 180.26,116.33 180.26,120.24 174.51,125.99
  BOTTOM w0.076: U1.AB2 174.91,131.19 174.91,130.7 175.08,130.54 175.08,129.52 174.73,129.17 174.73,128.16 v2(174.3,127.73)
  BOTTOM w0.102: v2(178.09,84.92) 178.09,84.77 177.54,84.22 176.95,84.22 176.84,84.33 176.84,84.47 176.95,84.58 177.47,84.58 177.59,84.7 177.59,84.87 177.47,84.98 177.01,84.98 176.88,85.11 176.88,85.91 176.69,86.1 176.01,86.1 175.89,86.22 175.89,86.39 176.01,86.51 176.42,86.51 176.57,86.66 JDIMM1.169
M_A_DQ34: length 70
  TOP w0.102: v2(181.39,82.38) 181.39,82.18 180.16,80.95 179.46,80.95 179.35,80.84 179.35,80.59 179.23,80.47 179.07,80.47 178.95,80.59 178.95,80.84 178.85,80.95 178.62,80.95 178.4,80.73 JDIMM2.183
  IN03 w0.076: v2(176.37,132.44) 175.79,131.86 175.79,131.02 175.3,130.53 175.3,127.55 179.33,123.52 179.5,123.52
  IN03 w0.13: v2(181.39,82.38) 180.89,82.38 180.64,82.63 180.64,83.15 180.51,83.28 180.31,83.28 180.18,83.41 180.18,83.67 180.31,83.8 180.51,83.8 180.64,83.93 180.64,84.19 180.51,84.32 180.31,84.32 180.18,84.45 180.18,84.71 180.31,84.84 180.51,84.84 180.64,84.97 180.64,94.01 183.43,96.81 183.43,108.72 184.07,109.35 184.07,119.54 182.75,120.86 182.16,120.86 179.5,123.52
  BOTTOM w0.076: v2(176.37,132.44) 176.05,132.77 U1.AA4
  BOTTOM w0.102: v2(181.39,82.38) 181.25,82.38 180.51,83.12 180.51,85.73 180.07,86.17 JDIMM1.183
M_A_DQ35: length 70.6
  TOP w0.102: JDIMM2.182 178.21,87.52 178.21,86.6 178.11,86.51 177.48,86.51 177.39,86.42 177.39,86.19 177.52,86.06 178.43,86.06 178.59,85.9 178.72,85.9 178.99,86.17 179.17,86.17 179.43,85.9 179.43,85.73 179.14,85.43 179.14,85.09 179.23,84.99 179.5,84.99 179.74,85.23 v2(179.74,85.3)
  IN03 w0.076: v2(176.37,133.09) 175.48,132.2 175.48,131.12 175.03,130.66 175.03,127.56 179.12,123.47
  IN03 w0.13: v2(179.74,85.3) 180.13,85.3 180.3,85.47 180.3,86.73 180.17,86.86 179.85,86.86 179.72,86.99 179.72,87.25 179.85,87.38 180.17,87.38 180.3,87.51 180.3,87.76 180.17,87.89 179.85,87.89 179.72,88.02 179.72,88.28 179.85,88.41 180.17,88.41 180.3,88.54 180.3,90.27 180.17,90.4 179.85,90.4 179.72,90.53 179.72,90.79 179.85,90.92 180.17,90.92 180.3,91.05 180.3,91.31 180.17,91.44 179.85,91.44 179.72,91.57 179.72,91.83 179.85,91.96 180.17,91.96 180.3,92.09 180.3,94.18 183.05,96.93 183.05,109.07 183.66,109.68 183.66,119.46 182.57,120.55 182.04,120.55 179.12,123.47
  BOTTOM w0.076: v2(176.37,133.09) 176.05,133.42 U1.AA5
  BOTTOM w0.102: v2(179.74,85.3) 180.16,84.87 180.16,81.66 179.82,81.31 JDIMM1.182
M_A_DQ36: length 72.9
  TOP w0.102: v2(178.09,82.07) 178.51,82.5 178.51,85.08 178.22,85.37 177.34,85.37 176.61,86.1 175.8,86.1 175.15,86.75 JDIMM2.170
  IN03 w0.076: v2(174.3,129.63) 173.65,128.99 173.65,127.49 173.88,127.26 173.88,125.93 174.23,125.58
  IN03 w0.13: v2(178.09,82.07) 177.62,82.53 177.62,83.56 177.33,83.85 177.33,87.99 177,88.33 177,94.29 179.54,96.83 179.54,101.78 179.67,101.91 179.93,101.91 180.05,102.03 180.05,102.3 179.93,102.42 179.67,102.42 179.54,102.55 179.54,120.27 174.23,125.58
  BOTTOM w0.076: v2(174.3,129.63) 174.3,129.63 174.72,130.05 174.72,130.44 174.61,130.55 174.61,132.83 U1.AB5
  BOTTOM w0.102: v2(178.09,82.07) 178.07,82.07 177.57,82.57 177.57,83.64 177.44,83.77 177.22,83.77 177.09,83.64 177.09,81.31 176.72,80.94 176.15,80.94 176.03,80.82 176.03,80.65 176.15,80.53 176.72,80.53 176.82,80.43 JDIMM1.170
M_A_DQ37: length 70.9
  TOP w0.102: v2(178.09,84.15) 177.68,83.75 177.68,81.52 176.8,80.65 176.11,80.65 175.9,80.45 JDIMM2.173
  IN03 w0.076: 174.26,125.9 174.09,126.07 174.09,127.31 173.86,127.54 173.86,128.55 v2(174.3,129)
  IN03 w0.13: 174.26,125.9 179.9,120.25 179.9,110.29 180.03,110.16 180.28,110.16 180.41,110.03 180.41,109.77 180.28,109.64 180.03,109.64 179.9,109.51 179.9,109.26 180.03,109.13 180.28,109.13 180.41,109 180.41,108.74 180.28,108.61 180.03,108.61 179.9,108.48 179.9,108.22 180.03,108.09 180.28,108.09 180.41,107.96 180.41,107.7 180.28,107.57 180.03,107.57 179.9,107.44 179.9,107.18 180.03,107.05 180.28,107.05 180.41,106.92 180.41,106.67 180.28,106.54 180.03,106.54 179.9,106.41 179.9,106.15 180.03,106.02 180.28,106.02 180.41,105.89 180.41,105.63 180.29,105.51 180.28,105.5 180.03,105.5 179.9,105.37 179.9,105.11 180.03,104.98 180.28,104.98 180.41,104.85 180.41,104.59 180.28,104.46 180.03,104.46 179.9,104.33 179.9,104.07 180.03,103.94 180.28,103.94 180.41,103.82 180.41,103.56 180.28,103.43 180.03,103.43 179.9,103.3 179.9,103.04 180.03,102.91 180.28,102.91 180.41,102.78 180.41,97.19 177.33,94.11 177.33,88.58 177.67,88.24 177.67,84.74 178.09,84.32 v2(178.09,84.15)
  BOTTOM w0.076: U1.AB4 174.92,132.5 174.92,131.66 174.76,131.49 174.76,130.64 174.88,130.52 174.88,129.67 174.3,129.1 v2(174.3,129)
  BOTTOM w0.102: v2(178.09,84.15) 178.2,84.15 178.51,84.46 178.51,85.07 178.23,85.35 178.02,85.35 177.87,85.5 177.87,85.73 177.79,85.8 177.64,85.8 177.57,85.73 177.57,85.42 177.46,85.32 177.39,85.32 177.38,85.32 177.31,85.32 177.18,85.44 177.18,86.03 176.96,86.26 176.96,86.39 177.03,86.47 177.46,86.47 177.57,86.57 JDIMM1.173
M_A_DQ38: length 70
  TOP w0.102: JDIMM2.187 179.4,80.2 179.66,80.46 180.1,80.46 181.81,82.17 181.81,83.22 v3(181.39,83.65)
  IN03 w0.076: v2(176.37,131.16) 175.56,130.34 175.56,127.59 179.37,123.78 179.62,123.78
  IN03 w0.13: 179.62,123.78 182.26,121.14 182.98,121.14 184.45,119.66 184.45,107.82 184.27,107.64 183.94,107.64 183.81,107.51 183.81,107.25 183.94,107.12 184.27,107.12 184.4,106.99 184.4,106.73 184.27,106.6 183.94,106.6 183.81,106.47 183.81,106.21 183.94,106.09 184.27,106.09 184.4,105.96 184.4,105.7 184.27,105.57 183.94,105.57 183.81,105.44 183.81,105.18 183.94,105.05 184.27,105.05 184.4,104.92 184.4,104.66 184.27,104.53 183.92,104.53 183.79,104.4 183.79,104.14 183.92,104.02 184.27,104.02 184.4,103.89 184.4,103.48 183.81,102.9 183.81,96.68 180.97,93.84 180.97,91.02 181.1,90.89 181.35,90.89 181.48,90.76 181.48,90.5 181.35,90.37 181.1,90.37 180.97,90.24 180.97,83.95 181.27,83.65 v3(181.39,83.65)
  BOTTOM w0.076: U1.AA2 176.05,131.47 176.25,131.27 v2(176.37,131.16)
  BOTTOM w0.102: v3(181.39,83.65) 181.39,83.55 181.26,83.42 180.98,83.42 180.85,83.55 180.85,85.24 180.98,85.37 181.47,85.37 181.6,85.49 181.6,85.91 181.47,86.04 181.3,86.04 181.07,86.27 JDIMM1.187
M_A_DQ39: length 70.2
  TOP w0.102: v2(181.39,84.91) 181.08,84.91 180.98,84.8 180.98,84.43 180.85,84.31 180.33,84.31 180.2,84.43 180.2,84.73 180.3,84.83 180.41,84.83 180.51,84.93 180.51,85.14 180.41,85.24 180.3,85.24 180.2,85.34 180.2,85.57 179.15,86.62 JDIMM2.186
  IN03 w0.076: v2(176.37,130.52) 175.79,129.94 175.79,127.68 179.41,124.06 179.72,124.06
  IN03 w0.13: 179.72,124.06 182.32,121.47 183.2,121.47 184.88,119.79 184.88,102.8 184.75,102.67 184.5,102.67 184.37,102.54 184.37,102.28 184.5,102.15 184.75,102.15 184.88,102.02 184.88,101.76 184.75,101.64 184.3,101.64 184.23,101.57 184.17,101.51 184.17,101.24 184.3,101.12 184.75,101.12 184.88,100.99 184.88,100.73 184.75,100.6 184.3,100.6 184.17,100.47 184.17,100.21 184.3,100.08 184.75,100.08 184.88,99.95 184.88,99.69 184.75,99.56 184.3,99.56 184.17,99.44 184.17,99.18 184.3,99.05 184.73,99.05 184.86,98.92 184.86,98.66 184.73,98.53 184.3,98.53 184.17,98.4 184.17,98.15 184.3,98.02 184.7,98.02 184.83,97.89 184.83,97.63 184.7,97.5 184.3,97.5 184.17,97.37 184.17,96.53 181.81,94.17 181.81,92.05 181.68,91.92 181.43,91.92 181.3,91.8 181.3,91.53 181.43,91.41 181.68,91.41 181.81,91.28 181.81,88.81 181.3,88.3 181.3,84.99 v2(181.39,84.91)
  BOTTOM w0.076: v2(176.37,130.52) 176.05,130.82 U1.AA1
  BOTTOM w0.102: JDIMM1.186 180.82,81.23 181.79,82.21 181.79,84.45 181.39,84.86 v2(181.39,84.91)
M_A_DQ40: length 72.6
  TOP w0.102: JDIMM2.190 180.15,86.72 182.56,84.31 182.56,83.11 v2(183.29,82.38)
  IN03 w0.076: v2(176.37,129.25) 176,128.88 176,127.71 179.4,124.32 179.8,124.32
  IN03 w0.13: v2(183.29,82.38) 183.29,82.17 183.17,82.05 182.33,82.05 182.21,82.17 182.21,93.52 185.67,96.98 185.67,119.51 183.46,121.72 182.43,121.72 179.83,124.32 179.8,124.32
  BOTTOM w0.076: U1.V5 177.09,132.8 177.09,129.97 v2(176.37,129.25)
  BOTTOM w0.102: JDIMM1.190 181.82,80.17 182.14,80.5 182.6,80.5 182.72,80.62 182.72,80.8 182.59,80.93 182.39,80.93 182.26,81.05 182.26,81.28 182.39,81.41 182.8,81.41 182.92,81.54 182.92,81.74 182.8,81.87 182.66,81.87 182.53,81.99 182.53,82.88 182.64,82.99 182.78,82.99 182.89,82.88 182.89,82.5 183.01,82.38 v2(183.29,82.38)
M_A_DQ41: length 73.7
  TOP w0.102: JDIMM2.191 180.4,80.17 180.66,80.43 181.12,80.43 181.64,80.95 182.5,80.95 183.72,82.17 183.72,84.49 v2(183.29,84.92)
  IN03 w0.076: 179.67,124.73 179.47,124.73 177.27,126.93 v2(177.27,127.72)
  IN03 w0.13: 179.67,124.73 180.1,124.73 182.61,122.23 183.97,122.23 186.84,119.36 186.84,112.79 186.71,112.66 186.53,112.66 186.4,112.54 186.4,112.27 186.53,112.15 186.71,112.15 186.84,112.02 186.84,111.72 186.71,111.6 186.54,111.6 186.41,111.47 186.41,111.21 186.54,111.08 186.71,111.08 186.84,110.95 186.84,110.69 186.71,110.56 186.54,110.56 186.41,110.43 186.41,110.17 186.54,110.04 186.71,110.04 186.84,109.91 186.84,109.65 186.71,109.52 186.54,109.52 186.41,109.39 186.41,109.13 186.54,109 186.71,109 186.84,108.87 186.84,108.62 186.71,108.49 186.54,108.49 186.41,108.36 186.41,108.1 186.54,107.97 186.73,107.97 186.86,107.84 186.86,107.58 186.73,107.45 186.54,107.45 186.41,107.32 186.41,107.06 186.54,106.93 186.73,106.93 186.86,106.8 186.86,106.54 186.73,106.41 186.54,106.41 186.41,106.28 186.41,106.03 186.54,105.9 186.73,105.9 186.86,105.77 186.86,105.51 186.73,105.38 186.54,105.38 186.41,105.25 186.41,96.71 182.87,93.17 182.87,85.04 183,84.92 v2(183.29,84.92)
  BOTTOM w0.076: U1.V2 177.43,131.19 177.43,130.96 177.43,127.84 177.3,127.72 v2(177.27,127.72)
  BOTTOM w0.102: v2(183.29,84.92) 183.04,84.92 182.89,84.76 182.89,83.42 182.78,83.32 182.64,83.32 182.53,83.42 182.53,85.07 182.66,85.2 182.85,85.2 182.95,85.29 182.95,85.49 182.83,85.61 182.46,85.61 182.34,85.73 182.34,85.89 182.46,86.01 182.64,86.01 182.76,86.13 182.76,86.3 182.64,86.42 182.43,86.42 182.07,86.78 JDIMM1.191
M_A_DQ42: length 73.1
  TOP w0.102: v2(186.6,84.92) 187,84.51 187,82.21 186.76,81.97 185.95,81.97 184.4,80.42 JDIMM2.207
  IN03 w0.076: 183.2,124.16 178.46,128.9 178.46,130.11 v2(178.89,130.54)
  IN03 w0.13: v2(186.6,84.92) 186.37,85.14 186.37,88.16 187.02,88.81 187.02,91.59 186.89,91.72 186.55,91.72 186.42,91.85 186.42,92.11 186.55,92.24 186.89,92.24 187.02,92.37 187.02,93.4 191.23,97.62 191.23,97.97 191.1,98.1 191.03,98.1 190.9,98.23 190.9,98.49 191.03,98.62 191.1,98.62 191.23,98.75 191.23,99.01 191.1,99.14 191.03,99.14 190.9,99.27 190.9,99.53 191.03,99.65 191.1,99.65 191.23,99.78 191.23,100.04 191.1,100.17 191.03,100.17 190.9,100.3 190.9,100.56 191.03,100.69 191.1,100.69 191.23,100.82 191.23,101.08 191.1,101.21 191.03,101.21 190.9,101.34 190.9,101.6 191.03,101.73 191.1,101.73 191.23,101.86 191.23,102.12 191.1,102.25 191.03,102.25 190.9,102.38 190.9,102.63 191.03,102.76 191.1,102.76 191.23,102.89 191.23,103.15 191.1,103.28 191.03,103.28 190.9,103.41 190.9,103.67 191.03,103.8 191.1,103.8 191.23,103.93 191.23,104.19 191.1,104.32 191.03,104.32 190.9,104.45 190.9,104.71 191.03,104.84 191.1,104.84 191.23,104.97 191.23,115.55 190.48,116.3 190.48,119.45 185.77,124.16 183.2,124.16
  BOTTOM w0.102: v2(186.6,84.92) 186.6,84.86 186.02,84.28 185.44,84.28 185.35,84.37 185.35,84.51 185.44,84.6 185.95,84.6 186.05,84.7 186.05,84.85 185.95,84.95 185.44,84.95 185.34,85.05 185.34,85.19 185.44,85.29 185.6,85.29 185.72,85.41 185.72,85.58 185.6,85.7 185.19,85.7 185.06,85.83 185.06,86.01 185.19,86.13 185.42,86.13 186.07,86.78 JDIMM1.207
  BOTTOM w0.14: v2(178.89,130.54) 178.56,130.82 U1.U1
