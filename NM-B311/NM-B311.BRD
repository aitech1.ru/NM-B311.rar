# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ47: length 88
  TOP w0.102: v2(186.6,70.31) 186.19,70.72 186.19,71.64 184.85,72.98 JDIMM4.208
  IN10 w0.076: v2(178.6,135.7) 178.97,135.33 178.97,134.19 179.26,133.9 179.26,130.06 184.27,125.05
  IN10 w0.13: v2(186.6,70.31) 186.15,70.76 186.15,71.96 186.34,72.15 186.34,75.43 187.02,76.11 187.02,78.03 189.96,80.98 189.96,81.49 189.71,81.74 189.71,85.42 189.96,85.68 189.96,85.93 189.37,86.52 189.37,92.96 189.25,93.08 189.25,93.21 189.48,93.44 189.48,93.71 189.23,93.96 189.23,94.23 189.48,94.48 189.48,94.75 189.23,95 189.23,95.27 189.48,95.51 189.48,95.78 189.23,96.03 189.23,96.3 189.48,96.55 189.48,96.82 189.23,97.07 189.23,97.34 189.48,97.59 189.48,97.86 189.23,98.1 189.23,98.37 189.48,98.62 189.48,98.89 189.23,99.14 189.23,99.41 189.48,99.66 189.48,99.93 189.23,100.18 189.23,100.45 189.48,100.7 189.48,100.97 189.23,101.21 189.23,101.48 189.48,101.73 189.48,102 189.23,102.25 189.23,102.52 189.48,102.77 189.48,103.04 189.23,103.29 189.23,103.56 189.48,103.8 189.48,104.07 189.23,104.32 189.23,104.59 189.48,104.84 189.48,105.11 189.23,105.36 189.23,105.63 189.48,105.88 189.48,106.15 189.23,106.4 189.23,106.66 189.48,106.91 189.48,107.18 189.23,107.43 189.23,107.7 189.48,107.95 189.48,108.22 189.23,108.47 189.23,108.74 189.48,108.99 189.48,109.26 189.23,109.5 189.23,109.77 189.48,110.02 189.48,110.29 189.23,110.54 189.23,110.81 189.48,111.06 189.48,111.33 189.23,111.58 189.23,111.85 189.48,112.1 189.48,112.36 189.23,112.61 189.23,112.88 189.48,113.13 189.48,113.75 189.35,113.88 189.2,113.88 189.07,114.01 189.07,114.27 189.2,114.4 189.35,114.4 189.45,114.51 189.48,114.53 189.48,114.79 189.35,114.92 189.2,114.92 189.07,115.05 189.07,115.31 189.2,115.44 189.35,115.44 189.48,115.57 189.48,115.82 189.35,115.95 189.2,115.95 189.07,116.08 189.07,116.34 189.2,116.47 189.35,116.47 189.48,116.6 189.48,116.92 189.35,117.05 189.2,117.05 189.07,117.17 189.07,117.43 189.2,117.55 189.2,117.83 185.01,122.02 185.01,124.32 184.27,125.05
  BOTTOM w0.102: v2(186.6,70.31) 186.6,70.25 187,69.84 187,69.29 187.25,69.04 187.25,67.9 186.89,67.54 186.73,67.54 186.55,67.36 JDIMM3.208
  BOTTOM w0.14: U1.V8 v2(178.6,135.7)
M_B_DQ48: length 91.5
  TOP w0.102: JDIMM4.212 185.85,73.58 188.09,71.34 188.09,69.43 188.49,69.04 v2(188.5,69.04)
  IN10 w0.076: 185.39,125.56 185.1,125.84 184.35,125.84 179.88,130.32 179.88,134.52 179.7,134.7 179.7,135.42 179.89,135.61 179.89,137.12 v2(180.43,137.65)
  IN10 w0.13: v2(188.5,69.04) 187.67,69.87 187.67,73.74 189.2,75.26 189.2,78.29 191.34,80.42 191.34,93.25 190.96,93.62 190.96,93.85 191.09,93.98 191.13,93.98 191.26,94.1 191.26,94.36 191.13,94.49 191.09,94.49 190.96,94.62 190.96,94.88 191.09,95.01 191.13,95.01 191.26,95.14 191.26,95.4 191.13,95.53 191.09,95.53 190.96,95.66 190.96,95.92 191.09,96.05 191.13,96.05 191.26,96.18 191.26,96.44 191.13,96.57 191.09,96.57 190.96,96.7 190.96,96.95 191.09,97.08 191.13,97.08 191.26,97.21 191.26,97.47 191.13,97.6 191.09,97.6 190.96,97.73 190.96,97.99 191.09,98.12 191.13,98.12 191.26,98.25 191.26,98.51 191.13,98.64 191.09,98.64 190.96,98.77 190.96,99.03 191.09,99.16 191.13,99.16 191.26,99.29 191.26,99.55 191.13,99.67 191.09,99.67 190.96,99.8 190.96,100.06 191.09,100.19 191.13,100.19 191.26,100.32 191.26,100.58 191.13,100.71 191.09,100.71 190.96,100.84 190.96,118.06 186.28,122.74 186.28,124.67 185.39,125.56
  BOTTOM w0.102: JDIMM3.212 187.55,67.1 188,67.54 188.77,67.54 188.89,67.67 188.89,67.85 188.77,67.97 188.13,67.97 188,68.1 188,68.3 188.13,68.43 189.15,68.43 189.27,68.56 189.27,68.91 189.15,69.04 v2(188.5,69.04)
  BOTTOM w0.14: U1.R11 v2(180.43,137.65)
M_B_DQ49: length 90.8
  TOP w0.102: JDIMM4.225 189.1,66.97 189.76,67.63 190.52,67.63 191.45,68.56 192.04,68.56 192.29,68.8 192.29,69.15 192.17,69.27 192.02,69.27 191.8,69.05 v2(191.8,69.04)
  IN10 w0.076: 187.09,127.82 185.34,127.82 182.59,130.56 182.59,134.17 182.18,134.58 182.18,135.79 181.88,136.1 181.88,136.76 181.8,136.84 181.8,137.19 v2(181.34,137.65)
  IN10 w0.13: 187.09,127.82 191.66,123.24 191.66,122.28 196,117.94 196,92.73 196.13,92.6 196.23,92.6 196.36,92.47 196.36,92.21 196.23,92.08 196.13,92.08 196,91.95 196,91.69 196.13,91.56 196.23,91.56 196.36,91.43 196.36,91.17 196.23,91.04 196.13,91.04 196,90.92 196,90.65 196.54,90.11 196.54,79.8 194.91,78.17 194.91,75.77 192.31,73.17 192.31,69.55 v2(191.8,69.04)
  BOTTOM w0.102: v2(191.8,69.04) 190.95,69.89 190.95,73.43 190.8,73.58 JDIMM3.225
  BOTTOM w0.14: U1.P11 v2(181.34,137.65)
M_B_DQ50: length 91.4
  TOP w0.102: v2(190.15,71.96) 189.55,71.96 189.43,72.09 189.43,72.24 189.2,72.47 189.2,72.97 189.08,73.09 188.91,73.09 188.79,72.97 188.79,72.47 188.69,72.37 188.46,72.37 187.93,72.9 187.93,73.08 188.06,73.21 188.51,73.21 188.85,73.54 JDIMM4.224
  IN10 w0.076: v2(181.34,135.05) 181.34,134.43 181.83,133.94 181.83,130.57 185.22,127.18 186.61,127.18
  IN10 w0.13: v2(190.15,71.96) 190.15,72.85 193.14,75.84 193.14,77.8 194.94,79.61 194.94,90.28 194.95,90.3 194.95,93.58 194.06,94.46 194.06,94.8 194.19,94.93 194.25,94.93 194.38,95.06 194.38,95.32 194.25,95.45 194.19,95.45 194.06,95.58 194.06,95.84 194.19,95.97 194.25,95.97 194.38,96.09 194.38,96.35 194.25,96.48 194.19,96.48 194.06,96.61 194.06,96.87 194.19,97 194.25,97 194.38,97.13 194.38,97.39 194.25,97.52 194.19,97.52 194.06,97.65 194.06,97.91 194.19,98.04 194.25,98.04 194.38,98.17 194.38,98.43 194.25,98.56 194.19,98.56 194.06,98.69 194.06,98.94 194.19,99.07 194.25,99.07 194.38,99.2 194.38,99.46 194.25,99.59 194.19,99.59 194.06,99.72 194.06,99.98 194.19,100.11 194.25,100.11 194.38,100.24 194.38,100.5 194.25,100.63 194.19,100.63 194.06,100.76 194.06,101.02 194.19,101.15 194.25,101.15 194.38,101.28 194.38,101.54 194.25,101.67 194.19,101.67 194.06,101.79 194.06,102.05 194.19,102.18 194.25,102.18 194.38,102.31 194.38,102.57 194.25,102.7 194.19,102.7 194.06,102.83 194.06,103.09 194.19,103.22 194.25,103.22 194.38,103.35 194.38,103.61 194.25,103.74 194.19,103.74 194.06,103.87 194.06,104.13 194.19,104.26 194.25,104.26 194.38,104.39 194.38,104.64 194.25,104.77 194.19,104.77 194.06,104.9 194.06,105.16 194.19,105.29 194.25,105.29 194.38,105.42 194.38,105.68 194.25,105.81 194.19,105.81 194.06,105.94 194.06,106.2 194.19,106.33 194.25,106.33 194.38,106.46 194.38,106.72 194.25,106.85 194.19,106.85 194.06,106.98 194.06,107.24 194.19,107.36 194.25,107.36 194.38,107.49 194.38,107.75 194.25,107.88 194.19,107.88 194.06,108.01 194.06,108.27 194.19,108.4 194.25,108.4 194.38,108.53 194.38,108.79 194.25,108.92 194.19,108.92 194.06,109.05 194.06,109.31 194.19,109.44 194.25,109.44 194.38,109.57 194.38,109.83 194.25,109.96 194.19,109.96 194.06,110.09 194.06,110.34 194.19,110.47 194.25,110.47 194.38,110.6 194.38,110.86 194.25,110.99 194.19,110.99 194.06,111.12 194.06,111.38 194.19,111.51 194.25,111.51 194.38,111.64 194.38,111.9 194.25,112.03 194.19,112.03 194.06,112.16 194.06,112.42 194.19,112.55 194.25,112.55 194.38,112.68 194.38,112.94 194.25,113.06 194.19,113.06 194.06,113.19 194.06,113.45 194.19,113.58 194.25,113.58 194.38,113.71 194.38,113.97 194.25,114.1 194.19,114.1 194.06,114.23 194.06,114.49 194.19,114.62 194.25,114.62 194.38,114.75 194.38,115.01 194.25,115.14 194.19,115.14 194.06,115.27 194.06,115.53 194.19,115.66 194.25,115.66 194.38,115.78 194.38,116.04 194.25,116.17 194.19,116.17 194.06,116.3 194.06,116.56 194.19,116.69 194.25,116.69 194.38,116.82 194.38,117.08 194.25,117.21 194.19,117.21 194.06,117.34 194.06,118.36 188.72,123.7 188.72,125.07 186.61,127.18
  BOTTOM w0.14: U1.P7 v2(181.34,135.05) ; v2(190.15,71.96) 190.62,71.49 190.62,67.06 190.55,66.99 JDIMM3.224
M_B_DQ51: length 92.6
  TOP w0.102: JDIMM4.215 186.6,67 187.82,68.22 188.75,68.22 189.38,68.84 189.38,70.03 188.92,70.49 188.92,71.45 188.79,71.58 v2(188.5,71.58)
  IN10 w0.076: 185.43,126.25 184.37,126.25 180.33,130.29 180.33,134.62 180,134.96 180,135.28 v2(180.43,135.7)
  IN10 w0.13: 185.43,126.25 186.91,124.77 186.91,123.11 191.97,118.06 191.97,117.62 191.71,117.36 191.71,117.1 191.97,116.84 191.97,116.59 191.71,116.33 191.71,116.07 191.97,115.81 191.97,115.55 191.71,115.29 191.71,115.03 192.22,114.52 192.22,114.25 191.97,114.01 191.97,113.74 192.22,113.49 192.22,113.22 191.97,112.97 191.97,112.7 192.22,112.45 192.22,112.18 192,111.96 191.97,111.93 191.97,111.66 192.22,111.41 192.22,111.15 191.97,110.9 191.97,110.63 192.22,110.38 192.22,110.11 191.97,109.86 191.97,109.59 192.22,109.34 192.22,109.07 191.97,108.82 191.97,108.55 192.22,108.31 192.22,108.04 191.97,107.79 191.97,107.52 192.22,107.27 192.22,107 191.97,106.75 191.97,106.48 192.22,106.23 192.22,105.96 191.97,105.71 191.97,105.45 192.22,105.2 192.22,104.93 191.97,104.68 191.97,104.41 192.22,104.16 192.22,103.89 191.97,103.64 191.97,103.37 192.22,103.12 192.22,102.85 191.97,102.61 191.97,102.34 192.22,102.09 192.22,101.82 191.97,101.57 191.97,101.3 192.22,101.05 192.22,100.78 191.97,100.53 191.97,100.26 192.22,100.01 192.22,99.75 191.97,99.5 191.97,99.23 192.22,98.98 192.22,98.71 191.97,98.46 191.97,98.19 192.22,97.94 192.22,97.67 191.97,97.42 191.97,97.15 192.22,96.91 192.22,96.64 191.97,96.39 191.97,96.12 192.22,95.87 192.22,95.6 191.97,95.35 191.97,95.08 192.22,94.83 192.22,94.56 191.97,94.32 191.97,93.68 192.83,92.83 192.83,80.93 190.67,78.77 190.67,75.72 188.5,73.55 v2(188.5,71.58)
  BOTTOM w0.102: JDIMM3.215 188.3,73.4 188.08,73.18 187.7,73.18 187.62,73.1 187.62,72.88 187.73,72.77 188.17,72.77 188.28,72.66 188.28,72.49 188.17,72.37 187.73,72.37 187.62,72.27 187.62,72.04 187.73,71.94 187.94,71.94 188.06,71.82 188.06,71.65 187.94,71.53 187.73,71.53 187.62,71.43 187.62,70.62 187.75,70.49 187.95,70.49 188.08,70.62 188.08,71.15 188.5,71.57 v2(188.5,71.58)
  BOTTOM w0.14: U1.R8 v2(180.43,135.7)
M_B_DQ52: length 91.7
  TOP w0.102: JDIMM4.211 185.6,67 185.85,67.25 186.37,67.25 187.67,68.55 188.65,68.55 189.01,68.91 189.01,69.8 v2(188.5,70.31)
  IN10 w0.076: v2(180.43,137) 180.05,136.62 180.05,135.55 179.85,135.35 179.85,134.82 180.11,134.57 180.11,130.31 184.36,126.05 185.28,126.05
  IN10 w0.13: v2(188.5,70.31) 188.06,70.76 188.06,73.61 189.58,75.14 189.58,78.2 192.22,80.84 192.22,92.96 191.61,93.57 191.61,100.92 191.48,101.05 191.46,101.05 191.33,101.18 191.33,101.43 191.46,101.56 191.48,101.56 191.61,101.69 191.61,101.95 191.48,102.08 191.46,102.08 191.33,102.21 191.33,102.47 191.46,102.6 191.48,102.6 191.61,102.73 191.61,102.99 191.48,103.12 191.46,103.12 191.33,103.25 191.33,103.51 191.46,103.64 191.48,103.64 191.61,103.77 191.61,104.03 191.48,104.15 191.46,104.15 191.33,104.28 191.33,104.54 191.46,104.67 191.48,104.67 191.61,104.8 191.61,105.06 191.48,105.19 191.46,105.19 191.33,105.32 191.33,105.58 191.46,105.71 191.48,105.71 191.61,105.84 191.61,106.1 191.48,106.23 191.46,106.23 191.33,106.36 191.33,106.62 191.46,106.75 191.48,106.75 191.61,106.88 191.61,107.13 191.48,107.26 191.46,107.26 191.33,107.39 191.33,107.65 191.46,107.78 191.48,107.78 191.61,107.91 191.61,108.17 191.48,108.3 191.46,108.3 191.33,108.43 191.33,108.69 191.46,108.82 191.48,108.82 191.61,108.95 191.61,109.21 191.48,109.34 191.46,109.34 191.33,109.47 191.33,109.72 191.46,109.85 191.48,109.85 191.61,109.98 191.61,110.24 191.48,110.37 191.46,110.37 191.33,110.5 191.33,110.76 191.46,110.89 191.48,110.89 191.61,111.02 191.61,111.28 191.48,111.41 191.46,111.41 191.33,111.54 191.33,111.8 191.46,111.93 191.48,111.93 191.61,112.06 191.61,112.32 191.48,112.45 191.46,112.45 191.33,112.57 191.33,112.83 191.46,112.96 191.48,112.96 191.61,113.09 191.61,113.35 191.48,113.48 191.46,113.48 191.33,113.61 191.33,113.87 191.46,114 191.48,114 191.61,114.13 191.61,114.39 191.48,114.52 191.46,114.52 191.33,114.65 191.33,118.19 186.58,122.94 186.58,124.74 185.28,126.05
  BOTTOM w0.102: JDIMM3.211 187.3,72.56 187.17,72.43 186.82,72.43 186.7,72.31 186.7,72.14 186.82,72.03 187.17,72.03 187.3,71.9 187.3,71.53 186.99,71.22 186.99,71.06 187.3,70.74 187.3,70.42 187.71,70.01 188.24,70.01 188.5,70.27 v2(188.5,70.31)
  BOTTOM w0.14: U1.R10 v2(180.43,137)
M_B_DQ53: length 90.6
  TOP w0.14: JDIMM4.228 189.85,73.43 189.72,73.31 189.67,73.31 189.54,73.18 189.54,72.68 189.67,72.55 189.88,72.55 190.03,72.7 190.24,72.7 190.72,72.22 190.72,71.2 190.85,71.07 191.08,71.07 191.21,71.2 191.21,71.45 191.33,71.58 v2(191.8,71.58)
  IN10 w0.076: v2(181.34,137) 181.72,136.62 181.72,135.98 181.98,135.72 181.98,134.48 182.34,134.12 182.34,130.53 185.28,127.59 186.93,127.59
  IN10 w0.13: v2(191.8,71.58) 191.8,73.17 194.53,75.9 194.53,78.26 196.18,79.91 196.18,89.99 195.64,90.53 195.64,94.74 195.42,94.96 195.42,95.26 195.64,95.48 195.64,95.77 195.42,95.99 195.42,96.29 195.64,96.51 195.64,96.81 195.42,97.03 195.42,97.33 195.64,97.55 195.64,97.85 195.42,98.07 195.42,98.36 195.64,98.58 195.64,98.88 195.42,99.1 195.42,99.4 195.64,99.62 195.64,99.92 195.42,100.14 195.42,100.44 195.64,100.66 195.64,100.96 195.42,101.18 195.42,101.47 195.64,101.69 195.64,101.99 195.42,102.21 195.42,102.51 195.64,102.73 195.64,103.03 195.42,103.25 195.42,103.55 195.64,103.77 195.64,104.06 195.42,104.28 195.42,104.58 195.64,104.8 195.64,105.1 195.42,105.32 195.42,105.62 195.64,105.84 195.64,106.14 195.42,106.36 195.42,106.66 195.64,106.87 195.64,107.17 195.42,107.39 195.42,107.69 195.64,107.91 195.64,108.21 195.42,108.43 195.42,108.73 195.64,108.95 195.64,109.25 195.42,109.47 195.42,109.76 195.64,109.98 195.64,110.28 195.42,110.5 195.42,110.8 195.64,111.02 195.64,111.32 195.42,111.54 195.42,111.84 195.64,112.06 195.64,112.35 195.42,112.57 195.42,112.87 195.64,113.09 195.64,113.39 195.42,113.61 195.42,113.91 195.64,114.13 195.64,114.43 195.42,114.65 195.42,114.95 195.64,115.17 195.64,115.46 195.42,115.68 195.42,115.98 195.64,116.2 195.64,116.5 195.42,116.72 195.42,117.02 195.64,117.24 195.64,117.79 189.3,124.13 189.3,125.23 186.93,127.59
  BOTTOM w0.102: v2(191.8,71.58) 192.21,71.17 192.21,68.87 191.55,68.21 JDIMM3.228
  BOTTOM w0.14: U1.P10 v2(181.34,137)
M_B_DQ54: length 92.6
  TOP w0.102: v2(190.15,68.79) 189.73,69.21 189.73,71.13 188.79,72.06 188.28,72.06 187.43,72.92 187.41,72.92 186.85,73.48 JDIMM4.216
  IN10 w0.076: v2(180.43,135.05) 180.56,134.92 180.56,130.28 184.38,126.46 185.55,126.46
  IN10 w0.13: 185.55,126.46 187.24,124.77 187.24,123.29 192.58,117.96 192.58,117.8 192.32,117.54 192.32,117.28 192.58,117.02 192.58,116.76 192.32,116.51 192.32,116.25 192.58,115.99 192.58,115.73 192.32,115.47 192.32,115.21 192.73,114.8 192.73,114.43 192.58,114.28 192.58,113.92 192.73,113.77 192.73,113.4 192.58,113.25 192.58,112.88 192.73,112.73 192.73,112.36 192.58,112.21 192.58,111.84 192.73,111.69 192.73,111.33 192.58,111.18 192.58,110.81 192.73,110.66 192.73,110.29 192.58,110.14 192.58,109.77 192.73,109.62 192.73,109.25 192.58,109.1 192.58,108.73 192.73,108.58 192.73,108.22 192.58,108.07 192.58,107.7 192.73,107.55 192.73,107.18 192.58,107.03 192.58,106.66 192.73,106.51 192.73,106.14 192.58,105.99 192.58,105.63 192.73,105.48 192.73,105.11 192.58,104.96 192.58,104.59 192.73,104.44 192.73,104.07 192.58,103.92 192.58,103.55 192.73,103.4 192.73,103.03 192.58,102.88 192.58,102.52 192.73,102.37 192.73,102 192.58,101.85 192.58,101.48 192.73,101.33 192.73,100.96 192.58,100.81 192.58,100.44 192.73,100.29 192.73,99.93 192.58,99.78 192.58,99.41 192.73,99.26 192.73,98.89 192.58,98.74 192.58,98.37 192.73,98.22 192.73,97.85 192.58,97.7 192.58,97.33 192.73,97.18 192.73,96.82 192.58,96.67 192.58,96.3 192.73,96.15 192.73,95.78 192.58,95.63 192.58,95.26 192.73,95.11 192.73,94.74 192.58,94.59 192.58,93.55 193.21,92.92 193.21,80.84 191.38,79.01 191.38,75.92 189.01,73.55 189.01,69.93 v2(190.15,68.79)
  BOTTOM w0.102: JDIMM3.216 188.55,67.11 188.68,67.24 190.19,67.24 190.3,67.34 190.3,67.49 190.19,67.59 189.31,67.59 189.2,67.7 189.2,67.86 189.31,67.97 190.19,67.97 190.3,68.09 190.3,68.24 190.19,68.35 189.71,68.35 189.58,68.48 189.58,68.66 189.71,68.79 v2(190.15,68.79)
  BOTTOM w0.14: U1.R7 v2(180.43,135.05)
M_B_DQ55: length 91.1
  TOP w0.102: JDIMM4.229 190.1,66.97 190.45,67.32 190.65,67.32 191.58,68.25 192.17,68.25 192.59,68.68 192.59,69.52 v2(191.8,70.31)
  IN10 w0.076: v2(181.34,135.7) 181.78,135.26 181.78,134.33 182.09,134.02 182.09,130.54 185.23,127.39 186.76,127.39
  IN10 w0.13: v2(191.8,70.31) 191.23,70.88 191.23,73.1 194.15,76.03 194.15,78.35 195.8,80 195.8,89.9 195.68,90.03 195.44,90.03 195.31,90.16 195.31,94.13 195.18,94.26 194.74,94.26 194.61,94.39 194.61,94.8 194.74,94.93 194.81,94.93 194.94,95.05 194.94,95.24 194.73,95.45 194.73,95.68 194.94,95.89 194.94,96.28 194.74,96.48 194.74,96.8 194.94,97 194.94,97.32 194.74,97.52 194.74,97.83 194.94,98.03 194.94,98.35 194.74,98.55 194.74,98.87 194.94,99.07 194.94,99.39 194.74,99.59 194.74,99.91 194.94,100.11 194.94,100.42 194.74,100.62 194.74,100.94 194.94,101.14 194.94,101.46 194.74,101.66 194.74,101.98 194.94,102.18 194.94,102.5 194.74,102.7 194.74,103.02 194.94,103.22 194.94,103.53 194.74,103.73 194.74,104.05 194.94,104.25 194.94,104.57 194.74,104.77 194.74,105.09 194.94,105.29 194.94,105.61 194.74,105.81 194.74,106.12 194.94,106.32 194.94,106.64 194.74,106.84 194.74,107.16 194.94,107.36 194.94,107.68 194.74,107.88 194.74,108.2 194.94,108.4 194.94,108.71 194.74,108.92 194.74,109.23 194.94,109.43 194.94,109.75 194.74,109.95 194.74,110.27 194.94,110.47 194.94,110.79 194.74,110.99 194.74,111.31 194.94,111.51 194.94,111.82 194.74,112.02 194.74,112.34 194.94,112.54 194.94,112.86 194.74,113.06 194.74,113.38 194.94,113.58 194.94,113.9 194.74,114.1 194.74,114.41 194.94,114.62 194.94,114.93 194.74,115.13 194.74,115.45 194.94,115.65 194.94,115.97 194.74,116.17 194.74,116.49 194.94,116.69 194.94,117.01 194.74,117.21 194.74,118.19 189.02,123.91 189.02,125.12 186.76,127.39
  BOTTOM w0.102: v2(191.8,70.31) 191.8,70.23 191.68,70.11 191.38,70.11 191.26,70.23 191.26,72.13 191.36,72.23 191.65,72.23 191.76,72.35 191.76,72.52 191.65,72.64 191.36,72.64 191.26,72.74 191.26,72.97 191.38,73.1 191.56,73.1 191.8,73.34 JDIMM3.229
  BOTTOM w0.14: U1.P8 v2(181.34,135.7)
M_B_DQ56: length 99.4
  TOP w0.102: JDIMM4.250 195.35,72.95 195.51,72.78 195.66,72.78 196.14,73.27 196.31,73.27 196.43,73.15 196.43,72.98 195.95,72.5 195.95,72.35 196.09,72.21 196.23,72.21 196.67,72.65 196.84,72.65 196.96,72.53 196.96,72.36 196.52,71.92 196.52,71.78 196.72,71.58 v2(196.98,71.58)
  IN10 w0.076: 187.17,133.6 185.66,135.11 185.62,135.11 184.58,136.15 184.58,137.13 v2(184.06,137.65)
  IN10 w0.13: v2(196.98,71.58) 201.39,71.58 202.03,72.22 202.03,73.87 202.53,74.37 203.29,74.37 204.81,75.9 204.81,84.87 205.53,85.59 205.53,92 205.23,92.3 205.23,114.53 203.73,116.03 203.73,123.12 200.64,126.21 194.81,126.21 189.58,131.45 189.58,131.88 188.9,132.56 187.69,132.56 187.17,133.08 187.17,133.6
  BOTTOM w0.102: JDIMM3.250 197.05,67.11 197.18,67.24 197.68,67.24 197.81,67.36 197.81,68.35 198.11,68.66 198.11,69.67 197.45,70.33 197.45,71.11 v2(196.98,71.58)
  BOTTOM w0.14: U1.L11 v2(184.06,137.65)
M_B_DQ57: length 99.6
  TOP w0.102: v2(193.71,69.04) 192.94,69.81 192.94,71.49 190.85,73.58 JDIMM4.232
  IN10 w0.076: v2(183.17,137.65) 182.65,137.13 182.65,136.15 182.43,135.93 182.43,134.74 182.9,134.27 182.9,130.56 185.46,128 186.05,128 186.18,128.12 187,128.12
  IN10 w0.13: 187,128.12 187.55,128.12 192.5,123.17 192.5,122.22 196.62,118.11 197.26,117.46 197.26,116.35 197.39,116.22 197.45,116.22 197.58,116.09 197.58,115.83 197.45,115.7 197.39,115.7 197.26,115.57 197.26,115.31 197.39,115.18 197.43,115.18 197.56,115.05 197.56,114.79 197.43,114.66 197.39,114.66 197.26,114.53 197.26,114.28 197.39,114.15 197.58,114.15 197.71,114.02 197.71,113.76 197.58,113.63 197.39,113.63 197.26,113.5 197.26,113.24 197.39,113.11 197.58,113.11 197.71,112.98 197.71,112.72 197.58,112.59 197.39,112.59 197.26,112.46 197.26,112.2 197.39,112.07 197.58,112.07 197.71,111.95 197.71,111.68 197.58,111.56 197.39,111.56 197.26,111.43 197.26,93.13 199.87,90.52 199.87,85.55 201.33,84.09 201.33,78.74 198.37,75.77 195.68,75.77 192.88,72.98 192.88,69.87 v2(193.71,69.04)
  BOTTOM w0.102: JDIMM3.232 192.55,68.1 192.95,68.49 192.95,70.41 193.05,70.51 193.19,70.51 193.29,70.41 193.29,69.19 193.44,69.04 v2(193.71,69.04)
  BOTTOM w0.14: U1.M11 v2(183.17,137.65)
M_B_DQ58: length 99.6
  TOP w0.102: JDIMM4.245 194.1,66.97 194.77,67.64 195.29,67.64 195.78,68.13 195.78,71.16 v2(195.36,71.58)
  IN10 w0.076: 186.13,133.77 185.57,134.32 185.57,134.32 184.81,135.07 v2(184.02,135.07)
  IN10 w0.13: v2(195.36,71.58) 195.36,72.03 196.6,73.27 199.75,73.27 203.74,77.26 203.74,85.31 204.44,86.01 204.44,89.08 203.91,89.62 203.91,90.3 203.74,90.47 203.74,90.82 203.91,90.99 203.91,91.34 203.74,91.51 203.74,91.86 203.91,92.02 203.91,92.37 203.74,92.54 203.74,92.89 203.91,93.06 203.91,93.41 203.74,93.58 203.74,93.93 203.91,94.1 203.91,94.45 203.74,94.62 203.74,94.97 203.91,95.13 203.91,95.48 203.74,95.65 203.74,96 203.91,96.17 203.91,96.52 203.74,96.69 203.74,99.4 203.61,99.52 203.4,99.52 203.27,99.65 203.27,99.91 203.4,100.04 203.61,100.04 203.74,100.17 203.74,100.43 203.61,100.56 203.4,100.56 203.27,100.69 203.27,100.95 203.4,101.08 203.61,101.08 203.74,101.21 203.74,101.47 203.61,101.6 203.4,101.6 203.27,101.73 203.27,101.99 203.4,102.12 203.61,102.12 203.74,102.24 203.74,102.5 203.61,102.63 203.4,102.63 203.27,102.76 203.27,103.02 203.4,103.15 203.61,103.15 203.74,103.28 203.74,103.54 203.61,103.67 203.43,103.67 203.3,103.8 203.3,104.06 203.43,104.19 203.61,104.19 203.74,104.32 203.74,113.3 202.66,114.38 202.66,122.68 200.27,125.07 194.33,125.07 188.7,130.7 188.04,130.7 186.13,132.62 186.13,133.77
  BOTTOM w0.076: 184.02,135.07 v2(184.02,135.07)
  BOTTOM w0.102: JDIMM3.245 195.8,73.5 195.43,73.13 194.56,73.13 194.43,73 194.43,72.72 194.56,72.6 195.4,72.6 195.53,72.47 195.53,72.24 195.4,72.11 194.57,72.11 194.44,71.99 194.44,71.71 194.57,71.58 v2(195.36,71.58)
  BOTTOM w0.14: U1.L7 184.02,135.07
M_B_DQ59: length 100.8
  TOP w0.102: v2(193.71,71.58) 194.18,71.11 194.18,68.89 192.82,67.53 192.23,67.53 191.95,67.25 191.28,67.25 191.1,67.07 JDIMM4.233
  IN10 w0.076: v2(183.13,135.7) 182.73,135.3 182.73,134.89 183.51,134.11 183.51,130.38 185.56,128.32 185.87,128.32 186.23,128.68
  IN10 w0.13: v2(193.71,71.58) 193.71,72.79 195.93,75.01 198.85,75.01 202.05,78.21 202.05,84.64 201.14,85.55 201.14,91.27 199.17,93.23 199.17,106.7 199.05,106.83 198.85,106.83 198.72,106.96 198.72,107.22 198.85,107.35 199.05,107.35 199.17,107.48 199.17,107.73 199.05,107.86 198.83,107.86 198.7,107.99 198.7,108.25 198.83,108.38 199.05,108.38 199.17,108.51 199.17,108.77 199.05,108.9 198.83,108.9 198.7,109.03 198.7,109.29 198.83,109.42 199.05,109.42 199.17,109.55 199.17,109.8 199.05,109.93 198.83,109.93 198.7,110.06 198.7,110.32 198.83,110.45 199.05,110.45 199.17,110.58 199.17,110.84 199.05,110.97 198.83,110.97 198.7,111.1 198.7,111.36 198.83,111.49 199.05,111.49 199.17,111.62 199.17,111.88 199.05,112.01 198.83,112.01 198.7,112.14 198.7,112.4 198.83,112.53 199.05,112.53 199.17,112.65 199.17,112.91 199.05,113.04 198.83,113.04 198.7,113.17 198.7,113.43 198.83,113.56 199.05,113.56 199.17,113.69 199.17,113.95 199.05,114.08 198.83,114.08 198.7,114.21 198.7,114.47 198.81,114.57 198.94,114.57 199.07,114.7 199.07,114.96 198.94,115.09 198.86,115.09 198.7,115.25 198.7,115.5 198.83,115.63 199.05,115.63 199.17,115.76 199.17,116.56 193.39,122.35 193.39,123.4 188.1,128.68 186.23,128.68
  BOTTOM w0.102: v2(193.71,71.58) 193.58,71.71 193.39,71.71 193.26,71.58 193.26,70.91 193.17,70.81 193.04,70.81 192.95,70.91 192.95,71.62 192.73,71.83 192.73,72.01 192.83,72.11 193.36,72.11 193.47,72.23 193.47,72.38 193.36,72.5 192.83,72.5 192.7,72.62 192.7,72.8 192.83,72.93 193.38,72.93 193.49,73.04 193.49,73.2 193.38,73.31 192.96,73.31 192.8,73.47 JDIMM3.233
  BOTTOM w0.14: v2(183.13,135.7) 182.85,135.38 U1.M8
M_B_DQ60: length 98.7
  TOP w0.102: v2(196.98,70.31) 197.43,69.87 197.43,68.41 197.3,68.28 196.37,68.28 195.1,67.01 JDIMM4.249
  IN10 w0.076: v2(184.06,137) 184.43,136.63 184.43,136.04 185.64,134.82 185.65,134.82 186.91,133.56
  IN10 w0.13: 186.91,133.56 186.91,132.82 188.26,131.47 189.02,131.47 194.64,125.86 200.49,125.86 203.37,122.97 203.37,115.45 204.62,114.2 204.62,101.67 204.82,101.47 204.82,101.15 204.62,100.96 204.62,100.64 204.82,100.44 204.82,100.12 204.62,99.92 204.62,99.64 204.87,99.4 204.87,99.13 204.85,99.11 204.62,98.88 204.62,98.61 204.87,98.36 204.87,98.09 204.62,97.84 204.62,97.57 204.87,97.32 204.87,97.05 204.62,96.8 204.62,96.53 204.87,96.29 204.87,96.02 204.62,95.77 204.62,95.5 204.87,95.25 204.87,94.98 204.62,94.73 204.62,94.46 204.87,94.21 204.87,93.94 204.62,93.7 204.62,93.43 204.87,93.18 204.87,92.91 204.62,92.66 204.62,92.4 205.16,91.87 205.16,85.72 204.45,85.02 204.45,76.96 199.56,72.06 196.79,72.06 196.54,71.81 196.54,70.76 v2(196.98,70.31)
  BOTTOM w0.102: JDIMM3.249 196.8,73.36 196.67,73.23 196.26,73.23 196.13,73.1 196.13,72.37 195.88,72.11 195.88,71.82 196.11,71.59 196.11,71.42 195.88,71.19 195.88,70.67 196.01,70.54 196.86,70.54 196.98,70.41 v2(196.98,70.31)
  BOTTOM w0.14: U1.L10 v2(184.06,137)
M_B_DQ61: length 97.8
  TOP w0.102: JDIMM4.236 191.85,73.05 193.28,71.62 193.28,70.74 v2(193.71,70.31)
  IN10 w0.076: 186.49,128.4 186.16,128.4 185.93,128.17 185.5,128.17 183.2,130.47 183.2,134.2 182.58,134.83 182.58,135.83 182.81,136.07 182.81,136.64 v2(183.17,137)
  IN10 w0.13: 186.49,128.4 187.8,128.4 192.93,123.27 192.93,122.3 198.34,116.89 198.34,110.87 198.21,110.74 197.8,110.74 197.67,110.61 197.67,110.35 197.8,110.22 198.21,110.22 198.34,110.09 198.34,109.83 198.21,109.7 197.75,109.7 197.62,109.57 197.62,109.31 197.75,109.18 198.21,109.18 198.34,109.05 198.34,108.8 198.21,108.67 197.75,108.67 197.62,108.54 197.62,108.28 197.75,108.15 198.21,108.15 198.34,108.02 198.34,107.76 198.21,107.63 197.75,107.63 197.62,107.5 197.62,107.24 197.75,107.11 198.21,107.11 198.34,106.98 198.34,106.72 198.21,106.59 197.75,106.59 197.62,106.46 197.62,106.21 197.75,106.08 198.21,106.08 198.34,105.95 198.34,93.04 200.5,90.88 200.5,85.55 201.69,84.36 201.69,78.35 198.73,75.39 195.8,75.39 193.26,72.85 193.26,70.76 v2(193.71,70.31)
  BOTTOM w0.102: v2(193.71,70.31) 193.96,70.31 194.11,70.16 194.11,68.81 193.94,68.63 193.68,68.63 193.55,68.51 JDIMM3.236
  BOTTOM w0.14: U1.M10 v2(183.17,137)
M_B_DQ62: length 99.6
  TOP w0.102: v2(195.36,68.41) 195.04,68.41 194.91,68.53 194.91,69.19 194.79,69.32 194.61,69.32 194.48,69.19 194.48,67.78 193.93,67.24 193.09,67.24 193.08,67.23 192.36,67.23 192.1,66.97 JDIMM4.237
  IN10 w0.076: 184.5,133.43 184.5,133.68 183.88,134.3 183.63,134.3 183.1,134.84 v2(183.1,135.04)
  IN10 w0.13: v2(195.36,68.41) 194.13,69.64 194.13,72.7 196.03,74.6 199.2,74.6 202.4,77.81 202.4,84.79 201.64,85.55 201.64,91.71 200.82,92.54 200.82,98.44 200.63,98.63 200.63,117.14 201.32,117.83 201.32,122.12 199.76,123.69 193.63,123.69 188.11,129.21 186.15,129.21 184.5,130.86 184.5,133.43
  BOTTOM w0.102: JDIMM3.237 193.8,72.06 194.11,71.75 194.11,70.59 194.42,70.28 194.42,69.35 v2(195.36,68.41)
  BOTTOM w0.14: U1.M7 v2(183.1,135.04)
M_B_DQ63: length 99.5
  TOP w0.102: v2(196.98,69.04) 196.58,69.45 196.58,71.29 194.35,73.52 JDIMM4.246
  IN10 w0.076: v2(184.06,135.7) 184.48,135.7 186.53,133.65
  IN10 w0.13: v2(196.98,69.04) 196.21,69.82 196.21,72.11 196.51,72.42 199.4,72.42 204.1,77.11 204.1,85.16 204.8,85.87 204.8,89.67 204.67,89.8 204.49,89.8 204.36,89.93 204.36,90.18 204.49,90.31 204.67,90.31 204.8,90.44 204.8,90.7 204.67,90.83 204.49,90.83 204.36,90.96 204.36,91.22 204.49,91.35 204.67,91.35 204.8,91.48 204.8,91.72 204.26,92.25 204.26,113.67 203.02,114.91 203.02,122.83 200.34,125.5 194.46,125.5 188.84,131.12 188.13,131.12 186.53,132.72 186.53,133.65
  BOTTOM w0.102: JDIMM3.246 196.05,66.97 196.32,67.24 196.75,67.24 197.05,67.54 197.38,67.54 197.5,67.67 197.5,67.9 197.38,68.02 197.19,68.02 197.07,68.14 197.07,68.31 197.19,68.43 197.35,68.43 197.81,68.89 197.81,69.52 197.68,69.65 197.49,69.65 197.36,69.52 197.36,69.17 197.23,69.04 v2(196.98,69.04)
  BOTTOM w0.14: U1.L8 183.73,135.38 v2(184.06,135.7)
M_B_DQS_DN0: length 92.5
  TOP w0.102: v2(134.47,71.33) 134.29,71.14 133.77,71.14 133.52,70.9 133.52,67.24 133.6,67.16 JDIMM4.11
  IN10 w0.076: 146.97,135.59 146.98,135.6 146.99,135.6 147.02,135.57 147.12,135.57 147.59,136.05 147.59,136.25 148.07,136.72 149.37,136.72 149.89,137.24 150.58,137.24 v2(150.94,136.87)
  IN10 w0.145: 146.97,135.59 146.69,135.31 142.93,131.55 142.93,129.25 133.77,120.1 133.77,116.56 133.06,115.85 133.06,115.33 133.22,115.17 133.22,114.13 133.06,113.97 133.06,113 133.22,112.84 133.22,111.8 133.06,111.64 133.06,110.67 133.22,110.51 133.22,109.47 133.06,109.31 133.06,108.34 133.22,108.17 133.22,107.14 133.06,106.98 133.06,106.01 133.22,105.84 133.22,104.81 133.06,104.64 133.06,103.67 133.22,103.51 133.22,102.47 133.06,102.31 133.06,101.34 133.22,101.18 133.22,100.14 133.06,99.98 133.06,93.4 133.55,92.92 133.55,91.57 133.88,91.24 133.88,90.56 133.55,90.23 133.55,88.68 133.83,88.4 133.83,87.57 133.55,87.29 133.55,80.84 134.14,80.25 134.14,78.31 134.75,77.7 134.75,75.97 134.57,75.8 134.14,75.8 133.84,75.5 133.84,75.01 134.14,74.7 134.62,74.7 134.75,74.58 134.75,74.29 134.62,74.17 134.16,74.17 133.86,73.87 133.86,73.34 134.16,73.04 134.76,73.04 134.9,72.9 134.9,71.54 134.69,71.33 v2(134.47,71.33)
  BOTTOM w0.102: JDIMM3.11 135.32,74.35 135.32,73.4 135.37,73.35 135.55,73.35 135.6,73.3 135.6,72.85 135.52,72.77 135.2,72.77 134.96,72.53 134.96,71.93 135.2,71.68 135.6,71.68 135.72,71.56 135.72,71.2 135.6,71.08 134.6,71.08 134.47,71.2 v2(134.47,71.33)
  BOTTOM w0.14: U1.BP9 150.65,136.51 150.65,136.68 150.84,136.87 v2(150.94,136.87)
M_B_DQS_DN1: length 89.4
  TOP w0.102: JDIMM4.32 138.85,72.96 139.08,72.72 139.83,72.72 139.96,72.6 139.96,72.16 139.83,72.04 139.19,72.04 138.94,71.79 138.94,71.12 139.19,70.87 140.39,70.87 v2(140.57,70.69)
  IN10 w0.076: 150.56,134 150.8,134.24 150.8,134.57 151.13,134.9 152.44,134.9 152.69,135.15 152.69,136.55 153.02,136.88 v2(153.02,137)
  IN10 w0.145: 150.56,134 150.04,133.48 150.04,131.38 146.12,127.46 146.12,126.46 138.21,118.55 138.21,95.13 137.89,94.8 137.89,94 138.76,93.13 138.76,92.09 138.43,91.76 138.43,90.72 138.76,90.39 138.76,78.56 139.22,78.1 139.22,73.74 139.39,73.57 139.39,71.1 139.69,70.8 140.46,70.8 v2(140.57,70.69)
  BOTTOM w0.102: v2(140.57,70.69) 140.57,70.81 140.7,70.94 141.25,70.94 141.38,70.81 141.38,68.54 141.25,68.41 140.73,68.41 140.47,68.15 140.47,67.81 140.85,67.43 140.85,67.25 140.78,67.19 140.6,67.19 140.55,67.14 JDIMM3.32
  BOTTOM w0.14: U1.BL9 152.57,136.48 153.02,136.93 v2(153.02,137)
M_B_DQS_DN2: length 89.1
  TOP w0.102: JDIMM4.53 144.1,66.97 144.36,67.23 144.57,67.23 144.77,67.43 144.99,67.43 145.33,67.78 145.33,68.03 145.23,68.14 145.23,68.49 145.53,68.78 145.88,68.78 146.18,68.48 146.54,68.48 146.83,68.77 146.83,70.25 146.68,70.41 146.5,70.41 146.4,70.31 v2(146.4,70.18)
  IN10 w0.076: v2(155.74,136.35) 155.74,136.31 156.12,135.93 156.12,134.88 154.76,133.51 154.76,131.35 154.6,131.19 153.87,130.46 153.77,130.46 153.75,130.45
  IN10 w0.145: v2(146.4,70.18) 146.29,70.3 145.11,70.3 144.81,70.6 144.81,71.3 145.39,71.88 145.39,72.96 145.02,73.33 145.02,79.79 143.43,81.39 143.43,118.06 149.46,124.1 149.46,126.15 153.75,130.45
  BOTTOM w0.102: v2(146.4,70.18) 146.22,70.37 145.5,70.37 145.26,70.61 145.26,71.03 145.5,71.28 145.66,71.28 145.79,71.4 145.79,71.61 145.66,71.73 145.14,71.73 144.89,71.98 144.89,72.4 145.14,72.65 146.04,72.65 146.1,72.71 146.1,72.83 145.8,73.14 JDIMM3.53
  BOTTOM w0.14: U1.BG9 v2(155.74,136.35)
M_B_DQS_DN3: length 90.4
  TOP w0.102: v2(150.48,70.44) 150.29,70.62 149.59,70.62 149.35,70.87 149.35,71.51 149.59,71.76 149.71,71.76 149.84,71.89 149.84,72.58 149.71,72.71 149.35,72.71 149.11,72.95 149.11,73.29 149.35,73.53 JDIMM4.74
  IN10 w0.076: v2(158.48,136.35) 158.86,135.97 158.86,134.62 158.14,133.9 158.14,132.11 158.07,132.04 158.07,132.03
  IN10 w0.145: 158.07,132.03 158.07,127.64 154.38,123.94 154.38,123.41 148.64,117.67 148.64,93.85 149.13,93.36 149.13,91.91 149.45,91.59 149.95,91.59 150.07,91.47 150.07,90.85 149.95,90.73 149.85,90.73 149.55,90.42 149.55,88.61 149.85,88.31 149.95,88.31 150.07,88.18 150.07,87.7 149.92,87.55 149.23,87.55 148.94,87.25 148.94,86.3 149.53,85.71 149.53,85.29 149.13,84.89 149.13,84.05 149.55,83.63 149.55,83.01 149.13,82.59 149.13,81.28 149.55,80.86 149.95,80.86 150.07,80.73 150.07,80.36 149.95,80.23 149.27,80.23 148.97,79.93 148.97,79.16 149.27,78.86 149.95,78.86 150.07,78.74 150.07,78.35 149.95,78.22 149.78,78.22 149.47,77.92 149.47,75.86 149.78,75.56 149.95,75.56 150.07,75.44 150.07,75.1 149.95,74.97 149.46,74.97 149.16,74.67 149.16,74.12 149.46,73.82 149.95,73.82 150.07,73.69 150.07,73.18 149.66,72.77 149.66,70.89 150.12,70.44 v2(150.48,70.44)
  BOTTOM w0.102: JDIMM3.74 151.05,67.15 151.1,67.2 151.3,67.2 151.35,67.25 151.35,70.54 151.2,70.69 150.6,70.69 150.48,70.56 v2(150.48,70.44)
  BOTTOM w0.14: U1.BC9 v2(158.48,136.35)
M_B_DQS_DN4: length 88.2
  TOP w0.102: v2(179.74,70.06) 179.74,70.18 179.86,70.31 180.05,70.31 180.18,70.18 180.18,68.66 179.85,68.33 178.29,68.33 177.4,67.43 177.4,67.25 177.35,67.2 177.15,67.2 177.1,67.15 JDIMM4.177
  IN10 w0.076: v2(174.94,136.35) 175.32,135.97 175.32,134.83 175.56,134.59 175.56,128.11 177.92,125.75 177.98,125.69 177.98,125.59 177.99,125.57
  IN10 w0.145: v2(179.74,70.06) 179.63,70.17 179.24,70.17 178.94,70.47 178.94,72.27 179.01,72.34 179.01,77.94 181.92,80.85 181.92,88.21 182.33,88.62 182.33,111.37 182.2,111.49 181.92,111.49 181.62,111.8 181.62,113.08 181.49,113.2 181.24,113.2 180.94,113.5 180.94,114.33 181.24,114.63 181.6,114.63 181.73,114.76 181.73,115.37 181.6,115.5 181.24,115.5 180.94,115.8 180.94,116.62 181.24,116.92 181.53,116.92 181.65,117.05 181.65,117.58 181.53,117.71 181.16,117.71 179.62,119.25 179.62,122.94 178.15,124.41 178.15,125.42 177.99,125.57
  BOTTOM w0.102: JDIMM3.177 178.8,73.28 178.7,73.18 178.06,73.18 177.81,72.94 177.81,72.56 178.06,72.32 179,72.32 179.13,72.19 179.13,71.43 178.86,71.17 178.86,70.44 179.06,70.24 179.55,70.24 v2(179.74,70.06)
  BOTTOM w0.14: U1.AC9 v2(174.94,136.35)
M_B_DQS_DN5: length 90
  TOP w0.102: v2(184.94,69.93) 184.76,70.11 184.52,70.11 184.27,70.36 184.27,71.62 184.16,71.73 183.97,71.73 183.64,72.06 183.64,72.74 183.45,72.93 183.27,72.93 183.14,72.8 182.59,72.8 182.35,73.04 JDIMM4.198
  IN10 w0.076: 182.97,124.79 182.97,124.83 182.95,124.85 182.72,125.1 182.49,125.1 178.07,129.53 178.07,136.05 177.77,136.35 v2(177.68,136.35)
  IN10 w0.145: 182.97,124.79 183.83,123.92 183.83,121.49 187.29,118.03 187.29,115.86 187.59,115.56 187.64,115.56 187.77,115.43 187.77,114.86 187.64,114.74 187.59,114.74 187.29,114.43 187.29,113.59 187.59,113.29 187.93,113.29 188.06,113.16 188.06,112.56 187.91,112.42 187.59,112.42 187.29,112.12 187.29,111.26 187.59,110.96 187.93,110.96 188.06,110.83 188.06,110.22 187.93,110.09 187.59,110.09 187.29,109.79 187.29,108.93 187.59,108.63 187.91,108.63 188.06,108.48 188.06,93.37 187.76,93.07 187.76,87.82 186.99,87.05 186.99,86.24 187.63,85.59 187.63,80.47 185.4,78.23 185.4,76.13 185.04,75.77 185.04,72.85 184.75,72.56 184.45,72.56 184.14,72.26 184.14,70.34 184.45,70.04 184.83,70.04 v2(184.94,69.93)
  BOTTOM w0.102: v2(184.94,69.93) 184.94,70.05 185.07,70.18 185.82,70.18 185.9,70.1 185.9,68.69 185.41,68.2 184.55,68.2 184.35,68 184.35,67.25 184.3,67.2 184.09,67.2 184.05,67.15 JDIMM3.198
  BOTTOM w0.14: v2(177.68,136.35) U1.W9
M_B_DQS_DN6: length 92.6
  TOP w0.102: JDIMM4.219 187.6,66.97 187.86,67.23 188.07,67.23 188.61,67.77 188.99,67.77 189.6,68.38 190.41,68.38 191.05,69.02 191.05,70.15 190.89,70.31 190.29,70.31 190.15,70.17 v2(190.15,70.06)
  IN10 w0.076: 186.15,126.7 186.1,126.75 184.4,126.75 180.82,130.33 180.82,135.96 v2(180.43,136.35)
  IN10 w0.145: 186.15,126.7 187.78,125.07 187.78,123.49 193.25,118.02 193.25,93.85 194.14,92.97 194.14,92.18 193.99,92.03 193.89,92.03 193.55,91.7 193.55,90.9 193.89,90.57 193.99,90.57 194.14,90.42 194.14,87.3 193.55,86.72 193.55,86.13 194.14,85.55 194.14,79.72 193.89,79.47 192.71,79.47 192.33,79.1 192.33,76.02 189.35,73.04 189.35,70.47 189.65,70.17 190.04,70.17 v2(190.15,70.06)
  BOTTOM w0.102: v2(190.15,70.06) 189.97,70.24 189.14,70.24 188.9,70.49 188.9,70.85 189.14,71.1 189.41,71.1 189.54,71.23 189.54,71.58 189.41,71.71 188.95,71.71 188.7,71.95 188.7,72.35 188.95,72.6 189.59,72.6 189.67,72.68 189.67,72.79 189.59,72.88 189.5,72.88 189.3,73.07 JDIMM3.219
  BOTTOM w0.14: U1.R9 v2(180.43,136.35)
M_B_DQS_DN7: length 99.6
  TOP w0.102: JDIMM4.240 192.85,72.95 193.36,72.44 194.33,72.44 194.66,72.11 194.66,70.18 194.98,69.86 195.18,69.86 v2(195.36,69.68)
  IN10 w0.076: v2(183.18,136.35) 183.5,136.03 183.5,134.83 183.79,134.53 183.96,134.53 184.85,133.65 184.85,133.21 184.84,133.19 184.84,133.18
  IN10 w0.145: 184.84,133.18 184.84,131.21 186.25,129.8 188.35,129.8 193.89,124.25 199.93,124.25 201.84,122.34 201.84,117.24 201.39,116.79 201.39,110.32 201.84,109.87 201.84,98.25 202.49,97.61 202.49,89.88 203.2,89.17 203.2,86.21 202.92,85.93 202.92,77.6 199.41,74.08 196.23,74.08 194.55,72.4 194.55,70.09 194.85,69.79 195.25,69.79 v2(195.36,69.68)
  BOTTOM w0.102: v2(195.36,69.68) 195.64,69.96 196.25,69.96 196.37,69.83 196.37,69.54 196.25,69.41 196.04,69.41 195.76,69.14 195.76,68.81 196.18,68.39 196.18,68.08 195.96,67.85 195.64,67.85 195.02,67.23 194.76,67.23 194.55,67.02 JDIMM3.240
  BOTTOM w0.14: U1.M9 v2(183.18,136.35)
M_B_DQS_DP0: length 92.5
  TOP w0.102: JDIMM4.13 134.1,67.15 134.01,67.24 133.81,67.24 133.73,67.33 133.73,70.81 133.85,70.94 134.35,70.94 134.47,70.81 v2(134.47,70.69)
  IN10 w0.076: 147.18,135.38 147.19,135.4 147.19,135.43 147.75,135.98 147.75,136.19 148.13,136.57 149.99,136.57 v2(150.29,136.87)
  IN10 w0.145: v2(134.47,70.69) 134.47,70.59 134.6,70.47 135.07,70.47 135.2,70.59 135.2,73.03 134.89,73.34 134.28,73.34 134.16,73.47 134.16,73.74 134.28,73.87 134.75,73.87 135.05,74.17 135.05,74.7 134.75,75 134.27,75 134.14,75.13 134.14,75.37 134.27,75.5 134.7,75.5 135.05,75.85 135.05,77.82 134.44,78.44 134.44,80.37 133.84,80.96 133.84,87.17 134.12,87.45 134.12,88.52 133.84,88.8 133.84,90.11 134.17,90.44 134.17,91.36 133.84,91.7 133.84,93.04 133.36,93.53 133.36,99.86 133.52,100.02 133.52,101.3 133.36,101.47 133.36,102.19 133.52,102.35 133.52,103.63 133.36,103.8 133.36,104.52 133.52,104.68 133.52,105.97 133.36,106.13 133.36,106.85 133.52,107.02 133.52,108.3 133.36,108.46 133.36,109.18 133.52,109.35 133.52,110.63 133.36,110.79 133.36,111.52 133.52,111.68 133.52,112.96 133.36,113.12 133.36,113.85 133.52,114.01 133.52,115.29 133.36,115.46 133.36,115.73 134.07,116.44 134.07,119.97 143.22,129.13 143.22,131.43 146.9,135.1 147.18,135.38
  BOTTOM w0.102: JDIMM3.13 135.8,72.77 135.6,72.57 135.29,72.57 135.16,72.44 135.16,72.01 135.29,71.89 135.68,71.89 135.93,71.64 135.93,71.12 135.68,70.87 134.66,70.87 v2(134.47,70.69)
  BOTTOM w0.14: v2(150.29,136.87) 150.29,136.8 U1.BR9
M_B_DQS_DP1: length 89.3
  TOP w0.102: JDIMM4.34 139.35,73.42 139.29,73.35 139.11,73.35 139.05,73.3 139.05,73.04 139.17,72.93 139.92,72.93 140.16,72.68 140.16,72.08 139.92,71.83 139.28,71.83 139.15,71.71 139.15,71.2 139.28,71.08 140.44,71.08 140.57,71.2 v2(140.57,71.33)
  IN10 w0.076: 150.77,133.78 150.78,133.8 150.78,134 150.95,134.17 150.95,134.5 151.19,134.74 151.64,134.74 151.71,134.67 151.71,134.46 151.8,134.37 151.92,134.37 152.01,134.46 152.01,134.67 152.08,134.74 152.65,134.74 152.85,134.94 152.85,136.28 152.91,136.35 v2(153.06,136.35)
  IN10 w0.145: v2(140.57,71.33) 140.57,71.23 140.44,71.1 139.81,71.1 139.69,71.23 139.69,71.4 140.05,71.76 140.05,71.92 139.69,72.29 139.69,73.7 139.52,73.86 139.52,78.22 139.06,78.68 139.06,90.51 138.73,90.84 138.73,91.63 139.06,91.97 139.06,93.25 138.62,93.69 138.62,93.7 138.42,93.89 138.19,94.12 138.19,94.68 138.51,95 138.51,118.43 146.42,126.34 146.42,127.34 150.34,131.26 150.34,133.35 150.77,133.78
  BOTTOM w0.076: U1.BJ9 153.45,136.03 153.45,136.34 153.39,136.4 153.11,136.4 v2(153.06,136.35)
  BOTTOM w0.102: v2(140.57,71.33) 140.75,71.14 141.34,71.14 141.58,70.9 141.58,68.46 141.34,68.21 140.82,68.21 140.67,68.07 140.67,67.89 141.05,67.51 JDIMM3.34
M_B_DQS_DP2: length 89.1
  TOP w0.102: v2(146.4,70.82) 146.61,70.61 146.76,70.61 147.03,70.34 147.03,68.69 146.63,68.28 146.09,68.28 145.79,68.58 145.61,68.58 145.43,68.4 145.43,68.22 145.54,68.12 145.54,67.69 145.07,67.23 144.86,67.23 144.6,66.97 JDIMM4.55
  IN10 w0.076: v2(156.65,136.35) 156.65,136.38 156.53,136.5 156.31,136.5 156.18,136.38 156.18,136.1 156.27,136 156.27,134.81 154.91,133.45 154.91,131.28 153.98,130.35 153.98,130.25 153.96,130.24
  IN10 w0.145: v2(146.4,70.82) 146.4,70.72 146.27,70.59 145.23,70.59 145.11,70.72 145.11,71.17 145.69,71.76 145.69,73.08 145.32,73.45 145.32,79.91 143.72,81.51 143.72,117.94 149.76,123.97 149.76,126.03 153.96,130.24
  BOTTOM w0.102: JDIMM3.55 146.3,73.42 146.24,73.36 146.06,73.36 146,73.3 146,73.22 146.31,72.92 146.31,72.63 146.12,72.44 145.22,72.44 145.09,72.32 145.09,72.06 145.22,71.94 145.75,71.94 145.99,71.69 145.99,71.32 145.75,71.07 145.59,71.07 145.46,70.95 145.46,70.7 145.59,70.57 146.27,70.57 146.4,70.7 v2(146.4,70.82)
  BOTTOM w0.14: U1.BF9 v2(156.65,136.35)
M_B_DQS_DP3: length 90.3
  TOP w0.102: JDIMM4.76 149.85,73.58 149.59,73.32 149.43,73.32 149.31,73.2 149.31,73.03 149.43,72.91 149.8,72.91 150.04,72.67 150.04,71.8 149.8,71.56 149.68,71.56 149.55,71.43 149.55,70.95 149.68,70.82 150.35,70.82 150.48,70.95 v2(150.48,71.07)
  IN10 w0.076: v2(159.4,136.35) 159.27,136.48 159.14,136.48 159.02,136.35 159.02,134.55 158.3,133.83 158.3,132.06 158.3,132.05 158.36,132.05 158.37,132.04 158.37,132.03
  IN10 w0.145: 158.37,132.03 158.37,127.52 154.67,123.82 154.67,123.28 154.4,123.01 148.93,117.55 148.93,93.98 149.43,93.49 149.43,92.04 149.57,91.89 150.07,91.89 150.37,91.59 150.37,90.73 150.07,90.43 149.97,90.43 149.85,90.3 149.85,88.73 149.97,88.6 150.07,88.6 150.37,88.3 150.37,87.57 150.04,87.25 149.36,87.25 149.24,87.13 149.24,86.43 149.83,85.83 149.83,85.17 149.43,84.76 149.43,84.18 149.85,83.76 149.85,82.89 149.43,82.47 149.43,81.41 149.68,81.16 150.07,81.16 150.37,80.86 150.37,80.24 150.07,79.94 149.39,79.94 149.26,79.81 149.26,79.29 149.39,79.16 150.07,79.16 150.37,78.86 150.37,78.23 150.07,77.93 149.9,77.93 149.77,77.8 149.77,75.99 149.9,75.86 150.07,75.86 150.37,75.56 150.37,74.98 150.07,74.68 149.58,74.68 149.45,74.55 149.45,74.25 149.58,74.12 150.07,74.12 150.37,73.82 150.37,73.06 149.96,72.65 149.96,71.02 150.09,70.89 150.35,70.89 150.48,71.02 v2(150.48,71.07)
  BOTTOM w0.102: JDIMM3.76 151.55,70.63 151.28,70.89 150.66,70.89 v2(150.48,71.07)
  BOTTOM w0.14: U1.BB9 v2(159.4,136.35)
M_B_DQS_DP4: length 88.2
  TOP w0.102: v2(179.74,70.69) 179.92,70.51 180.14,70.51 180.38,70.26 180.38,68.57 179.94,68.13 178.38,68.13 177.6,67.35 JDIMM4.179
  IN10 w0.076: v2(175.86,136.35) 175.81,136.4 175.55,136.4 175.47,136.33 175.47,134.89 175.71,134.66 175.71,128.17 178.03,125.85 178.08,125.8 178.19,125.8 178.2,125.79
  IN10 w0.145: v2(179.74,70.69) 179.74,70.59 179.61,70.47 179.36,70.47 179.24,70.59 179.24,72.15 179.31,72.22 179.31,77.82 182.21,80.72 182.21,88.09 182.62,88.5 182.62,111.49 182.32,111.79 182.04,111.79 181.92,111.92 181.92,113.2 181.61,113.5 181.37,113.5 181.24,113.63 181.24,114.2 181.37,114.33 181.73,114.33 182.03,114.63 182.03,115.49 181.73,115.79 181.37,115.79 181.24,115.92 181.24,116.5 181.37,116.62 181.65,116.62 181.95,116.92 181.95,117.7 181.65,118 181.29,118 179.92,119.38 179.92,123.06 178.45,124.53 178.45,125.54 178.2,125.79
  BOTTOM w0.102: v2(179.74,70.69) 179.74,70.57 179.61,70.44 179.14,70.44 179.06,70.52 179.06,71.08 179.33,71.35 179.33,72.27 179.08,72.52 178.14,72.52 178.01,72.65 178.01,72.85 178.14,72.98 178.78,72.98 179,73.2 179,73.3 179.04,73.34 179.24,73.34 179.29,73.39 179.29,74.37 JDIMM3.179
  BOTTOM w0.14: U1.AA9 v2(175.86,136.35)
M_B_DQS_DP5: length 89.9
  TOP w0.102: JDIMM4.200 182.85,74.37 182.85,73.41 182.79,73.35 182.61,73.35 182.55,73.3 182.55,73.12 182.68,73 183.05,73 183.19,73.14 183.54,73.14 183.85,72.83 183.85,72.14 184.05,71.94 184.25,71.94 184.47,71.71 184.47,70.44 184.6,70.32 184.82,70.32 184.94,70.44 v2(184.94,70.56)
  IN10 w0.076: 183.18,125 183.17,125 183.02,125 182.78,125.25 182.56,125.25 178.22,129.59 178.22,136.3 178.3,136.38 178.57,136.38 v2(178.6,136.35)
  IN10 w0.145: v2(184.94,70.56) 184.94,70.47 184.82,70.34 184.57,70.34 184.44,70.47 184.44,72.14 184.57,72.26 184.88,72.26 185.34,72.72 185.34,75.65 185.69,76 185.69,78.11 187.93,80.34 187.93,85.72 187.28,86.36 187.28,86.92 188.06,87.7 188.06,92.95 188.35,93.25 188.35,108.6 188.03,108.92 187.71,108.92 187.59,109.05 187.59,109.66 187.71,109.79 188.05,109.79 188.35,110.09 188.35,110.95 188.05,111.25 187.71,111.25 187.59,111.38 187.59,112 187.71,112.12 188.03,112.12 188.35,112.44 188.35,113.28 188.05,113.58 187.71,113.58 187.59,113.71 187.59,114.31 187.71,114.44 187.76,114.44 188.07,114.74 188.07,115.55 187.76,115.85 187.71,115.85 187.59,115.98 187.59,118.16 184.13,121.62 184.13,124.05 183.18,125
  BOTTOM w0.102: JDIMM3.200 184.55,67.91 184.63,68 185.49,68 186.1,68.61 186.1,70.18 185.9,70.38 185.13,70.38 v2(184.94,70.56)
  BOTTOM w0.14: U1.V9 v2(178.6,136.35)
M_B_DQS_DP6: length 92.5
  TOP w0.102: JDIMM4.221 188.1,66.97 188.7,67.57 189.07,67.57 189.68,68.18 190.49,68.18 191.26,68.94 191.26,70.23 190.98,70.51 190.33,70.51 v2(190.15,70.69)
  IN10 w0.076: 186.36,126.91 186.35,126.9 186.35,126.92 186.34,126.92 186.31,126.89 186.18,126.89 186.16,126.9 184.46,126.9 180.97,130.4 180.97,136.13 181.19,136.35 v2(181.34,136.35)
  IN10 w0.145: 186.36,126.91 187.12,126.15 187.12,126.15 188.07,125.2 188.07,123.61 193.54,118.14 193.54,93.98 194.43,93.09 194.43,92.05 194.11,91.74 194.01,91.74 193.85,91.58 193.85,91.03 194.01,90.87 194.11,90.87 194.43,90.55 194.43,87.18 193.85,86.6 193.85,86.26 194.43,85.67 194.43,79.6 194.01,79.18 192.83,79.18 192.63,78.97 192.63,75.9 189.65,72.92 189.65,70.59 189.78,70.47 190.02,70.47 190.15,70.59 v2(190.15,70.69)
  BOTTOM w0.102: JDIMM3.221 189.8,73.41 189.75,73.36 189.56,73.36 189.5,73.3 189.5,73.16 189.58,73.08 189.67,73.08 189.87,72.88 189.87,72.59 189.67,72.39 189.03,72.39 188.91,72.27 188.91,72.04 189.03,71.91 189.5,71.91 189.74,71.67 189.74,71.14 189.5,70.89 189.23,70.89 189.1,70.77 189.1,70.57 189.23,70.44 190.02,70.44 190.15,70.57 v2(190.15,70.69)
  BOTTOM w0.14: U1.P9 v2(181.34,136.35)
M_B_DQS_DP7: length 99.5
  TOP w0.102: v2(195.36,70.31) 195.36,70.19 195.23,70.06 195.06,70.06 194.86,70.26 194.86,72.2 194.41,72.65 193.44,72.65 193.05,73.03 193.05,73.3 193.1,73.35 193.3,73.35 193.35,73.4 JDIMM4.242
  IN10 w0.076: 185.13,133.18 185.13,133.19 185.12,133.19 185,133.31 185,133.71 184.03,134.69 183.85,134.69 183.65,134.89 183.65,136.26 183.74,136.35 v2(184.06,136.35)
  IN10 w0.145: 185.13,133.18 185.13,131.34 186.38,130.09 188.47,130.09 194.01,124.55 200.05,124.55 202.14,122.46 202.14,117.12 201.69,116.67 201.69,110.44 202.14,109.99 202.14,98.38 202.79,97.73 202.79,90 203.5,89.29 203.5,86.08 203.22,85.8 203.22,77.47 199.53,73.79 196.36,73.79 194.85,72.28 194.85,70.21 194.98,70.08 195.23,70.08 195.36,70.21 v2(195.36,70.31)
  BOTTOM w0.102: JDIMM3.242 195.05,66.97 195.72,67.64 196.04,67.64 196.39,67.99 196.39,68.48 195.97,68.9 195.97,69.06 196.12,69.21 196.33,69.21 196.58,69.46 196.58,69.91 196.33,70.16 195.51,70.16 v2(195.36,70.31)
  BOTTOM w0.14: U1.L9 v2(184.06,136.35)
MAINON: length 747.2
  TOP w0.089: R299.2 37.23,50.36 v1(36.71,50.88)
  TOP w0.097: PR1306.2 v2(23.59,19.38) ; PR1253.2 206.5,152.51 205.71,151.72 204.67,151.72 v2(204.44,151.95) ; PR1258.2 191.64,128.98 191.74,129.09 v2(191.74,130.08) ; PR1405.1 107.87,65.92 v2(108.17,65.61) ; v2(277.34,39.7) 277.34,40.24 277.11,40.46 PR610.1 ; PR623.1 76.09,43.44 v1(74.9,42.24) 74.34,42.8 70.99,42.8 v2(70.48,42.29)
  IN03 w0.089: 30.7,49.61 30.07,48.97
  IN03 w0.091: v2(38.07,42.5) 39.47,42.5 40.7,41.26 48.26,41.26 48.74,41.74 56.61,41.74 v2(58.13,43.26) ; v2(108.17,65.61) 107.66,65.1 101.73,65.1 101.08,65.76 99.55,65.76 99.12,65.32 90.87,65.32 86.06,60.52 73.36,60.52 v2(72.87,60.02) ; v1(36.71,50.88) 35.7,49.86 30.96,49.86 30.7,49.61 ; 30.07,48.97 29.69,48.97 28.82,48.11 28.44,48.11 27.91,47.58 27.91,45.16 26.13,43.39 25.88,43.39 25.62,43.13 25.62,42.78 27.78,40.62 27.78,25.99 27.02,25.23 27.02,24.08 23.59,20.65 v2(23.59,19.38)
  IN05 w0.091: v2(70.48,42.29) 69.52,42.29 68.55,43.26 v2(58.13,43.26)
  IN08 w0.089: 39.47,46.69 39.47,49.36 38.45,50.37 37.22,50.37 v1(36.71,50.88)
  IN08 w0.091: v2(185.64,194.77) 186.31,194.11 189.42,194.11 190.19,194.87 192.02,194.87 192.63,194.26 195.93,194.26 196.31,193.88 196.31,193.46 199.73,190.04 199.73,184.09 198.51,182.87 198.51,176.57 200.12,174.96 200.12,167.08 201.31,165.9 201.31,158.5 204.44,155.37 v2(204.44,151.95) 204.44,151.59 198.6,145.75 198.6,132.45 197.07,130.93 v2(197.07,130.76) ; v2(277.34,39.7) 276.96,39.32 275.61,39.32 275.31,39.62 274.47,39.62 274.17,39.32 267.43,39.32 263.4,43.36 260.22,43.36 256.65,39.79 253.74,39.79 253.09,40.44 214.91,40.44 212.01,43.34 204.31,43.34 201.69,40.72 182.22,40.72 180.74,42.2 170.07,42.2 167.66,44.61 122.22,44.61 117.57,39.96 v2(116.68,39.96) ; v2(38.07,42.5) 38.5,42.93 38.5,44.07 39.47,45.04 39.47,46.69 ; v2(108.17,65.61) 108.55,65.23 115.16,65.23 120.62,59.77 124.25,59.77 126.03,57.99 154.88,57.99 155.39,58.5 166.69,58.5 167.61,59.42 167.61,61.42 166.21,62.82 166.21,63.73 165.13,64.81 165.13,66.44 163.82,67.75 163.82,102.71 191.18,130.08 v2(191.74,130.08) ; v2(70.48,42.29) 70.48,44.45 70.87,44.83 70.87,50.16 69.95,51.08 69.95,58.63 71.34,60.02 v2(72.87,60.02)
  IN10 w0.091: v2(108.17,65.61) 110.3,65.61 111.73,64.18 111.73,62.94 112.24,62.44 114.78,62.44 115.54,61.67 115.54,59.9 119.35,56.09 119.35,55.07 120.14,54.28 120.14,52.02 116.3,48.19 116.3,43.13 117.06,42.37 117.06,40.34 v2(116.68,39.96) ; v2(185.64,194.77) 185.26,194.39 175.48,194.39 174.03,195.84 170.71,195.84 170,196.55 165.73,196.55 165.22,196.04 164.24,196.04 163.48,195.28 157.34,195.28 156.33,194.26 154.68,194.26 152.37,191.96 152.37,181.18 150.08,178.9 150.08,174.7 147.42,172.04 135.6,172.04 134.53,170.97 134.53,151.14 134.72,150.96 136.57,150.96 137.13,151.51 v2(137.89,151.51) 138.22,151.51 138.4,151.34 138.4,150.7 138.07,150.37 137.43,150.37 137.13,150.07 135.1,150.07 134.33,149.3 134.33,140.67 133.19,139.53 119.35,139.53 117.44,137.62 117.44,130.64 117.95,130.13 121.71,130.13 v2(122.21,130.63)
  BOTTOM w0.089: U5.D9 36.28,51.4 36.71,50.96 v1(36.71,50.88)
  BOTTOM w0.097: R520.1 137.13,151.51 v2(137.89,151.51) ; v2(191.74,130.08) 192.32,130.08 193.14,130.89 193.77,130.89 194.66,131.78 196.78,131.78 197.07,131.48 v2(197.07,130.76) ; v2(58.13,43.26) 58.39,43.26 58.95,43.82 PR1302.2
  BOTTOM w0.356: v2(122.21,130.63) 122.59,130.25 PR3465.1
