# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1.2V_SN: length 1.5
  BOTTOM w0.508: PC412.1 117.23,89.23 PR403.2
1.05VP_BS: length 7.8
  TOP w0.254: 264.15,46.18 263.37,46.96 PU501.6
  TOP w0.508: 264.15,46.18 v1(264.15,45.78) 264.81,45.11 266.08,45.11 267,46.04 267,46.87 266.41,47.45 PR502.1
1.05VP_EN: length 5.3
  TOP w0.254: PU501.1 263.42,49.21 264.31,50.09 v2(264.61,50.09)
  BOTTOM w0.254: v1(265.04,53.42) PR505.2 PR507.1 PC511.1 265.04,50.52 v2(264.61,50.09)
1.05VP_FB: length 4.6
  TOP w0.254: v2(264.36,47.5) 264.18,47.5 263.82,47.86 PU501.4
  BOTTOM w0.254: v2(264.36,47.5) 264.66,47.2 PR511.2 PC515.2 265.68,48.11 PR508.2
1.05VP_ILIM: length 3
  TOP w0.254: v2(264.31,48.42) 263.82,48.42 263.72,48.31 PU501.3
  BOTTOM w0.356: PR503.2 263.44,48.47 PR501.1 264.2,48.52 v2(264.31,48.42)
1.05VP_LX:
  vias: v1(259.46,51.44)
1.8V_EN: length 2.8
  BOTTOM w0.254: PR3465.2 PC3541.1 123.62,131.46 123.62,132.54 123.48,132.68 PU1309.1
1.8V_MAIN_EN: length 278
  TOP w0.097: v2(246.86,106.25) 247.49,106.89 R976.2 ; v2(287.37,175.09) 286.92,175.54 286.1,175.54 R2186.1 285.26,174.7 284.83,174.7 v1(284.19,174.07) 284.19,171.66 284.91,170.95 R2269.1
  IN03 w0.091: v2(246.86,106.25) 246.35,106.25 245.59,107.01 241.14,107.01 240.13,106 239.36,106 239.11,106.25 239.11,107.01 238.35,107.78 232.89,107.78 230.98,109.68 230.98,112.22 229.33,113.87 226.79,113.87 225.01,112.09 218.41,112.09 217.39,113.11 217.39,118.31 216.81,118.89 v2(216.81,119.45)
  IN05 w0.091: v2(297.49,197.53) 297.02,197.06 296.26,197.06 295.88,196.68 295.88,185.09 296.11,184.86 296.11,181.41 291.56,176.86 287.75,176.86 287.37,176.48 v2(287.37,175.09) 287.5,174.96 298.16,174.96 298.42,175.21 300.7,175.21 303.37,172.55 303.37,164.04 305.4,162 305.4,122.63 304.77,122 304.77,110.95 303.45,109.64 v2(303.45,109.4)
  IN08 w0.091: v2(216.81,119.45) 216.81,119.53 216.62,119.71 v2(210.53,119.71)
  IN10 w0.091: v2(246.86,106.25) 246.6,106 246.6,104.85 245.46,103.71 245.46,100.86 242.38,97.78 242.38,84.95 243.68,83.65 251.12,83.65 251.79,82.98 265.37,82.98 265.91,83.52 273.53,83.52 274.86,84.85 274.86,86.68 279.66,91.48 279.66,104.31 281.22,105.87 290.74,105.87 294.17,109.3 303.35,109.3 v2(303.45,109.4)
  BOTTOM w0.097: v2(210.53,119.71) 210.53,119.68 210.31,119.46 PR38.1 ; v2(297.49,197.53) PR30.2
1.8V_MAIN_EN_LS: length 159.3
  TOP w0.097: R2185.2 286.69,173.44 Q85.3 v2(288.12,173.44) ; D2020.1 297.81,64.56 298.04,64.34 299.94,64.34 v2(301.09,65.48) ; R1013.1 v2(291.31,174.2)
  IN05 w0.091: v2(305.78,73.61) 301.09,78.31 301.09,82.5 302.1,83.52 302.1,85.17 302.48,85.55 302.48,92.28 302.99,92.79 302.99,93.55 303.63,94.19 303.63,95.46 305.25,97.08 305.25,98.79 303.63,100.41 302.1,100.41 300.7,101.81 300.7,103.97 300.96,104.22 300.96,108.28 304.01,111.33 304.01,123.02 304.64,123.65 304.64,161.62 302.61,163.66 302.61,171.26 300.69,173.18 298.93,173.18 297.91,174.2 v2(291.31,174.2) 288.88,174.2 v2(288.12,173.44)
  IN08 w0.091: v2(301.09,65.48) 302.99,67.39 303.63,67.39 305.78,69.55 v2(305.78,73.61) ; v2(291.31,174.2) 291.56,174.2 298.67,181.31 300.83,181.31 v2(301.59,182.07)
  BOTTOM w0.097: v2(301.59,182.07) 300.45,182.07 299.99,182.53 PR803.1 ; PR804.2 297.93,183.52 PD801.2 299.94,182.78 PR803.1 ; PR803.1 PR801.1
1.8V_MAIN_EN_LS_N: length 4.2
  TOP w0.097: Q90.5 295.8,173.31 R1014.2 296.26,173.76 v1(296.26,174.7) 295.37,174.7 295.11,174.44 Q90.6
1.8V_MAIN_EN_N: length 3.3
  TOP w0.097: R2268.2 290.42,172.62 v1(290.42,172.8) ; R2268.2 289.61,171.9 Q101.6 ; R2268.2 289.2,171.4 Q101.5
1.8V_MAIN_EN_R: length 10.9
  TOP w0.097: R976.1 247.49,109.81 v2(246.86,110.44) 246.35,110.95 245.71,110.95 244.95,111.71 244.14,111.71 243.25,112.6 v3(240.76,112.6)
  BOTTOM w0.097: v2(246.86,110.44) 246.73,110.32 R975.2 247.92,109.76 v1(248,109.68)
  BOTTOM w0.1: v3(240.76,112.6) 240.79,112.63 G2.BE1
1.8VP_BS: length 1.8
  TOP w0.356: v2(123.86,135.46) 123.8,135.39 PR3462.1
  BOTTOM w0.254: PU1309.6 123.48,134.93 123.86,135.31 v2(123.86,135.46)
1.8VP_FB: length 3.9
  BOTTOM w0.254: PU1309.4 124.1,134.03 124.74,134.67 PR3457.2 PC3528.2 PR3458.1
1.8VP_ILIM: length 4
  BOTTOM w0.254: PU1309.3 124.2,133.58 124.61,133.17 124.61,132.21 124.82,132 PR3461.1 PR3463.2
1.8VP_LX: length 1.2
  TOP w0.356: v2(122.21,131.39) 121.7,131.9 PC3533.2
  vias: v1(121.2,130.63)
1.55V_PWR_EN: length 58.3
  TOP w0.097: D2017.1 D51.1 291.46,69.71 v1(291.69,69.93) 291.69,73.38 292.13,73.82 R809.1 293.26,73.87 R813.1 294.15,74.78 D2012.1 294.26,75.55 294.35,75.64 v2(295.62,75.64)
  IN05 w0.091: v2(301.21,103.46) 301.21,101.68 302.23,100.66 303.7,100.66 305.46,98.9 305.46,95.52 303.5,93.55 303.5,91.77 302.74,91.01 302.74,85.47 302.44,85.17 302.44,83.47 301.34,82.38 301.34,79.07 301.47,78.95 302.61,78.95 303.24,78.31 303.24,77.04 303.63,76.66 304.26,76.66 v2(305.15,75.77)
  BOTTOM w0.097: v2(301.21,103.46) 301.42,103.66 PR3567.2 ; v2(305.15,75.77) 301.47,75.77 300.7,76.53 298.16,76.53 297.78,76.15 296.13,76.15 v2(295.62,75.64)
1.55V_PWR_EN_N: length 112.2
  TOP w0.097: Q105.4 299.31,169.96 v2(299.43,170.09) ; R810.2 298.22,73.69 v1(297.66,74.25) 297.28,74.25 v2(297.02,73.99) 297.02,73.86 297.27,73.61 Q91.6
  IN05 w0.091: v2(300.58,80.34) 300.58,84.15 302.1,85.68 302.1,92.41 302.61,92.92 302.61,93.81 303.37,94.57 303.37,95.71 304.77,97.11 304.77,98.5 303.5,99.77 301.72,99.77 300.32,101.17 300.32,104.22 300.7,104.6 300.7,108.41 303.75,111.46 303.75,123.4 304.39,124.03 304.39,161.37 302.23,163.53 302.23,168.99 301.13,170.09 v2(299.43,170.09)
  IN08 w0.091: v2(300.58,80.34) 298.93,78.69 297.4,78.69 296.51,77.8 296.51,75.39 297.02,74.88 v2(297.02,73.99)
2.5V_MEM_EN: length 3.8
  TOP w0.097: PU403.1 210.76,114.09 210.18,113.52 210.18,112.47 PC421.1 PR425.1
2.5V_MEM_PWRGD: length 2.7
  TOP w0.097: PR451.1 PR423.2 210.11,113.82 210.83,114.54 PU403.2
2.5VP_BS: length 2.1
  BOTTOM w0.457: v3(210.66,117.68) 211.07,117.68 v1(211.32,117.43) 211.32,116.63 PR428.1
2.5VP_FB: length 3.5
  TOP w0.254: v2(210.48,115.44) PU403.4
  BOTTOM w0.254: PR438.1 209.75,113.27 PC435.2 PR439.2 210.08,115.04 v2(210.48,115.44)
2.5VP_ILIM: length 2.5
  TOP w0.097: PR427.2 PR431.1 210.48,114.71 210.77,114.99 PU403.3
2.5VP_LX: length 2.5
  BOTTOM w0.508: v2(212.62,112.86) 212.2,112.44 PC424.2 211.7,111.1 PR418.1
3V5V_EN: length 13.2
  TOP w0.203: v2(47.09,10.87) PR313.2 PR314.1 PC317.1 47.57,12.32 46.78,12.32 46.45,12.65 46.45,12.89 PU301.6 ; v2(42.01,10.87) 41.88,11 v1(41.88,12.02) 41.88,12.4 42.73,13.25 PU301.20
  IN10 w0.091: v2(47.09,10.87) v2(42.01,10.87)
3VLDO_1.0VG: length 2
  BOTTOM w0.254: PU702.5 217.22,167.59 217.88,168.25 PC718.1
3VLDO_1.05VP: length 2.8
  TOP w0.305: PC512.1 265.21,47.26 264.76,46.82 264.2,46.82 263.61,47.41 PU501.5
3VLDO_1.8VP: length 2.2
  BOTTOM w0.254: PU1309.5 123.86,134.48 124.36,134.98 124.36,135.28 PC3532.1
3VLDO_2.5VP: length 1.8
  TOP w0.254: PU403.5 210.72,115.89 210.01,116.6 PC437.1
5VALW_PG: length 60.3
  TOP w0.097: PU301.7 46.55,13.65 47.16,13.03 v2(47.16,12.81) ; R791.1 16.33,46.05 v2(16.2,45.93)
  IN05 w0.091: v2(47.16,12.81) 46.68,12.81 45.82,13.67 45.82,15.32 44.93,16.21 44.93,19.38 38.07,26.24 38.07,32.46 36.54,33.99 29.56,33.99 28.04,35.51 26.89,35.51 26.51,35.89 26.51,36.78 25.55,37.75 23.43,37.75 23.08,38.1 23.08,44.91 22.32,45.67 16.45,45.67 v2(16.2,45.93)
  BOTTOM w0.097: PR355.1 48.36,11.61 v2(47.16,12.81)
12V_SN: length 2.3
  BOTTOM w0.508: PR417.2 275.46,57.62 PC416.1 v1(275.46,59.69)
12V_SN_PUMP: length 1.3
  TOP w0.457: PR3599.2 279.7,20.36 PC3601.1
+0.6V_VTT: length 25.1
  TOP w0.254: JDIMM4.258 197.35,75.29 198.28,76.22 v2(198.28,76.28) ; v2(198.22,85.8) 197.45,85.8 197.15,86.11 JDIMM2.258
  TOP w0.305: PR1404.2 114.27,69.93 114.65,69.55 v2(114.65,68.91)
  IN10 w0.254: v2(117.19,70.56) 115.54,70.56 114.65,69.68
  IN10 w0.305: 114.65,69.68 v2(114.65,68.91)
  BOTTOM w0.102: v2(198.28,76.28) 198.41,76.28
  BOTTOM w0.254: JDIMM3.258 199.05,67.33 199.49,67.77
  BOTTOM w0.457: 199.49,67.77 204.18,67.77 205.07,68.66
  BOTTOM w0.508: v2(198.22,85.8) 198.98,85.04 204.82,85.04
  vias: v1(118.21,81.99) v2(117.95,70.56) v2(205.84,72.47) v2(205.84,70.95) v2(205.84,70.18) v2(205.84,69.42)
+0.6VSP: length 0.9
  TOP w0.305: PU401.2 110.86,91.88
  vias: v1(116.4,93.93)
+1.0V_VCCSFR: length 21.6
  TOP w0.305: v2(185.72,150.49) 185.47,150.23 C946.2
  IN05 w0.508: 185.21,151 v2(185.72,150.49)
  IN05 w0.635: v2(182.85,165.69) 182.09,164.93 182.09,164.29 180.72,162.92 180.72,159.41 182.09,158.04 182.09,152.73 183.1,151.72 184.49,151.72 185.21,151
  BOTTOM w0.305: v2(185.72,150.49) 185.34,150.87 U1.H28 U1.J28
  BOTTOM w0.762: R54.1 v2(182.85,165.69)
+1.0V_VCCST: length 127.5
  TOP w0.356: v2(115.03,194.39) 115.16,194.52 PC1157.2 PR1235.1 PR1234.2 ; C945.2 185.59,152.73 185.37,152.96 v2(185.37,153.22)
  TOP w0.381: v2(196.23,159.49) 194.53,157.79 194.53,157.43 v1(192.21,155.11) 191.74,154.64 190.47,154.64 189.96,154.13 R14.2
  IN03 w0.356: v2(145.64,162.13) 145.64,161.37 144.24,159.97 v2(144.24,155.91)
  IN03 w0.508: v2(182.85,164.42) 182.16,163.73 182.16,160.35 181.78,159.97 168.88,159.97 166.72,162.13 v2(145.64,162.13) 140.05,162.13 129.13,173.05 118.84,173.05 115.41,176.48 115.41,189.56 114.81,190.16 114.81,194.17 v2(115.03,194.39)
  BOTTOM w0.203: v2(185.37,153.22) 185.4,153.22 U1.H30 ; v2(144.24,155.91) 143.35,155.02 143.35,150.88 143.99,150.24 144.49,150.24 R24.2
  BOTTOM w0.356: v2(144.24,155.91) 144.49,156.16 R25.2 ; R8.2 146.15,162.64 v2(145.64,162.13) 145.13,162.64 R7.1
+1.0V_VCCST_VCCSFR:
  vias: v2(198.09,157.81) v2(198.09,157.18)
+1.0V_VCCSTG: length 78.5
  TOP w0.097: v1(187.45,152.07) 186.38,152.07 v2(186.37,152.06)
  TOP w0.305: C944.2 185.25,151.35 C948.2 C947.2 185.33,152.06 v2(186.37,152.06)
  IN03 w0.254: v2(146.65,153.24) 145.89,154 145.89,158.83 148.05,160.99 165.58,160.99 167.61,158.96 181.07,158.96 181.96,158.07 181.96,152.86 182.98,151.84 185.26,151.84 185.48,152.06 v2(186.37,152.06)
  IN10 w0.305: v2(135.4,146) 134.72,146.69 134.72,148.54 134.97,148.8 142.59,148.8 146.65,152.86 v2(146.65,153.24)
  BOTTOM w0.254: v2(186.37,152.06) 186.37,152.26 186.17,152.46 U1.G30 ; R11.2 v2(146.65,153.24)
  BOTTOM w0.305: U1.H29 185.4,151.67 185.78,152.06 v2(186.37,152.06)
  BOTTOM w0.508: R60.2 134.46,145.52 134.79,145.85 135.25,145.85 v2(135.4,146)
  vias: v2(197.7,159.35) v2(197.68,158.71)
+1.0V_VCCSTG_RC: length 213.6
  IN05 w0.091: v2(85.44,29.85) 85.01,29.42 80.74,29.42 80.52,29.64 74.43,29.64 71.54,26.75 64.87,26.75 63.11,28.51 57.9,28.51 56.86,29.54 56.33,29.54 50.85,35.02 50.85,38.61 v2(50.26,39.2)
  IN08 w0.091: v2(114.78,126.83) 114.27,126.32 111.6,126.32 110.2,124.92 110.2,120.48 103.6,113.87 103.6,111.71 101.31,109.43 97.3,109.43 83.59,95.71 81.12,95.71 80.47,95.06 80.47,90.11 79.75,89.39 78.61,89.39 78.2,88.98 78.2,82.07 77.58,81.45 77.58,77.3 77.19,76.92 77.19,69.03 78.84,67.39 79.91,67.39 80.61,66.68 80.61,65.36 80.36,65.1 80.36,61.67 80.61,61.42 80.61,54.18 82.39,52.4 82.39,37.8 85.13,35.06 85.13,30.16 v2(85.44,29.85)
  IN10 w0.091: v2(114.78,126.83) 114.27,127.33 114.27,127.97 114.52,128.22 131.29,128.22 133.95,130.89 133.95,132.29 139.29,137.62 139.29,140.34 v2(135.4,144.22)
  BOTTOM w0.097: R836.2 50.59,39.2 v2(50.26,39.2) ; U59.2 137.91,146.84 C248.2 137.84,145.82 136.24,144.22 v2(135.4,144.22) R60.1
+1.0VALW: length 416.4
  TOP w0.305: R205.2 256.97,60.48 257.85,61.37 R596.1
  TOP w0.356: R596.1 257.85,62.21 258.57,62.92 259.41,62.92 259.94,63.44 259.94,67.52
  TOP w0.381: v2(51.53,8.97) 51.78,8.72 PR1403.2
  TOP w0.457: C601.2 v2(137.81,149.81)
  IN03 w0.381: v2(51.53,8.97) 52.37,8.13 58.8,8.13 59.18,8.51 59.18,12.83 v2(59.94,13.59)
  IN08 w0.305: v2(184.12,193.25) 184.65,193.78 189.61,193.78 190.37,194.54 191.71,194.54 192.37,193.88 195.74,193.88 195.95,193.67 195.95,193.36 199.4,189.9 199.4,184.28 198.09,182.96 198.09,173.64 199.61,172.11 199.61,166.83 200.76,165.69 200.76,155.53 v2(203.17,153.11)
  IN08 w0.508: v2(119.35,52.86) 117.88,52.86 117.19,53.55 114.14,53.55 111.6,56.09 103.7,56.09 101.95,57.83 101.95,59.64 106.14,63.83 106.14,65.36 110.27,69.49 110.27,75.71 112.24,77.68 114.01,77.68 114.78,78.44 114.78,93.17 113.13,94.82 113.13,98 121.89,106.76 136.87,106.76 143.73,113.62 143.73,132.29 141.26,134.76 141.26,140.99 139.41,142.83 139.41,148.42 138.02,149.81 v2(137.81,149.81)
  IN10 w0.305: v2(184.12,193.25) 184.12,193.5 183.84,193.78 171.9,193.78 169.77,195.91 166.21,195.91 164.79,194.49 158.31,194.49 156.43,192.61 154.4,192.61 153.26,191.47 153.26,181.05 151.99,179.78 151.99,176.99 151.1,176.1 151.1,173.69 148.43,171.02 140.68,171.02 140.3,170.64 140.3,163.78 142.08,162 142.08,149.69 141.62,149.23 138.6,149.23 138.02,149.81 v2(137.81,149.81)
  IN10 w0.381: v2(119.35,52.86) 119.35,52.45 114.9,48.01 114.9,42.5 106.9,34.5 106.9,27.64 105.76,26.5 99.01,26.5 94.31,21.8 91.03,21.8 90.01,22.81 79.85,22.81 79.47,23.19 75.8,23.19 69.32,16.71 67.89,16.71 66.98,15.8 62.15,15.8 v2(59.94,13.59)
  IN10 w1.016: 216.76,131.4 217.14,131.78 217.14,133.94
  IN10 w1.524: 212.57,131.02 211.55,132.03 211.55,134.06
  IN10 w2.54: 218.54,87.33 219.93,87.33 221.84,85.42 ; 215.11,130.38 215.11,124.92
  BOTTOM w0.305: v2(137.81,149.81) 138.14,149.81 138.56,149.4 U59.5
  vias: v1(261.72,70.56) v2(207.87,156.8) v2(207.87,156.04) v2(223.49,81.05) v2(223.49,79.86) v2(224.25,81.05) v2(224.25,79.86)
+1.0VALW_PCH: length 7.7
  TOP w0.508: 254.48,60.4 254.48,58.37 254.73,58.12 255.62,58.12 256,57.74 256,56.84 256.43,56.41 256.96,56.41 257.45,56.9 C2693.2 L39.1
  vias: v1(254.6,74.25) v2(253.79,66.78) v2(254.6,66.75)
+1.0VG: length 6.8
  BOTTOM w0.254: PR719.2 PR717.1 v1(219.17,161.12) 219.17,160.48 217.65,158.96
+1.0VP: length 10.7
  BOTTOM w0.254: v2(264.2,57.76) 264.2,57.28 267.43,54.05 267.43,50.4 266.92,49.89 PR506.1 PR508.1
  vias: v1(259.43,57.94)
+1.2V_BST: length 3.8
  TOP w0.254: 113.13,89.36 113,89.49 PU401.18
  TOP w0.508: 113.13,89.36 113.89,89.36 v1(114.31,88.94) 114.4,88.85 PR401.1
+1.2V_CPU_VDDQ: length 16.1
  BOTTOM w0.254: v2(171.28,136.42) U1.AG9 ; v2(163.82,133.74) 164.14,134.07 U1.AR6 U1.AP6 165.34,134.33 U1.AP7 ; v2(178.89,133.74) 179.21,134.07 U1.T6 ; U1.AW6 161.63,134.07 v2(161.29,133.73) 160.95,134.07 U1.AY6 ; v2(173.09,138.3) U1.AE12 ; U1.AJ12 v2(168.54,137.69) U1.AL11 ; U1.J6 185.1,133.97 184.46,133.97 U1.K6 184.13,134.3 183.75,134.3 183.52,134.07 U1.L6 ; v2(163.05,137.69) 163.34,137.98 U1.AT12 163.64,138.11 164.29,138.11 U1.AR12 ; U1.AG5 170.9,133.42 171.2,133.71 171.21,133.71 171.29,133.71 v2(171.35,133.7) 171.41,133.7 171.69,133.42 U1.AF5 171.88,133.51 171.88,133.97 U1.AF6
  BOTTOM w0.305: v2(184.86,137.67) 184.77,137.67 U1.K12 184.3,138.15 183.8,138.15 U1.L12 ; U1.AA6 176.3,133.74 v2(176.37,133.74) 176.7,134.07 U1.W6 ; U1.J6 185.27,134.07 v2(185.6,133.73) 185.5,133.73 185.2,133.43 U1.J5 ; U1.R6 U1.T6
  vias: v1(164.56,119.97) v1(181.07,120.22)
+1.2V_FB: length 4.4
  TOP w0.254: PR410.2 104.9,90.81 PR408.2 PC413.2 PR413.1 108.25,90.81 108.77,90.29 PU401.6
+1.2V_LG: length 12.6
  TOP w0.305: 111.26,87.26 PU401.15
  TOP w0.508: v2(111.09,86.69) 111.09,87.09 111.26,87.26
  IN03 w0.508: v2(111.09,86.69) 110.7,86.69 110.36,86.36 110.36,81.28 110.87,80.77 v2(114.14,80.77)
  BOTTOM w0.508: PQ401.8 113.97,81.49 114.22,81.23 114.22,80.85 v2(114.14,80.77)
+1.2V_TON: length 2
  TOP w0.254: PU401.9 108.41,89.09 108.17,88.85 PR412.2
+1.2V_UG: length 6.2
  TOP w0.305: PU401.17 112.57,89.09 112.71,88.95
  BOTTOM w0.457: PR402.2 109.32,87.2 v1(110.33,88.22)
  BOTTOM w0.508: v1(110.33,88.22) 111.73,88.22 111.98,88.47 v2(113,88.47) v2(113.63,88.47)
+1.2V_UGR: length 10.3
  IN08 w0.508: v2(107.8,81.53) v2(107.16,81.53) 106.3,82.4 106.3,86.45 v2(107.84,87.99)
  BOTTOM w0.381: PR402.1 v2(107.84,87.99)
  BOTTOM w0.508: v2(107.16,81.53) v2(107.8,81.53) 107.84,81.49 PQ401.1
+1.2V_VDDQ: length 285.7
  TOP w0.254: v2(178.09,76.91) 177.58,76.91 177.35,76.69 JDIMM4.178 ; JDIMM4.75 149.6,64.82 v2(149.83,64.6) ; v2(192.88,64.6) 193.1,64.81 JDIMM4.241 ; JDIMM4.163 173.6,64.77 173.45,64.62 ; v2(162.02,64.6) 161.6,65.02 JDIMM4.123 ; JDIMM4.111 158.6,64.86 v2(158.34,64.6) ; v2(107.87,94.01) C426.1 109.51,94.58 U56.5 ; v2(148.38,76.91) 149,76.91 149.4,77.31 JDIMM2.75 ; v2(134.27,76.28) 133.85,75.86 JDIMM4.12 ; JDIMM4.220 187.85,76.77 187.99,76.91 v2(188.5,76.91) ; v2(138.35,76.91) 138.72,76.91 138.9,77.1 JDIMM2.33 ; v2(144.18,88.98) 144.18,88.85 144.15,88.83 JDIMM2.54 ; PR1407.2 119.6,70.39 ; JDIMM4.153 171.1,64.6 ; JDIMM2.178 177.15,89.34 176.88,89.61 v2(176.44,89.61) ; JDIMM2.241 192.9,77.21 193.2,76.91 v2(193.71,76.91) ; JDIMM4.159 172.6,64.6 ; 182.98,64.6 182.6,64.97 JDIMM4.199 ; v2(186.6,89.61) 186.91,89.61 187.65,88.88 JDIMM2.220 ; JDIMM4.135 v2(164.6,64.6) ; JDIMM4.147 169.6,64.6 ; JDIMM4.129 v2(163.1,64.6) ; v2(134.27,89.74) 133.65,89.12 JDIMM2.12 ; JDIMM2.199 182.4,77.3 182.79,76.91 v2(183.29,76.91) ; 155.16,89.61 154.65,89.1 JDIMM2.96 ; v2(161,64.6) 160.75,64.6 160.1,65.25 JDIMM4.117 ; v2(155.61,76.86) 155.05,76.86 154.85,76.67 JDIMM4.96 ; JDIMM4.141 v2(166.1,64.6) ; v2(144.18,76.28) 144.35,76.11 JDIMM4.54
  TOP w0.305: JDIMM4.118 160.35,75.44 160.81,75.9 160.81,76.66 160.61,76.86 v2(160.18,76.86) 159.73,76.86 159.23,76.36 159.23,75.89 158.85,75.52 JDIMM4.112 ; JDIMM2.147 169.4,78.01 168.89,77.5 v2(168.56,77.5) ; JDIMM2.141 165.9,77.81 165.59,77.5 v2(164.75,77.5) 164.4,77.85 JDIMM2.135 ; v2(160.18,77.5) 158.9,77.5 158.4,77.99 JDIMM2.111 ; v2(160.18,77.5) 160.18,77.88 159.9,78.16 JDIMM2.117 ; v2(160.18,77.5) 161.02,77.5 161.4,77.88 JDIMM2.123 ; JDIMM2.124 161.65,88.74 161.89,88.98 v2(162.72,88.98) 163.15,88.55 JDIMM2.130 ; JDIMM2.148 169.65,88.74 169.89,88.98 v2(170.59,88.98) 170.92,88.98 171.15,88.75 JDIMM2.154 ; JDIMM4.154 171.35,75.9 170.97,76.28 v2(170.59,76.28) 170.21,76.28 169.85,75.92 JDIMM4.148 ; JDIMM2.163 173.4,77.82 173.13,77.55 v2(172.5,77.55) 172.4,77.65 JDIMM2.159 ; v2(157.77,89.61) 158.21,89.61 158.65,89.17 JDIMM2.112 ; v2(160.18,88.98) 160.15,88.95 JDIMM2.118 ; v2(170.59,77.55) 170.9,77.86 JDIMM2.153 ; JDIMM4.33 139.1,64.92 v2(138.78,64.6) ; JDIMM2.136 164.65,88.88 v2(164.75,88.98) ; v2(166.66,88.98) 166.41,88.98 166.15,88.73 JDIMM2.142 ; JDIMM4.136 164.85,76.13 v2(164.75,76.23) ; v2(172.5,88.98) 172.65,88.83 JDIMM2.160 ; JDIMM2.129 162.9,77.68 v2(162.72,77.5) ; v2(172.5,75.8) 172.85,75.44 JDIMM4.160 ; JDIMM4.130 163.35,75.6 v2(162.72,76.23) 162.16,76.23 161.85,75.92 JDIMM4.124 ; JDIMM4.142 166.35,75.92 v2(166.66,76.23) ; v2(155.61,89.61) 155.16,89.61
  TOP w0.356: PC820.1 PR440.2
  TOP w0.381: v2(105.76,95.46) 105.63,95.46 105.05,94.87 PC820.1
  IN10 w0.381: v2(105.76,95.46) 105.89,95.46 107.33,94.01 v2(107.87,94.01) 108.55,94.69 110.97,94.69 115.67,99.39 v2(123.67,99.39)
  BOTTOM w0.178: 141.07,89.64 141.07,89.01 140.57,88.51 JDIMM1.33
  BOTTOM w0.254: v2(166.66,88.98) 166.34,88.98 166.07,88.71 JDIMM1.135 ; JDIMM1.117 161.57,88.78 161.77,88.98 v2(162.72,88.98) 163.07,88.63 JDIMM1.123 ; 178.66,64.6 179.05,64.99 JDIMM3.178 ; JDIMM1.220 189.32,77.1 189.14,76.91 v2(188.5,76.91) ; JDIMM3.199 184.3,76.67 184.06,76.91 v2(183.29,76.91) ; v2(146.21,77.55) 145.82,77.94 JDIMM1.54 ; 173.45,64.62 173.6,64.62 173.96,64.98 174.34,64.98 174.55,65.19 JDIMM3.160 ; v2(162.02,64.6) 162.02,65.02 162.05,65.04 JDIMM3.118 ; JDIMM3.241 194.8,76.46 194.34,76.91 v2(193.71,76.91) ; JDIMM3.112 160.55,64.8 160.75,64.6 v2(161,64.6) ; v2(164.6,64.6) 165.05,65.04 JDIMM3.130 ; JDIMM3.136 166.55,65.04 166.35,64.84 v2(166.1,64.6) ; JDIMM3.220 189.55,64.82 v2(189.33,64.6) ; 171.1,64.6 171.55,65.04 JDIMM3.148 ; JDIMM3.33 140.8,75.95 141.13,76.28 141.13,76.66 140.88,76.91 v2(140.37,76.91) ; JDIMM1.159 174.07,88.62 173.58,89.11 172.63,89.11 v2(172.5,88.98) 172.57,88.91 JDIMM1.153 ; JDIMM3.12 135.55,64.83 v2(135.73,64.65) ; v2(160.18,88.98) 160.07,88.87 JDIMM1.111 ; JDIMM3.75 151.3,76.52 150.91,76.91 v2(150.27,76.91) ; v2(178.09,76.91) 178.59,76.91 178.82,77.14 JDIMM1.178 ; v2(183.29,89.61) 183.74,89.61 184.07,89.28 JDIMM1.199 ; v2(170.59,88.98) 171.07,88.5 JDIMM1.147 ; v2(136.18,76.91) 135.67,76.91 135.32,77.26 JDIMM1.12 ; JDIMM1.75 151.07,89.39 150.84,89.61 v2(150.27,89.61) ; v2(167.86,64.6) 168.05,64.78 JDIMM3.142 ; 194.28,89.87 194.28,89.14 194.57,88.85 JDIMM1.241 ; v2(164.75,88.98) 164.57,88.8 JDIMM1.129 ; JDIMM3.154 173.05,65.04 172.6,64.6 ; JDIMM3.54 146.05,64.8 v2(145.85,64.6) ; JDIMM1.96 156.32,77.22 155.96,76.86 v2(155.61,76.86) ; JDIMM3.96 156.55,64.84 v2(156.31,64.6) ; v2(168.56,88.98) 167.74,88.98 167.57,88.81 JDIMM1.141 ; JDIMM1.163 175.07,89.77 174.47,90.38 v2(174.4,90.38) ; JDIMM3.159 174.3,75.29 173.9,75.7 173.9,76.28 174.1,76.48 174.38,76.48 v2(174.4,76.51) ; JDIMM3.124 163.55,65.04 v2(163.1,64.6)
  BOTTOM w0.305: v2(160.18,76.86) 160.61,76.86 160.81,76.66 160.81,75.9 160.3,75.38 JDIMM3.111 ; JDIMM1.112 160.32,77.64 v2(160.18,77.5) ; JDIMM1.154 172.82,77.87 v2(172.5,77.55) 173.44,77.55 174.32,78.43 JDIMM1.160 ; JDIMM3.163 175.3,76.02 174.84,76.48 174.43,76.48 v2(174.4,76.51) ; JDIMM3.153 172.8,75.5 v2(172.5,75.8) ; v2(170.59,77.55) 171.32,78.28 JDIMM1.148 ; JDIMM1.124 163.32,77.77 163.05,77.5 v2(162.72,77.5) 162.14,77.5 161.82,77.82 JDIMM1.118 ; v2(166.66,77.5) 166.32,77.84 JDIMM1.136 ; JDIMM1.130 164.82,77.57 v2(164.75,77.5) ; JDIMM3.117 161.8,76 162.03,76.23 v2(162.72,76.23) 163.3,75.65 JDIMM3.123 ; JDIMM3.135 166.3,75.87 v2(166.66,76.23) 167.47,76.23 167.8,75.9 JDIMM3.141 ; v2(164.75,76.23) 164.8,76.18 JDIMM3.129 ; v2(170.59,76.28) 171.1,76.28 171.3,76.08 JDIMM3.147 ; JDIMM1.142 167.82,78.24 v2(168.56,77.5)
  BOTTOM w0.457: R93.2 169.39,62.82 ; R89.2 165.96,90.25 ; R84.2 161.77,62.94
  vias: v1(169.64,96.6) v2(120.11,70.56) v2(120.49,68.02) v2(120.75,69.29) v2(121.13,70.56) v2(121.38,68.02) v2(122.02,70.56) v2(122.02,69.29) v2(122.27,68.02) v2(123.03,70.56) v2(123.16,69.29) v2(123.16,68.02) v2(123.92,70.56) v2(124.25,69.29) v2(124.25,68.02) v2(124.94,70.56) v2(125.03,69.3) v2(125.01,68.04) v2(125.8,69.32) v2(125.8,68.05) v2(126.61,69.32) v2(126.61,68.05) v2(126.66,70.26) v2(127.43,70.29) v2(127.38,69.35) v2(127.38,68.08) v2(132.11,89.74) v2(132.11,76.91) v2(136.18,89.61) v2(138.34,89.61) v2(139.8,63.71) v2(140.37,89.61) v2(141.32,63.53) v2(142.27,89.61) v2(142.27,76.91) v2(142.59,63.53) v2(144.37,63.53) v2(145.64,63.53) v2(146.21,89.61) v2(147.42,63.53) v2(148.37,89.61) v2(148.69,63.53) v2(150.46,63.53) v2(151.73,63.53) v2(152.18,89.61) v2(153.51,63.53) v2(154.78,63.53) v2(156.56,63.53) v2(157.83,63.53) v2(159.61,63.53) v2(160.88,63.53) v2(162.48,63.53) v2(162.72,89.61) v2(162.72,76.86) v2(163.75,63.53) v2(165.7,63.53) v2(166.66,89.61) v2(166.66,76.86) v2(166.97,63.53) v2(168.56,89.61) v2(168.56,76.86) v2(168.56,76.23) v2(170.59,89.61) v2(170.59,76.91) v2(171.8,63.53) v2(172.5,89.61) v2(173.07,63.53) v2(176.63,63.53) v2(177.9,63.53) v2(178.09,89.61) v2(179.74,89.61) v2(179.74,76.91) v2(179.67,63.53) v2(180.94,63.53) v2(181.39,89.61) v2(181.39,76.91) v2(182.21,63.53) v2(183.99,63.53) v2(184.94,89.61) v2(184.94,76.91) v2(185.26,63.53) v2(186.6,76.91) v2(187.04,63.53) v2(188.31,63.53) v2(188.5,89.61) v2(190.09,63.53) v2(190.15,89.61) v2(191.36,63.53) v2(191.8,89.61) v2(193.14,63.53) v2(193.71,89.61) v2(194.41,63.53) v2(195.29,63.53)
+1.2VDDQ: length 33.8
  TOP w0.254: PR441.2 v2(103.22,91.77) ; v2(109.44,91.85) 109.66,91.63 PU401.5
  TOP w0.305: 112.95,89.92 112.92,89.89 PU401.19
  IN03 w0.381: v2(109.44,91.85) 114.45,91.85 117.7,88.6 123.29,88.6 124.56,87.33 124.56,82.63 v2(122.65,80.72)
  IN10 w0.381: v2(103.22,91.77) 103.52,91.77 104.16,92.41 108.55,92.41 109.11,91.85 v2(109.44,91.85)
  vias: v1(113.38,89.97) v2(113.13,90.5) v2(113.76,90.5)
+1.05V_DGPU_PGOOD: length 205.5
  TOP w0.097: PR722.1 v2(219.93,165.18) ; D51.2 289.56,70.41 289.15,70.82 v2(289.15,70.98) 289.15,71.1 D70.1
  IN08 w0.091: v2(289.15,70.98) 288.64,71.48 288.64,72.34 287.88,73.1 284.45,73.1 283.05,71.71 280.26,71.71 279.5,70.95 279.5,68.66 279.11,68.28 276.97,68.28 276.33,68.92 276.33,70.83 276.96,71.45 276.96,74.9 276.21,75.64 274.8,75.64 273.91,74.76 273.78,74.76 272.26,73.23 265.4,73.23 263.49,75.14 259.18,75.14 258.92,75.39 253.46,75.39 251.63,73.56 250.74,73.56 249.52,72.34 244.44,72.34 244.32,72.22 241.14,72.22 240.89,72.47 238.47,72.47 232.76,78.18 221.96,78.18 221.71,78.44 216,78.44 212.66,81.77 212.66,93.84 211.56,94.94 211.56,101.95 213.22,103.62 216.68,103.62 217.92,104.86 217.92,107.12 217.7,107.34 217.7,111.15 216.12,112.73 216.12,115.65 216.38,115.9 216.38,117.61 217.66,118.89 220.38,118.89 220.57,119.08 220.57,120.86 220.82,121.11 221.2,121.11 222.22,122.13 222.22,122.51 221.86,122.86 216.91,122.86 211.96,127.82 211.96,146.21 212.56,146.8 212.56,151.08 212.06,151.57 212.06,155.15 213.2,156.29 217.77,156.29 218.92,157.43 218.92,164.16 v2(219.93,165.18)
+1.8V: length 238.2
  TOP w0.457: v2(290.67,24.65) R284.2
  IN03 w0.508: v2(264.89,42.75) 264.89,42.12 267.18,39.83 267.18,35.39 268.07,34.5 268.07,28.61 269.62,27.05 271.32,27.05 v2(272.51,25.86)
  IN05 w0.508: v2(116.55,41.1) 115.92,40.47 115.92,39.2 116.17,38.94 116.17,38.3 115.76,37.88 113.32,37.88 110.89,35.45 100.8,35.45 97.08,39.18 97.08,40.26 92.55,44.78 89.76,44.78 88.87,45.67 v2(86.33,45.67)
  IN08 w0.508: v2(290.67,24.65) 289.08,24.65 288.51,24.08 274.29,24.08 v2(272.51,25.86) ; v2(264.89,42.75) 263.49,44.15 260.15,44.15 257.06,41.06 257.06,40.8 256.49,40.23 253.92,40.23 253.16,41 215.11,41 212.19,43.92 204.29,43.92 201.59,41.22 191.23,41.22 189.07,43.39 170.15,43.39 168.5,45.03 118.99,45.03 116.55,42.6 v2(116.55,41.1)
  vias: v1(84.8,48.47) v2(85.57,48.52) v2(86.07,58.25) v2(86.07,57.61) v2(86.2,48.52) v2(86.84,58.25) v2(86.84,57.61) v2(86.84,48.52) v2(87.6,48.52)
+1.8V_AON: length 824
  TOP w0.254: R980.1 245.86,106.66 v2(245.86,105.9) 245.66,105.9 245.54,106.02 244.88,106.02 244.32,105.46 R990.1 ; C1333.1 303.7,70.11 U63.5 ; R1002.1 245.66,114.3 246.22,113.74 248.76,113.74 249,113.51 250.94,113.51 251.05,113.62 251.56,113.62 252.7,112.48 252.7,108.97 R983.2 252.19,108.11 250.97,106.89 249.27,106.89 249.07,107.09 R986.1 248.38,107.52 v2(248.25,107.65) 248,107.39 248,106.51 246.86,105.36 246.86,104.09 246.35,103.58 246.35,102.06 246.6,101.81 246.6,100.84 246.22,100.46 R987.1 ; 204.18,127.71 203.8,127.33 202.23,127.33 R995.1 ; 204.18,127.71 204.57,127.33 205.07,127.33 205.48,127.74 207.16,127.74 207.56,127.33 R2264.2 ; 204.18,127.71 204.18,128.22 204.69,128.73 205.45,128.73 205.76,128.43 207.92,128.43 209.26,127.08 212.69,127.08 215.49,124.29 219.3,124.29 219.55,124.03 219.55,122.89 ; R993.1 66.14,81.36 v2(66.77,81.99) ; C1339.1 303.57,73.61 303.77,73.81 U62.5 ; v2(244.32,107.78) 244.06,108.03 Q93.2 244.06,108.77 R982.1 ; v2(239.67,106.81) 239.67,106.96 239.29,107.34 R2154.1 R2150.1 ; R1016.1 v2(68.04,75.64) ; v2(242.46,107.65) 242.11,108 R2152.1
  TOP w0.305: v2(299.31,80.85) 299.03,81.13 290.7,81.13 290.04,80.47 290.04,78.69 289.53,78.18 285.46,78.18 284.58,79.07 v1(280.89,79.07) 272.38,79.07 270.99,77.68 270.99,74.25 272.51,72.72 275.94,72.72 276.37,73.16 R2183.1
  TOP w0.356: C1339.1 v2(304.26,73.23) ; v2(248.25,107.65) 248.38,107.78 R999.1 R796.1 ; R962.1 219.17,116.35 218.49,117.03 v2(218.49,117.21) ; v2(300.83,196.04) 298.67,198.2 297.28,198.2 v2(296.64,197.56) ; C1333.1 v2(303.7,68.61)
  IN03 w0.305: v2(215.74,74.63) 215.49,74.37 202.66,74.37 202.15,74.88 114.9,74.88 114.4,74.37 99.66,74.37 97.76,76.28 96.36,76.28 92.93,79.71 85.44,79.71 84.68,78.95 73.63,78.95 70.96,76.28 68.68,76.28 v2(68.04,75.64) ; v2(246.57,108.19) 246.6,108.16 247.75,108.16 v2(248.25,107.65)
  IN03 w0.356: v2(246.57,108.19) 244.73,108.19 v2(244.32,107.78) 244.19,107.65 v2(242.46,107.65) 241.14,107.65 240.3,106.81 v2(239.67,106.81) 239.67,107.09 238.6,108.16 233.01,108.16 231.36,109.81 231.36,112.47 229.46,114.38 226.54,114.38 224.63,112.47 218.92,112.47 218.54,112.86 218.54,113.62 218.03,114.13 218.03,115.9 218.49,116.36 v2(218.49,117.21) ; v2(299.31,80.85) 299.94,81.49 299.94,82.38 299.56,82.76 289.27,82.76 285.59,86.44 v2(280.13,86.44) ; v2(206.72,195.38) 210.05,195.38 v2(211.55,193.88)
  IN03 w0.508: v2(220.44,121.75) 219.68,121.75 219.17,121.24 219.17,118.7 218.49,118.02 v2(218.49,117.21)
  IN05 w0.356: v2(206.72,195.38) 206.72,194.93 208.38,193.28 208.38,192.1 210.8,189.68 210.8,173.82 209.14,172.16 209.14,168.61 208.38,167.85 208.38,165.43 207.74,164.8 207.74,160.1 207.11,159.46 207.11,152.86 207.68,152.29 209.2,152.29 211.48,150.01 v2(212.13,150.01)
  IN08 w0.356: v2(277.84,69.42) 278.1,69.68 278.1,75.62 276.8,76.91 274.03,76.91 272.51,75.39 271.37,75.39 269.97,76.79 258.79,76.79 256.89,78.69 252.57,78.69 251.81,77.93 247.75,77.93 247.24,78.44 240.76,78.44 239.49,79.71 227.93,79.71 225.52,82.12 222.98,82.12 221.08,80.22 v2(220.44,80.22) 220.06,80.22 215.61,84.66 215.61,91.27 214.98,91.9 214.98,94.06 213.46,95.58 213.46,96.66 213.02,97.09 213.02,99.39 213.81,100.18 213.81,101.48 214.14,101.81 217.52,101.81 219.42,103.71 219.42,111.71 218.54,112.6 218.54,113.39 217.85,114.07 217.85,116.58 v2(218.49,117.21) ; v2(303.7,68.61) 304.26,69.17 v2(304.26,73.23) ; v2(66.77,81.99) 67.28,81.49 67.28,79.58 66.9,79.2 66.9,77.3 68.04,76.15 v2(68.04,75.64) ; v2(220.44,122.38) 211.37,122.38 208.38,125.38 208.38,126.7 209.52,127.84 209.52,144.61 212,147.09 212,149.88 v2(212.13,150.01)
  IN10 w0.356: v2(281.65,183.59) 278.61,183.59 276.75,185.45 272.82,185.45 271.24,187.02 219.17,187.02 212.31,193.88 v2(211.55,193.88) ; v2(307.69,80.98) 309.85,83.14 309.85,93.55 309.29,94.11 309.29,97.56 310.28,98.56 310.28,107.6 v2(309.72,108.16)
  BOTTOM w0.254: PR3551.1 309.47,108.41 v2(309.72,108.16) ; PR27.2 297.92,196.93 297.28,196.93 v2(296.64,197.56) ; v2(206.72,195.38) 206.39,195.71 R2271.1 ; 227.93,122.76 230.22,122.76 230.85,123.4 230.85,125.48 R2255.1 R2254.1 ; 227.93,122.76 222.73,122.76 ; 227.93,122.76 227.93,125.23 R2256.1 ; R977.1 R974.1 242.84,108.84 242.46,108.46 v2(242.46,107.65) ; v2(300.83,196.04) 301.1,195.77 PR32.2 ; G2.BC14 v3(242.48,121.97) ; R1000.1 R975.1 246.73,108.34 v2(246.57,108.19) ; v3(243.25,121.49) 243.25,122 242.99,122.27 G2.BB14 ; v2(244.32,107.78) 244.32,107.54 245.86,106 v2(245.86,105.9) ; R2251.1 222.88,117.71 218.88,117.71 218.49,117.31 v2(218.49,117.21)
  BOTTOM w0.3: G2.BA10 v3(243.29,119.17)
  BOTTOM w0.305: 305.4,79.71 305.4,78.06 306.55,76.91 306.55,75.52 v2(304.26,73.23) ; 305.4,79.71 305.02,80.09 301.85,80.09 300.83,81.11 299.56,81.11 v2(299.31,80.85) ; 305.4,79.71 306.42,79.71 v2(307.69,80.98)
  BOTTOM w0.356: U2021.7 284.83,85.17 ; 284.83,85.17 284.83,86.19 284.58,86.44 U2021.3 ; 284.83,85.17 284.83,84.03 ; v2(281.65,183.59) 281.86,183.8 PR3561.1 291.1,192.74 295.93,197.56 v2(296.64,197.56) ; v2(215.74,74.63) 215.74,76.03 218.23,78.51 218.23,79.53 218.92,80.22 v2(220.44,80.22) ; v2(277.84,69.42) 277.84,69.17 277.08,68.41 276.42,68.41 275.43,67.42 275.43,63.83 278.61,60.66 289.91,60.66 294.74,55.83 299.69,55.83 300.7,56.85 302.48,56.85 304.01,58.37 304.01,68.28 303.7,68.58 v2(303.7,68.61) ; U2021.8 284.96,83.9 284.83,84.03 ; 284.83,84.03 284.83,83.26 284.45,82.88 281.15,82.88 280.82,83.21 R944.2
  BOTTOM w0.508: U2021.3 282.54,86.44 282.11,86.87 C1401.1 C1402.1 280.56,86.87 v2(280.13,86.44)
  vias: v2(221.08,122.38) v2(221.08,121.75) v2(221.71,122.38)
+1.8V_MAIN: length 180.7
  TOP w0.254: R963.2 218.41,114.2 218.41,116.03 217.98,116.46 217.98,118.78 v2(217.43,119.33) ; v2(288.26,169.12) 288.59,169.45 R2267.2
  IN03 w0.356: v2(221.08,124.03) 219.42,124.03 218.03,122.63 218.03,120.35 217.43,119.75 v2(217.43,119.33)
  IN08 w0.356: v2(212.69,132.62) 212.69,145.88 213.33,146.51 v2(213.33,150.07)
  IN10 w0.356: v2(288.26,169.12) 288.77,169.62 288.77,171.4 290.29,172.93 290.29,176.74 286.99,180.04 286.99,181.05 285.72,182.32 283.38,182.32 282.75,182.96 278.23,182.96 276.5,184.69 272.69,184.69 270.99,186.39 214.34,186.39 213.2,185.25 213.2,183.21 211.68,181.69 211.68,176.15 213.25,174.58 217.14,174.58 222.22,169.5 222.22,155.4 221.2,154.38 220.06,154.38 219.3,155.15 213.58,155.15 213.2,154.77 213.2,150.19 v2(213.33,150.07)
  BOTTOM w0.203: v3(242.48,130.37) 242.59,130.37 G2.BB26 242.99,130.67 v3(243.23,130.42)
  BOTTOM w0.254: v3(243.23,134.62) 243.13,134.62 G2.BB32 ; G2.BD27 241.49,131.37 v3(241.79,131.67) ; G2.BC32 v3(242.48,134.57) ; G2.BC26 v3(242.48,130.37) ; v3(242.48,133.77) 242.19,133.47 G2.BC30 ; G2.BC27 242.19,131.37 v3(242.48,131.67) ; G2.BC29 v3(242.48,132.47) ; G2.BB27 243.14,131.62 v3(243.23,131.62) ; G2.BD30 v3(241.79,133.77)
  BOTTOM w0.3: G2.BB29 243.13,132.52 v3(243.23,132.52)
  BOTTOM w0.356: C677.1 v2(227.68,128.98) ; C676.1 v2(223.87,128.98)
  vias: v1(221.96,123.5) v2(213.33,132.62) v2(214.09,132.62) v2(214.85,132.62) v2(215.49,132.62) v2(216.12,132.62) v2(221.71,124.03) v2(222.35,124.03)
+1.8V_SW:
  vias: v1(132.18,126.44) v2(132.43,125.68) v2(132.43,124.92) v2(133.06,127.21) v2(133.06,126.44) v2(133.06,125.68) v2(133.06,124.92) v2(133.7,125.05) v2(133.83,127.21) v2(133.83,126.44) v2(133.83,125.68) v2(206.34,123.65) v2(206.34,123.02) v2(206.98,123.65) v2(206.98,123.02)
+1.8V_SW_PGOOD: length 50.7
  TOP w0.097: PU7.B2 277.21,74.46 PC15.1 R2183.2 277.29,72.8 276.83,72.34 272.38,72.34 270.61,74.12 v1(270.61,78.44) 271.7,79.53 284.63,79.53 285.59,78.57 289.4,78.57 289.66,78.82 289.66,80.6 290.93,81.87 296.26,81.87 298.67,84.28 298.67,84.66 299.43,85.42 300.7,85.42 300.8,85.33 D2007.2
+1.8VA_AUD: length 7.6
  TOP w0.203: C300.2 289,28.12 289.4,28.53 v2(289.4,28.65) 289.4,29.06 289.13,29.33 U7.24
  TOP w0.356: v1(290.37,25.96) 290.28,26.05 R284.1 289,26.2 C301.2 C300.2
  BOTTOM w0.457: C322.2 C323.1 289.53,28.78 v2(289.4,28.65)
+1.8VALW_PCH: length 4
  TOP w0.457: C547.2 221.24,48.72 220.89,49.08 v1(220.89,49.36) 220.89,49.97 221.16,50.24 R290.2
+1.8VP: length 10.2
  BOTTOM w0.254: 126.33,124.41 126.33,126.32 127.73,127.71 127.73,132.06 PR3459.1 126.9,132.89 PR3458.2
  vias: v1(85.31,41.99) v2(85.57,43.51) v2(86.33,43.51) v2(87.09,43.51) v2(120.05,123.64) v2(120.05,122.88) v2(120.05,122.25) v2(120.05,121.61) v2(120.75,123.65) v2(120.75,122.89) v2(120.75,122.25) v2(120.75,121.62)
+1.55V_DGPU_PGOOD: length 29.1
  TOP w0.097: v2(298.55,74.76) 297.3,74.76 296.13,75.93 296.13,76.09 295.94,76.28 294.61,76.28 292.58,74.25 v1(291.94,74.25) 291.23,74.25 R1007.1
  IN08 w0.091: v2(301.59,85.8) 301.34,85.8 301.09,85.55 301.09,79.84 300.2,78.95 300.2,76.41 v2(298.55,74.76)
  BOTTOM w0.097: v2(301.59,85.8) 302.1,86.31 PR704.2
+1.55VG:
  vias: v1(279.11,99.39) v2(281.27,101.25) v2(281.27,100.41) v2(281.27,99.65) v2(281.27,98.89) v2(281.27,98.12) v2(281.27,97.49) v2(281.27,96.73) v2(281.27,95.96) v2(281.96,101.25) v2(281.96,100.41) v2(281.96,99.65) v2(281.96,98.89) v2(281.96,98.12) v2(281.96,97.49) v2(281.96,96.73) v2(281.96,95.96) v2(282.67,101.25) v2(282.67,100.41) v2(282.67,99.65) v2(282.67,98.89) v2(282.67,98.12) v2(282.67,97.49) v2(282.67,96.73) v2(282.67,95.96) v2(283.03,95.33) v2(283.03,94.69) v2(283.03,93.93) v2(283.03,93.17) v2(283.03,92.41) v2(283.41,96.73) v2(283.41,96.09) v2(283.69,101.17) v2(283.69,100.54) v2(283.66,95.33) v2(283.66,94.69) v2(283.66,93.93) v2(283.66,93.17) v2(283.66,92.41) v2(284.04,96.73) v2(284.04,96.09) v2(284.32,101.17) v2(284.32,100.54) v2(285.08,101.17) v2(285.08,100.54) v2(285.21,102.31)
+1.55VSG: length 661.8
  TOP w0.114: 269.14,166.91 269.14,164.09 ; 276.89,164.76 276.57,164.76 ; 252.12,164.21 252.12,164.51 ; 260.12,165.31 260.12,164.51 260.12,164.11 ; 277.14,164.21 277.14,164.51 ; 276.45,165.56 277.08,165.56 ; 277.97,165.56 278.61,165.56 ; 268.57,167.14 268.89,167.14 ; 270.17,167.96 270.49,167.96 ; 270.17,167.14 271.29,167.14
  TOP w0.127: 242.07,166.11 242.07,165.79 ; 260.92,166.59 260.92,167.81 ; 252.92,177.31 252.92,176.99 ; 259.87,165.56 259.55,165.56 ; 269.93,168.19 269.93,168.51 ; 252.91,165.79 252.91,166.11 ; 261.15,166.36 261.47,166.36 ; 234.87,166.91 234.87,166.59 ; 234.64,166.34 233.38,166.34 233.27,166.45 ; 260.92,165.31 260.92,164.08 ; 243.11,165.55 243.44,165.55 ; 269.93,166.91 269.93,166.59 ; 241.51,165.55 241.84,165.55 ; 253.95,175.95 254.27,175.95 ; 242.07,164.51 242.07,164.19 ; 253.15,164.75 253.47,164.75 ; 251.87,177.54 251.55,177.54 ; 268.56,167.96 268.89,167.96 ; 252.1,177.31 252.1,176.99 252.09,176.97 ; 278.16,164.76 278.49,164.76 ; 242.88,164.51 242.88,164.19 ; 252.12,174.5 252.12,175.8 ; 252.91,164.51 252.91,164.19 ; 277.93,165.79 277.93,166.11 ; 251.55,176.74 251.87,176.74 ; 261.15,165.55 261.47,165.55 ; 235.11,167.95 235.43,167.95 ; 233.84,167.15 233.46,167.15 ; 234.07,168.51 234.07,168.19 ; 251.55,165.55 251.87,165.55 ; 234.64,165.55 233.28,165.55 v3(232.87,165.15) ; 259.55,166.36 259.87,166.36 ; 277.93,164.51 277.93,164.19 ; 235.11,168.74 235.44,168.74 ; 253.95,175.14 254.28,175.14 ; 243.11,164.75 243.44,164.75 ; 269.12,168.51 269.12,168.19 ; 242.88,165.79 242.88,166.11 ; 233.27,167.71 233.27,167.39 ; 277.12,166.11 277.12,165.79 ; 253.15,165.55 253.47,165.55 ; 241.84,164.76 241.51,164.76 ; 251.87,164.76 251.55,164.76 ; 252.9,174.6 252.9,174.91 ; 251.55,175.95 251.87,175.95 ; 260.1,166.91 260.1,166.59
  TOP w0.254: v3(291.43,136.72) C2587.1 ; v3(297.43,117.73) 297.28,117.59 C2612.1 ; v3(294.5,148.14) 294.45,148.19 C2557.1 ; C2564.1 294.53,137.42 v3(294.63,137.52) ; C2491.1 259.63,171.47 v3(259.71,171.55) ; R2203.2 292.75,140.44 v3(292.23,139.91) ; v3(275.13,173.95) 275.04,174.04 C2530.1 ; C2580.1 287.75,140.4 v3(288.23,139.92) ; v3(244.32,167.15) 244.38,167.08 C2461.1 ; C2556.1 297.15,152.61 v3(297.3,152.76) ; v3(279.13,177.15) 280.27,177.15 C2519.1 ; v3(300.1,145.74) 300.24,145.6 C2537.1 ; C2525.1 279.48,165.4 v3(279.33,165.55) ; v3(267.93,173.15) 267.87,173.21 C2521.1 ; C2469.1 236.9,176.37 v3(236.87,176.35) ; C2550.1 288.95,148.99 v3(288.9,148.94) ; C2589.1 289.03,135.89 v3(289.03,136.72) ; v3(291.43,139.92) 291.62,140.11 C2570.1 ; C2586.1 297.08,132.77 v3(297.03,132.72) ; v3(270.33,171.55) 270.39,171.48 C2531.1 ; v3(258.91,168.35) 258.9,168.34 C2492.1 ; v3(291.3,145.74) 291.77,145.27 C2562.1 ; v3(299.43,135.89) 298.92,135.38 C2588.1 ; v3(291.43,113.89) 291.43,114.53 C2615.1 ; v3(253.31,171.55) 253.32,171.53 C2497.1 ; v3(279.13,173.95) 279.19,173.88 C2533.1 ; v3(288.1,145.74) 288.15,145.69 C2545.1 ; C2614.1 293.03,118.53 v3(293.03,120.28) ; v3(236.07,165.95) 236.59,165.95 237,166.36 C2471.1 ; C2552.1 293.13,157.97 v3(292.1,156.94) ; C2516.1 267.6,164.83 v3(267.93,165.15) ; v3(262.11,175.55) 262.24,175.42 C2488.1 ; C2553.1 296.88,156.96 v3(296.9,156.94) ; C2603.1 299.12,122.19 v3(299.43,121.88) ; v3(297.03,139.92) 296.58,140.36 C2575.1 ; C2571.1 297.06,127.68 C2569.1 ; C2482.1 262.85,176.41 v3(262.11,177.15) ; C2468.1 240.05,173.97 v3(240.07,173.95) ; v3(262.11,169.15) 262.17,169.21 C2489.1 263.36,168.97 C2478.1 ; C2613.1 294.58,113.14 v3(294.62,113.09) ; C2470.1 235.36,171.47 v3(235.27,171.55) ; v3(255.06,174.35) 255.11,174.3 C2490.1 ; C2551.1 288.09,156.95 v3(288.1,156.94) ; v3(291.3,148.94) 291.17,149.06 C2560.1 ; R2197.2 233.53,172.49 v3(232.87,173.15) ; v3(236.07,168.35) 236.12,168.39 C2467.1 ; v3(296.1,145.74) 295.83,145.46 R2198.2 ; C2499.1 258.89,165.97 v3(258.91,165.95) ; C2498.1 258.03,176.27 v3(258.11,176.35) ; v3(298.63,139.92) 299.53,140.82 C2573.1 ; C2453.1 232.66,168.56 v3(232.87,168.35) ; C2529.1 275.88,171.55 v3(276.73,171.55) ; C2505.1 254.14,165.92 v3(254.11,165.95) ; v3(279.28,167.15) 279.46,167.33 C2511.1 ; C2448.1 C2454.1 232.26,173.34 v3(232.87,173.95) ; v3(289.7,156.94) 289.92,157.15 C2558.1 ; v3(296.9,145.74) 297.62,145.01 C2538.1 ; v3(262.11,173.95) 262.54,173.52 R2195.2 263.2,173.51 R874.1 ; v3(232.87,175.55) 232.35,176.08 C2455.1 C2449.1
  TOP w0.356: v3(243.47,97.12) 243.39,97.04 C2659.1
  TOP w0.381: v3(246.87,96.72) 246.92,96.67 C2675.1 ; C2676.1 247,94.45 v3(246.87,94.32) ; C2645.1 v3(269.83,94.32) ; C2670.1 255.9,92.8 255.18,93.52 v3(254.87,93.52) ; v3(254.87,87.12) 255.52,87.12 C2658.1 ; v3(254.87,95.92) 255.08,95.7 C2671.1 ; v3(270.63,91.12) 270.53,91.22 C2625.1 ; v3(273.03,89.52) 273.68,90.17 R2205.2 ; 273.03,87.12 v3(273.03,87.12) 273.53,87.12 C2640.1 ; R2204.2 243.4,89.79 v3(243.67,89.52) ; v3(265.83,88.72) 265.88,88.67 C2649.1 ; C2666.1 250.57,88.47 v3(250.72,88.32) ; v3(253.27,92.72) 251.15,92.72 250.9,92.98 C2667.1 ; C2648.1 261.59,95.48 v3(261.63,95.52) ; v3(269.83,96.72) 269.8,96.75 C2643.1 ; v3(247.67,86.32) 247.77,86.42 C2679.1 ; v3(273.03,88.72) 273.98,88.72 C2638.1 ; v3(300.23,110.69) 300.37,110.55 C2601.1 ; C2660.1 242.55,88.32 242.96,88.72 v3(243.67,88.72) ; C2623.1 273.22,94.13 v3(273.03,94.32) ; v3(261.63,97.12) 261.42,97.33 C2642.1 ; C2661.1 242.69,85.52 v3(243.67,85.52)
  IN03 w0.381: v3(252.51,169.15) 252.51,169.15 253.31,169.15 v3(253.31,169.15) ; v3(252.51,169.15) v3(251.71,169.15) ; v3(252.51,169.15) v3(252.51,169.95) ; v3(264.23,86.32) 264.23,87.12 v3(264.23,87.12) 265.03,87.12 v3(265.03,87.12) ; v3(267.93,169.15) v3(268.73,169.15) v3(269.53,169.15) ; v3(246.07,92.72) v3(246.07,91.12) v3(246.07,90.32) ; v3(265.83,88.72) 265.83,88.72 v3(265.03,89.52) ; v3(263.43,94.32) 263.43,94.32 v3(263.43,93.52) 263.43,93.52 264.23,93.52 v3(264.23,93.52) ; v3(270.33,170.75) v3(270.33,171.55) v3(270.33,172.35)
  IN10 w0.356: v2(308.71,84.79) 306.04,87.46 299.94,87.46 298.29,85.8 295.24,85.8 293.59,84.15 281.65,84.15 279.88,85.93 276.7,85.93 v2(276.45,85.68)
  IN10 w0.381: v3(262.11,169.15) 262.11,169.15 v3(261.31,169.15) v3(260.51,169.15) ; v3(292.1,147.34) v3(292.1,146.54) v3(292.1,145.74) ; v3(292.9,148.14) v3(293.7,148.14) v3(294.5,148.14) v3(295.3,148.14) ; v3(241.67,169.15) 241.68,169.15 v3(242.48,169.15) v3(242.48,168.35) ; v3(259.71,171.55) v3(259.71,170.75) 259.71,169.95 v3(259.71,169.95) ; v3(276.73,166.75) v3(277.53,166.75) ; v3(271.43,93.52) v3(272.23,93.52) v3(273.03,93.52) ; v3(270.63,91.12) v3(270.63,91.92) v3(270.63,92.72) ; v3(292.23,110.69) 292.23,110.69 v3(292.23,111.49) v3(292.23,112.29) 292.22,112.29 v3(291.43,112.29) ; v3(277.53,168.35) v3(277.53,169.15) v3(276.73,169.15) ; v3(293.03,113.09) v3(293.82,113.09) v3(294.62,113.09) 295.42,113.09 v3(295.42,113.08) ; v3(292.23,131.12) v3(292.23,130.32) ; v3(270.63,90.32) v3(271.43,89.52)
  IN10 w0.4: v3(259.71,171.55) v3(259.71,172.35)
  BOTTOM w0.25: G2.L30 264.69,133.47 v3(264.98,133.77) G2.K30 ; G2.K29 v3(264.98,132.47) ; G2.L15 264.69,122.97 v3(264.98,123.27) G2.K15
  BOTTOM w0.254: U2026.F3 v3(246.07,89.52) U2026.G4 v3(246.07,90.32) ; v3(245.27,94.32) U2026.M3 v3(245.27,93.52) U2026.L2 ; v2(308.71,84.79) 308.71,90.63 310.23,92.15 PR3422.2 ; G2.M10 v3(263.58,119.77) ; U2026.R10 v3(251.67,96.72) ; U2025.G14 295.62,121.28 295.62,120.89 U2025.G13 ; U2026.H3 v3(246.07,91.12) ; G2.K12 v3(264.98,121.17) ; v3(243.67,89.52) U2026.G1 v3(244.47,89.52) U2026.G2 ; U48.H12 252.91,171.95 ; U2026.E5 v3(247.67,88.72)
  BOTTOM w0.3: G2.Y42 258.53,141.62 v3(258.53,141.52) ; G2.M43 263.66,142.34 v3(263.66,142.2) ; v3(259.44,141.52) 259.44,141.62 G2.V42 ; G2.K41 v3(264.98,140.87) ; v3(257.34,141.52) 257.34,141.62 G2.AA42 ; G2.P42 262.74,141.62 v3(262.74,141.52) ; G2.K38 v3(264.98,138.77) ; v3(261.53,141.52) 261.53,141.62 G2.R42 ; G2.K17 v3(264.98,124.07)
  BOTTOM w0.305: U60.H12 263.83,92.32 v3(263.43,92.72) ; U60.G13 263.03,93.12 v3(263.43,93.52) 263.43,93.52 U60.F12 ; v3(292.1,156.94) U2023.L14 v3(292.1,156.14) U2023.L13 ; U60.L13 262.83,90.12 262.43,90.12 U60.L14 262.23,89.92 v3(261.83,89.52) ; U60.L13 263.83,90.72 U60.K12 v3(264.23,91.12) ; U60.L13 263.43,89.52 v3(263.43,89.52) U60.M12 v3(263.43,88.72) ; v3(262.11,166.75) 261.71,167.15 U48.P1 ; U48.K12 v3(252.51,169.95) 252.11,169.55 U48.L13 ; U2022.C10 v3(240.87,165.95) ; U2024.G11 v3(292.23,131.12) U2024.F12 ; v3(300.23,128.72) 299.83,129.12 U2024.T14 ; v3(250.91,166.75) 250.91,166.75 U48.P14 ; U2022.G11 v3(241.67,169.15) U2022.F12 242.08,168.75 v3(242.48,168.35) ; v3(268.73,169.15) U55.G2 269.53,169.15 v3(269.53,169.15) 269.53,169.15 U55.F3 ; 277.93,172.75 U55.L13 278.08,172.59 278.57,172.59 U55.L14 278.73,172.75 v3(279.13,173.15) ; 277.93,172.75 v3(277.53,173.15) U55.M12 277.13,173.55 v3(277.53,173.95) ; 277.93,172.75 U55.K12 v3(276.73,171.55) ; U2024.D14 v3(289.83,128.72) 290.3,128.25 C2590.1 ; U48.L4 v3(259.71,169.95) U48.K3 v3(259.71,170.75) ; U60.T14 v3(261.83,85.52) ; v3(261.31,169.15) U48.L1 v3(262.11,169.15) ; v3(261.31,169.15) U48.L2 260.51,169.15 v3(260.51,169.15) 260.11,168.75 ; v3(261.31,169.15) U48.M1 v3(262.11,168.35) ; U2023.P1 v3(289.7,145.74) ; 272.49,178.84 272.49,176.92 v3(271.93,176.35) U55.R5 ; v3(270.33,170.75) U55.H3 v3(270.33,169.95) 270.33,169.95 U55.G4 ; U2023.N10 v3(290.5,153.74) U2023.P11 289.7,154.54 v3(289.7,154.54) U2023.P12 ; U2022.B14 v3(244.32,165.55) 244.56,165.3 245.92,165.3 C2466.1 ; U2023.L13 v3(292.9,155.34) 293.3,154.94 U2023.K12 ; U2023.L13 v3(292.1,155.34) 291.7,154.94 U2023.M12 v3(292.1,154.54) U2023.L11 ; v3(263.43,94.32) 263.83,93.92 U60.F12 ; v3(297.03,132.72) U2024.N10 v3(297.83,131.92) U2024.P11 ; v3(289.03,118.69) 289.43,118.29 U2025.R10 ; U55.H12 277.13,170.35 v3(277.53,169.95) 277.53,169.95 U55.G13 277.93,169.55 v3(277.53,169.15) U55.F12 ; v3(294.5,148.14) 294.9,147.74 U2023.H3 v3(295.3,148.14) U2023.G4 v3(296.1,148.14) 296.5,147.74 U2023.F3 ; U2025.L1 v3(292.23,110.69) ; U48.F3 259.71,173.15 v3(259.71,173.15) U48.G4 v3(259.71,172.35) U48.H3 259.71,171.55 v3(259.71,171.55) ; U2025.L11 292.23,119.49 v3(292.23,119.49) U2025.M12 292.23,120.28 v3(292.23,120.29) 292.23,120.29 U2025.L13 ; U2023.G11 296.1,154.54 v3(296.1,154.54) U2023.F12 296.5,154.94 v3(296.1,155.34) ; v3(299.42,113.09) 299.83,112.68 U2025.B3 ; U2025.P12 v3(289.83,119.49) 290.23,119.09 U2025.P11 290.63,118.69 v3(290.63,118.69) 291.03,118.29 U2025.N10 ; U2024.P11 v3(298.63,131.92) U2024.R10 ; U2024.P11 v3(298.63,131.12) U2024.P12 ; U2024.L13 295.62,129.72 295.62,129.32 U2024.L14 v3(296.23,128.72) ; U2024.L13 v3(296.23,130.32) U2024.M12 v3(297.03,130.32) ; U2024.L13 U2024.K12 v3(294.63,131.12) ; v3(291.43,130.32) 291.43,130.32 U2024.F12 ; U2025.M14 291.83,121.49 v3(291.43,121.89) ; U2024.B12 v3(288.23,130.32) ; v3(292.23,121.89) 292.23,121.88 U2025.L14 292.62,121.48 v3(292.23,121.09) 292.23,121.09 U2025.L13 ; v3(299.42,114.69) 299.03,114.29 U2025.C5 ; U2024.F12 v3(292.23,130.32) U2024.G13 v3(293.03,130.32) 293.03,130.32 U2024.H12 ; U55.N5 271.53,174.35 v3(271.13,173.95) ; C2665.1 255.03,89.68 v3(254.87,89.52) U2026.G14 254.27,90.12 253.87,90.12 U2026.G13 ; U55.D1 268.33,167.15 v3(267.93,166.75) ; U2023.M1 v3(291.3,145.74) ; v3(270.33,177.15) 269.93,176.75 U55.T3 ; U2024.E10 v3(290.63,131.92) U2024.D11 v3(289.83,131.12) U2024.D12 ; U2025.D14 298.22,121.48 v3(297.82,121.88) ; U60.F12 v3(264.23,93.52) U60.G11 ; v3(261.83,89.52) U60.M14 262.23,89.12 v3(261.83,88.72) 261.69,88.58 C2627.1 ; v3(261.83,89.52) 261.77,89.58 C2626.1 ; v3(267.93,165.15) 268.33,165.55 U55.B1 ; v3(296.22,120.29) 295.83,120.68 U2025.G13 U2025.H12 295.02,119.88 v3(294.62,119.49) ; C2473.1 245.93,173.91 244.12,173.91 v3(244.07,173.95) 243.67,173.55 U2022.M14 ; U2024.M3 296.62,137.92 v3(296.23,138.31) 296.23,138.32 U2024.L2 ; 274.42,86.19 273.96,86.19 v3(273.03,87.12) 272.63,87.52 U60.P1 ; U60.L4 v3(270.63,90.32) U60.K3 v3(270.63,91.12) ; U48.B3 260.11,176.75 v3(260.51,176.35) ; U2025.P14 289.83,121.88 v3(289.83,121.89) 289.83,123.75 C2611.1 ; v3(250.91,165.15) 251.31,165.55 U48.T14 ; U55.G1 267.93,169.15 v3(267.93,169.15) U55.F1 268.33,168.75 v3(267.93,168.35) ; U55.F12 276.73,169.15 v3(276.73,169.15) U55.G11 ; U55.F12 v3(277.53,168.35) ; U2023.R10 v3(288.9,153.74) ; v3(296.22,121.88) 295.83,121.49 U2025.G14 ; C2565.1 288.27,128.67 v3(288.23,128.72) U2024.B14 ; C2567.1 297.17,128.58 v3(297.03,128.72) U2024.M14 ; U48.L13 252.51,169.15 v3(252.51,169.15) 252.91,168.75 U48.M12 253.31,169.15 v3(253.31,169.15) U48.L11 ; U48.L13 v3(251.71,169.15) 251.71,169.15 U48.L14 251.31,169.55 v3(250.91,169.15) U48.M14 251.31,168.75 v3(250.91,168.35) ; v3(296.1,156.94) U2023.G14 295.6,156.44 295.6,155.84 ; v3(292.1,146.54) U2023.L2 v3(292.1,147.34) U2023.M3 v3(291.3,147.34) ; U2023.T12 288.5,154.94 v3(288.1,155.34) ; U48.F14 v3(250.91,173.95) ; v3(292.23,111.49) 292.62,111.88 U2025.L2 ; U2025.T3 288.62,112.68 v3(288.23,112.29) ; v3(267.93,173.15) U55.L1 v3(268.73,173.15) U55.L2 269.53,173.15 v3(269.53,173.15) 269.93,173.55 U55.M3 ; U2025.B12 299.82,119.88 v3(299.42,120.28) ; v3(265.03,96.72) 265.43,96.32 U60.C10 ; U2024.L11 v3(296.23,131.92) ; U2026.F14 v3(254.87,88.72) 255.24,88.35 256.01,88.35 ; v3(288.1,147.34) 288.5,147.74 U2023.T3 ; U2025.F14 296.63,121.49 v3(297.02,121.88) ; v3(253.31,171.55) U48.H12 ; U2022.D1 v3(232.87,166.75) ; v3(254.11,168.35) 254.51,167.95 U48.N10 v3(254.11,167.55) U48.P11 v3(253.31,166.75) U48.P12 ; U48.T1 261.71,165.55 v3(262.11,165.15) ; U2023.L1 v3(292.1,145.74) ; U2024.G4 v3(293.03,137.52) 293.03,137.52 293.43,137.91 U2024.H3 v3(293.83,137.52) ; U2022.H12 v3(242.47,169.95) U2022.G13 v3(242.48,169.15) ; v3(297.02,112.29) U2025.F3 v3(296.22,113.09) U2025.G4 295.43,113.08 v3(295.42,113.08) 295.03,112.69 295.03,112.69 ; v3(279.13,173.15) U55.M14 v3(279.13,173.95) 279.38,174.2 280.81,174.2 C2527.1 ; v3(279.13,173.15) 280.17,173.15 280.2,173.12 281.01,173.12 C2528.1 ; U2025.K12 v3(293.03,120.28) U2025.L13 ; v3(273.03,89.52) U60.L1 v3(272.23,89.52) ; U2022.L2 v3(234.48,173.15) U2022.M3 ; U2022.B12 v3(242.48,165.15) ; U48.D12 v3(253.31,175.55) 253.71,175.15 U48.D11 ; v3(265.03,94.32) 265.43,94.72 U60.E10 v3(265.03,95.12) U60.D11 264.24,95.91 v3(264.24,95.92) 263.84,95.52 U60.D12 ; U2025.M3 v3(291.43,112.29) ; U48.N5 v3(258.91,168.35) ; v3(252.51,173.15) 252.11,172.75 U48.G13 ; U2025.T12 v3(288.23,120.29) ; 295.6,155.84 295.6,155.64 ; 295.6,155.84 U2023.G13 ; U48.G13 252.01,172.65 251.41,172.65 U48.G14 v3(250.91,173.15) ; U48.G13 252.91,171.95 ; v3(271.13,168.35) 271.53,167.95 U55.E5 ; v3(242.48,166.75) 242.07,167.15 U2022.D12 v3(241.67,166.75) U2022.D11 v3(240.87,167.55) U2022.E10 ; U2024.K3 v3(295.43,137.52) U2024.L4 ; v3(259.71,175.55) 260.11,175.15 U48.D3 ; 295.03,112.69 v3(294.62,113.09) ; 295.03,112.69 U2025.H3 ; U55.E10 v3(275.93,167.55) 275.93,167.55 U55.D11 v3(276.73,166.75) ; U2026.N10 v3(251.67,95.12) U2026.P11 v3(252.47,95.92) ; U2022.P14 v3(244.07,175.55) ; U60.B1 v3(273.03,97.52) ; 260.11,168.75 U48.M3 ; 260.11,168.75 v3(260.51,168.35) ; C2606.1 287.92,123.74 287.92,122.2 v3(288.23,121.89) 288.63,121.49 U2025.T14 ; U55.C5 v3(271.13,165.95) ; U55.C10 v3(275.93,165.95) ; U2022.T14 v3(244.07,177.15) ; U2024.R10 v3(299.43,132.72) ; U2024.R10 v3(298.63,132.72) ; U2025.T1 v3(288.23,110.68) ; U55.B3 v3(270.33,165.95) ; U2023.B14 v3(299.3,156.94) ; U2022.D3 v3(234.48,167.55) ; v3(290.63,113.09) 290.63,113.09 U2025.P3 ; U48.T12 v3(252.51,165.15) ; U2025.M1 v3(291.43,110.69) ; U60.B12 v3(264.23,96.72) ; U2024.D1 v3(289.83,139.92) ; U2025.P1 v3(289.83,110.69)
  BOTTOM w0.356: C2566.1 296.16,128.66 v3(296.23,128.72) ; C2494.1 250.86,173.99 v3(250.91,173.95) ; C2472.1 244.33,167.16 v3(244.32,167.15) ; v2(265.27,84.53) 265.27,84.41 264.89,84.03 264.89,83.96 264.57,83.65 ; C2630.1 272.04,83.04 272.04,83.91 v2(272.46,84.33) 273.15,83.65 273.15,82.95 C2636.1 ; v3(267.93,173.15) 267.52,173.55 266.1,173.55 C2507.1 ; v3(279.13,177.15) 279.75,177.77 279.75,178.96 279.81,179.02 ; 242.07,173.55 v3(242.48,173.95) ; 242.07,173.55 v3(242.48,173.15) ; 242.07,173.55 U2022.M12 ; 256.01,88.35 C2657.1 257.64,88.35 C2664.1 ; U2022.L13 242.07,171.95 U2022.K12 v3(241.68,171.55) ; v3(250.91,165.15) 250.77,165.01 C2493.1 ; U2024.G14 v3(292.23,128.72) ; v3(244.07,177.15) 245.5,178.58 C2451.1 ; C2480.1 262.84,176.42 v3(262.11,177.15) ; v3(250.91,166.75) 250.85,166.81 C2500.1 ; v3(294.63,137.52) U2024.K3 ; U2024.L2 296.22,139.11 v3(296.23,139.11) 295.83,139.51 U2024.L1 ; C2655.1 253.43,84.62 v3(253.28,84.76) 253.18,84.76 252.25,83.84 C2652.1 ; U2024.F14 v3(291.43,128.72) ; C2608.1 297.8,123.68 297.8,121.9 v3(297.82,121.88) ; 302.09,115.44 300.17,115.44 v3(299.42,114.69) ; v3(240.89,177.88) 240.89,178.39 241.08,178.58 C2458.1
  BOTTOM w0.381: v3(298.62,113.09) 298.23,112.69 U2025.D3 ; U48.F1 v3(261.31,173.15) U48.G2 ; U48.F1 262.11,173.15 v3(262.11,173.15) U48.G1 ; U48.F1 v3(262.11,173.95) 262.61,173.95 263.04,173.51 C2503.1 ; U55.M1 v3(267.93,173.95) ; U60.R10 v3(265.03,87.12) ; U60.R10 v3(265.83,87.12) ; U60.R10 v3(265.83,86.32) ; U48.F12 v3(252.51,173.95) ; U2022.R10 v3(240.88,175.55) U2022.P11 ; U2022.R10 v3(240.07,175.55) ; U2022.R10 v3(240.07,176.35) ; U2022.F3 v3(234.48,169.15) 234.07,169.55 U2022.G2 v3(233.67,169.15) U2022.F1 v3(232.87,168.35) ; U2024.B3 v3(289.03,137.52) ; R910.1 257.89,89.68 C2665.1 ; C2585.1 297.35,141.79 297.35,140.24 v3(297.03,139.92) U2024.M1 ; U2023.B1 v3(300.1,145.74) 300.51,145.32 C2543.1 ; v3(250.91,173.15) 248.91,173.15 C2502.1 R2217.1 ; U2025.F12 296.62,119.88 v3(296.22,119.49) ; v3(254.11,173.15) 253.71,172.75 U48.G11 ; U2023.E5 v3(296.9,149.74) ; U2022.P11 v3(240.88,174.75) U2022.N10 v3(240.07,173.95) ; U2022.P11 v3(241.68,175.55) U2022.P12 ; v3(271.43,95.12) 271.03,95.52 U60.D3 ; U48.T3 260.11,165.55 v3(260.51,165.95) ; v3(235.27,175.55) U2022.P3 ; v3(273.03,94.32) 272.63,93.92 U60.F1 ; U2023.D3 v3(298.5,148.14) ; C2593.1 300.77,109.19 300.23,109.73 v3(300.23,110.69) U2025.B1 ; U2026.D12 v3(252.47,87.12) U2026.D11 ; U60.E5 v3(269.83,94.32) ; U55.P11 v3(275.93,174.75) U55.N10 v3(275.13,173.95) ; U55.P11 v3(275.93,175.55) U55.R10 v3(275.13,175.55) ; U55.P11 v3(276.73,175.55) U55.P12 ; v3(291.3,156.94) U2023.M14 ; U2023.P14 v3(289.7,156.94) 289.69,156.95 289.69,158.79 C2563.1 ; U2022.T12 v3(241.67,176.35) ; U2023.D1 v3(298.5,145.74) 298.44,145.67 298.44,143.88 C2546.1 ; U2026.E10 v3(250.72,88.32) ; C2476.1 C2463.1 232.67,173.36 v3(232.87,173.15) U2022.L1 ; U60.P3 v3(270.63,87.12) ; U2023.K3 293.3,147.74 v3(293.7,148.14) ; v3(291.43,113.89) 291.03,114.28 U2025.N5 ; v3(258.11,173.95) U48.E5 v3(258.91,173.95) ; C2669.1 255.74,85.5 255.73,85.49 254.9,85.49 v3(254.87,85.52) U2026.B14 ; U2024.P14 v3(298.63,128.72) ; U2023.G2 U2023.G1 v3(296.1,145.74) 296.75,145.09 296.75,143.88 C2555.1 ; U60.T3 271.03,85.92 v3(271.43,85.52) ; U2024.T3 v3(300.23,138.32) ; U60.F14 v3(261.63,93.92) ; C2663.1 256.77,95.92 v3(254.87,95.92) U2026.P14 ; U2022.P1 v3(232.87,175.55) 232.46,175.14 C2464.1 ; U55.B12 v3(277.53,165.15) ; v3(242.48,173.15) U2022.L13 243.08,172.55 243.47,172.55 U2022.L14 243.67,172.75 v3(244.07,173.15) ; v3(270.33,171.55) U55.K3 v3(270.33,172.35) U55.L4 ; U2026.P1 v3(243.47,95.52) ; U2024.P1 v3(298.63,139.92) ; v3(293.03,113.09) 292.63,113.48 U2025.L4 ; U2026.P3 v3(246.07,95.12) ; C2651.1 248.42,85.56 v3(247.67,86.32) U2026.C5 ; C2604.1 296.26,108.84 296.26,110.65 v3(296.23,110.69) U2025.G1 296.22,111.48 v3(296.22,111.49) U2025.G2 ; C2592.1 296.37,141.78 296.37,140.06 v3(296.23,139.92) U2024.L1 ; U2026.M14 v3(254.87,94.32) ; U2025.K3 293.43,112.69 v3(293.82,113.09) ; U60.F3 271.03,93.92 v3(271.43,93.52) U60.G2 v3(272.23,93.52) ; U2026.L13 v3(253.27,93.52) U2026.M12 v3(252.47,93.52) U2026.L11 ; U2026.L13 v3(254.07,93.52) U2026.L14 v3(254.87,93.52) ; U2026.L13 v3(253.27,92.72) U2026.K12 ; U2026.B12 v3(253.27,86.32) ; v3(297.3,152.76) U2023.E10 v3(297.7,153.74) U2023.D11 298.5,154.54 v3(298.5,154.54) U2023.D12 ; U60.R5 v3(269.03,86.32) ; v3(265.83,88.72) U60.N10 v3(265.03,87.92) 264.63,87.52 U60.P11 v3(264.23,87.12) U60.P12 ; v3(235.27,170.75) U2022.H3 v3(235.27,169.95) U2022.G4 ; U60.L11 v3(265.03,89.52) ; C2554.1 287.79,158.79 287.79,157.25 v3(288.1,156.94) U2023.T14 ; U55.T12 v3(276.73,176.35) ; U2024.F3 v3(292.23,138.32) U2024.G2 v3(292.23,139.12) U2024.G1 292.62,139.52 v3(292.23,139.91) ; U2024.R5 299.03,136.29 v3(299.43,135.89) ; U2026.B3 v3(246.07,86.32) ; U55.D3 v3(269.53,167.55) ; v3(253.27,88.72) U2026.F12 v3(253.27,89.52) U2026.G13 U2026.H12 v3(252.47,91.12) ; U2023.B3 v3(299.3,148.14) ; v3(270.33,175.55) 269.93,175.15 U55.P3 ; 274.39,89.13 273.42,89.13 v3(273.03,89.52) ; U2025.E10 v3(297.43,117.73) ; U2026.D14 v3(254.87,87.12) ; U60.G1 272.63,93.12 v3(273.03,93.52) ; U2026.K3 v3(246.07,92.72) U2026.L4 ; v3(261.31,175.55) 261.71,175.15 U48.D1 v3(262.11,175.55) 262.24,175.42 C2501.1 ; U2024.B1 v3(288.23,139.92) ; v3(252.47,95.92) U2026.P12 v3(253.27,95.12) ; U2024.F1 v3(291.43,139.92) ; U60.P14 v3(261.83,87.12) ; U60.H3 v3(270.63,91.92) ; R897.1 C2605.1 296.08,122.03 v3(296.22,121.88) ; C2577.1 299.56,141.88 299.56,140.58 v3(300.23,139.92) U2024.T1 ; U60.T1 v3(273.03,85.52) ; U2026.R5 v3(246.87,96.72) ; C2549.1 297.68,158.8 297.68,156.96 v3(297.7,156.94) U2023.D14 ; U60.T12 v3(264.23,86.32) ; U2022.F14 v3(244.27,168.75) ; v3(232.87,173.95) U2022.M1 ; U55.P14 v3(279.13,175.55) ; U60.D1 272.63,95.52 v3(273.03,95.92) ; U2026.C10 v3(250.87,86.32) ; U2025.R5 v3(289.03,113.88) ; U2023.T1 288.5,146.14 v3(288.1,145.74) ; U2026.N5 v3(246.87,94.32) ; R867.1 295.95,158.87 C2548.1 295.94,157.1 v3(296.1,156.94) ; U2022.C5 v3(236.07,165.95) ; U60.N5 v3(269.83,88.72) ; U2025.G11 v3(296.23,118.69) ; C2668.1 241.86,88.76 243.63,88.76 v3(243.67,88.72) U2026.F1 ; C2662.1 257.75,97.14 257.37,97.52 v3(254.87,97.52) U2026.T14 ; v3(255.49,178.01) v3(255.49,177.37) 255.49,176.93 v3(254.91,176.35) U48.C10 ; U2025.C10 v3(299.43,117.88) ; U2025.D1 v3(298.63,110.69) 298.6,110.65 298.6,109.99 298.09,109.48 C2607.1 ; U2022.L4 v3(235.27,172.35) U2022.K3 v3(235.27,171.55) ; U2025.D12 298.23,119.88 v3(298.62,119.49) 298.62,119.48 U2025.D11 ; U60.M1 v3(273.03,88.72) 273.6,88.15 ; U60.D14 v3(261.63,95.52) 259.3,95.52 259.02,95.8 C2646.1 ; U2022.B1 v3(232.87,165.15) ; U2022.D14 v3(244.32,167.15) ; U2023.N5 v3(291.3,148.94) ; U2023.C5 v3(299.3,149.74) 300.06,150.49 301.96,150.49 ; U2024.P3 v3(298.63,137.52) ; U55.T14 v3(279.13,177.15) ; U2025.F1 v3(297.03,110.69) ; U48.B12 v3(252.51,176.35) ; U2025.E5 297.43,114.28 v3(297.02,114.69) ; U2026.B1 v3(243.67,85.52) ; v3(244.47,93.52) U2026.L1 243.75,93.12 v3(243.54,93.33) ; 295.6,155.64 U2023.H12 v3(294.5,154.54) ; v3(270.63,96.72) U60.B3 ; U2024.T12 v3(299.43,131.12) ; U2022.L11 v3(240.88,173.15) ; U2022.G14 v3(244.27,169.55) ; U60.B14 v3(261.63,97.12) 260.11,97.12 C2629.1 ; U48.R10 v3(254.11,165.95) ; U48.C5 v3(258.11,176.35) 257.52,176.93 ; U55.L11 v3(275.93,173.15) ; U55.D12 v3(277.53,166.75) ; U2026.D3 v3(246.07,87.12) ; U2026.D1 v3(243.67,87.12) ; U2024.D3 v3(290.63,138.32) ; U2026.M1 v3(243.47,93.92) ; U2023.F1 v3(296.9,145.74) ; U2022.B3 v3(235.27,165.95) ; U2023.L4 v3(292.9,148.14) ; U2022.E5 v3(236.07,168.35) ; U55.B14 v3(279.33,165.55) 279.54,165.34 280.97,165.34 C2509.1 ; U60.C5 v3(269.83,96.72) ; U48.R5 v3(258.91,165.95) ; U55.D14 v3(279.28,167.15) 279.55,167.42 281.01,167.42 C2508.1 ; v3(236.87,176.35) U2022.R5 ; U2023.R5 v3(288.9,148.94) ; U2022.T3 v3(234.48,177.15) ; U55.G14 v3(279.33,169.55) ; U2026.T1 v3(243.47,97.12) ; U55.F14 v3(279.33,168.75) ; U2024.E5 v3(291.43,136.72) ; v3(299.3,152.91) 298.9,153.31 U2023.C10 ; U48.D14 v3(250.91,174.75) ; U2023.F14 v3(296.9,156.94) ; U2025.B14 v3(299.43,121.88) ; 267.52,177.55 v3(267.93,177.15) U55.T1 ; v3(261.31,177.15) 261.71,176.75 U48.B1 v3(262.11,177.15) ; U2023.B12 v3(300.1,154.54) ; U55.P1 v3(267.93,175.55) v2(267.01,175.55) ; U60.G14 v3(261.63,93.12) ; U60.M3 271.43,89.52 v3(271.43,89.52) U60.L2 v3(272.23,89.52) ; U2022.T1 v3(232.87,177.15) 232.78,177.25 231.17,177.25 C2457.1 230.64,177.18 v3(230.22,176.76) ; U2024.C5 v3(289.03,136.72) ; U2026.T3 v3(245.27,97.52) ; U48.P3 v3(259.71,167.55) ; U2022.N5 v3(236.07,173.95) ; U2024.N5 v3(297.03,136.72) ; v3(250.91,176.35) U48.B14 ; v3(270.63,92.72) U60.G4 ; U48.E10 v3(255.06,174.35) ; U2024.C10 v3(289.03,131.92) ; U2022.G1 v3(232.87,169.15) ; U2023.P3 v3(290.5,148.14) ; U2026.G11 v3(251.67,89.52) ; U2026.T12 v3(252.47,96.72)
  BOTTOM w0.457: v2(303.75,150.45) 303.69,150.38 C2539.1 302.07,150.38 301.96,150.49
  vias: v1(230.22,171.66) v2(238.72,177.89) v2(240,177.88) v2(264.64,175.34) v2(264.76,166.58) v2(264.76,165.94) v2(265.27,175.72) v2(265.27,169.5) v2(265.27,168.86) v2(270.94,178.54) v2(271.57,178.54) v2(272.26,110.32) v2(272.26,109.55) v2(272.76,105.87) v2(272.76,105.11) v2(275.25,89.11) v2(275.69,86.44) v2(275.69,85.68) v2(275.69,84.92) v2(276.45,87.2) v2(276.45,86.44) v2(277.34,101.04) v2(277.34,100.28) v2(277.34,99.39) v2(277.34,98.63) v2(277.34,96.35) v2(277.34,95.58) v2(277.34,94.82) v2(277.34,94.06) v2(277.34,92.54) v2(277.34,91.77) v2(278.23,101.04) v2(278.23,100.28) v2(278.23,99.39) v2(278.23,98.63) v2(278.23,96.35) v2(278.23,95.58) v2(278.23,94.82) v2(278.23,94.06) v2(278.23,92.54) v2(278.23,91.77) v2(279.75,181.05) v2(279.75,180.17) v2(301.09,117.81) v2(301.67,113.74) v2(301.85,157.18) v2(301.96,145.76) v2(301.97,139.02) v2(301.97,133.43) v2(302.1,132.03) v2(302.1,117.94) v2(302.61,139.02) v2(302.61,133.43) v2(302.74,145.75) v2(302.74,132.03) v2(302.99,157.18) v2(303.24,114.76) v2(303.24,114) v2(303.75,149.69) v3(248.04,141.52) v3(248.09,142.27) v3(248.89,175.59) v3(248.88,142.27) v3(250.13,141.52) v3(250.18,142.27) v3(250.99,142.27) v3(251.04,141.52) v3(251.04,120.52) v3(250.99,119.77) v3(252.23,141.52) v3(252.23,120.52) v3(252.28,142.27) v3(252.28,119.77) v3(253.09,142.27) v3(253.13,141.52) v3(253.13,120.52) v3(253.09,119.77) v3(254.39,142.27) v3(254.39,119.77) v3(255.18,142.27) v3(255.23,141.52) v3(255.23,120.52) v3(255.18,119.77) v3(256.38,178.01) v3(256.44,141.52) v3(256.44,120.52) v3(256.48,142.27) v3(256.48,119.77) v3(257.28,142.27) v3(257.34,120.52) v3(257.28,119.77) v3(258.53,120.52) v3(258.58,142.27) v3(258.58,119.77) v3(259.18,84.66) v3(259.39,142.27) v3(259.39,119.77) v3(259.68,84.15) v3(260.63,120.52) v3(260.69,142.27) v3(260.69,119.77) v3(261.48,142.27) v3(261.53,120.52) v3(261.48,119.77) v3(262.74,120.52) v3(262.79,142.27) v3(262.79,119.77) v3(264.14,121.92) v3(264.23,140.02) v3(264.23,137.92) v3(264.23,135.82) v3(264.23,134.62) v3(264.23,131.62) v3(264.17,130.57) v3(264.23,128.32) v3(264.23,125.32) v3(264.98,140.07) v3(264.98,137.97) v3(264.98,136.67) v3(264.98,135.87) v3(264.98,134.57) v3(264.98,131.67) v3(264.98,130.37) v3(264.98,129.57) v3(264.98,128.27) v3(264.98,127.47) v3(264.98,126.17) v3(264.98,125.37) v3(264.98,121.97) v3(265.53,177.12) v3(265.91,84.53) v3(266.92,177.24) v3(285.34,109.55) v3(286.23,109.55) v3(294.99,108.66) v3(295.62,108.66) v3(299.99,108.66) v3(301.09,127.84)
