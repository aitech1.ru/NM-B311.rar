# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAINON_N: length 5.9
  TOP w0.097: PQ1401.5 109.57,66.88 109.44,67.01 109.44,67.26 109.56,67.38 PQ1401.6 110.02,67.47 PR1401.1 111.22,67.77 110.97,68.02 PQ1403.5 PQ1403.2 v1(110.97,70.56)
MBAT_PRES_N: length 178
  TOP w0.097: v2(83.92,4.02) 83.71,3.81 PR208.1
  IN03 w0.091: v2(35.78,4.52) 35.78,4.14 36.42,3.51 40.99,3.51 41.62,4.14 50.9,4.14 52.55,5.79 59.28,5.79 61.18,3.89 66.64,3.89 67.41,4.65 71.09,4.65 72.61,3.13 78.18,3.13 79.07,4.02 81.07,4.02 81.58,3.51 83.41,3.51 v2(83.92,4.02)
  IN05 w0.091: v1(40.99,52.78) 41.36,53.16 45.07,53.16 49.25,48.97 52.17,48.97 54.2,46.94 54.2,45.55 56.36,43.39 56.36,41.1 57.75,39.7 57.75,39.07 59.79,37.04 86.07,37.04 v2(88.61,39.58)
  IN08 w0.091: v2(83.92,4.02) 83.92,5.67 83.28,6.3 83.28,14.54 81.23,16.59 81.23,16.94 81.24,16.95 81.24,16.98 81.45,17.19 81.81,17.19 82.09,17.48 82.09,17.8 82.37,18.08 82.77,18.08 82.99,18.3 82.99,18.81 82.83,18.97 82.83,19.33 84.07,20.57 84.07,25 87.34,28.27 87.34,32.97 88.61,34.24 v2(88.61,39.58)
  BOTTOM w0.097: v2(35.78,4.52) 30.14,4.52 29.76,4.91 JDBUG1.4 ; v1(40.99,52.78) 40.25,52.78 39.87,52.4 39.59,52.4 39.08,52.91 U5.G13 ; v2(83.92,4.02) 84.8,4.91 89.76,4.91 92.68,7.83 92.68,9.24 93.47,10.03 94.12,10.03 PR103.2 PR104.1
MBAT_PRES_N_R: length 2.9
  BOTTOM w0.097: JBAT1.7 96.63,13.55 96.34,13.27 v1(96.34,12.9) 96.03,12.59 PR104.2
MCT1_TL: length 8.4
  TOP w0.508: v2(20.8,96.48) 21.55,96.48 ; v2(20.8,102.48) 21.6,102.48 ; v2(20.8,93.48) 21.63,93.48 ; v2(20.8,99.48) 21.6,99.48
  BOTTOM w0.457: TL1.21 v2(20.8,99.48) ; TL1.24 v2(20.8,102.48) ; TL1.18 v2(20.8,96.48) ; TL1.15 v2(20.8,93.48)
  vias: v1(21.3,109.93)
MDA0: length 18.6
  IN10 w0.14: v3(259.71,164.35) 259.75,164.31 259.75,164.03 260.96,162.83 260.96,157.39 260.32,156.75 260.32,151.49 v3(259.8,150.96)
  BOTTOM w0.102: G2.U51 260.39,148.41 260.7,148.72 260.7,150.58 260.57,150.7
  BOTTOM w0.152: v3(259.8,150.96) 260.31,150.96 260.57,150.7 ; U48.U4 v3(259.71,164.35)
MDA1: length 19.9
  IN10 w0.14: v3(261.31,164.35) 261.31,164.06 262.07,163.29 262.07,156.92 261.38,156.23 261.38,149.54 260.78,148.94 260.78,147.17 v3(260.79,147.17)
  BOTTOM w0.152: v3(260.79,147.17) 260.74,147.12 260.74,146.65 260.39,146.3 G2.U48 ; U48.U2 v3(261.31,164.35)
MDA2: length 20.9
  IN10 w0.14: v3(259.71,165.15) 259.19,164.63 259.19,163.8 260.4,162.59 260.4,157.62 259.54,156.76 259.54,154.66 258.95,154.07 258.95,152.42 v3(259.8,151.57)
  BOTTOM w0.102: G2.U50 260.39,147.68 260.74,148.03 260.74,148.35 260.92,148.54 260.92,150.99 260.83,151.08
  BOTTOM w0.152: U48.T4 v3(259.71,165.15) ; v3(259.8,151.57) 260.34,151.57 260.83,151.08
MDA3: length 23.8
  IN10 w0.14: v3(260.04,149.82) 259.98,149.76 259.39,149.76 258.57,150.59 258.57,154.31 258.91,154.65 258.91,156.92 259.84,157.85 259.84,162.36 258.63,163.57 258.63,164.04 258.48,164.2 258.48,165.34 258.69,165.55 260.11,165.55 v3(260.51,165.15)
  BOTTOM w0.102: G2.U49 260.05,147.1 260.05,149.03 260.13,149.1 260.13,149.73 v3(260.04,149.82)
  BOTTOM w0.152: U48.T2 v3(260.51,165.15)
MDA4: length 25.4
  IN10 w0.14: v3(261.79,153.01) 262.19,153.01 262.63,153.44 262.63,155.83 263.19,156.39 263.19,167.91 262.35,168.75 260.11,168.75 v3(259.71,168.35)
  BOTTOM w0.102: G2.R51 261.79,148.33 261.39,148.73 261.39,152.62 v3(261.79,153.01)
  BOTTOM w0.152: U48.N4 v3(259.71,168.35)
MDA5: length 22.8
  IN10 w0.14: v3(261.31,167.55) 261.71,167.15 262.32,167.15 262.63,166.84 262.63,156.68 262,156.05 262,154.74 262.25,154.48 262.25,153.88 262.01,153.64 v3(261.79,153.64)
  BOTTOM w0.102: G2.R50 261.79,147.69 261.44,148.04 261.44,148.28 261.16,148.56 261.16,153.01 261.33,153.19
  BOTTOM w0.152: U48.N2 v3(261.31,167.55) ; 261.33,153.19 v3(261.79,153.64)
MDA6: length 30.6
  IN10 w0.14: v3(259.71,169.15) 260.31,169.75 263.2,169.75 263.75,169.2 263.75,156.1 263.03,155.39 263.03,152.85 262.21,152.03 262.21,149.04 261.9,148.73 261.9,145.48 v3(261.48,145.07)
  BOTTOM w0.152: G2.R47 v3(261.48,145.07) ; U48.M4 v3(259.71,169.15)
MDA7: length 25.5
  IN10 w0.14: v3(261.31,168.35) 260.91,167.95 260.91,163.66 261.52,163.06 261.52,157.16 260.88,156.52 260.88,149.63 260.25,149 260.25,145.4 v3(260.69,144.97)
  BOTTOM w0.152: G2.U46 v3(260.69,144.97) ; U48.M2 v3(261.31,168.35)
MDA8: length 26.1
  IN03 w0.14: v3(259.38,144.38) 258.98,143.98 258.36,143.98 258.07,144.27 258.07,147.91 257.29,148.69 257.03,148.95 257.03,155.8 257.29,156.06 257.29,157.98 258.25,158.94 258.25,160.21 254.47,164 253.66,164 v3(253.31,164.35)
  BOTTOM w0.152: v3(259.38,144.38) 259.66,144.67 G2.V46 ; U48.U11 v3(253.31,164.35)
MDA9: length 25.7
  IN03 w0.14: v3(251.71,164.35) 251.93,164.35 252.43,163.85 253.02,163.85 256.73,160.13 256.73,156.24 256.54,156.06 256.54,148.83 257.73,147.64 257.73,144.04 258.21,143.56 v3(258.69,143.56)
  BOTTOM w0.152: G2.Y45 v3(258.69,143.56) ; U48.U13 v3(251.71,164.35)
MDA10: length 24.2
  IN03 w0.14: v3(258.69,145.77) 258.33,146.13 258.33,148.4 257.58,149.15 257.58,155.42 257.85,155.69 257.85,157.65 258.82,158.62 258.82,160.43 254.67,164.58 253.87,164.58 v3(253.31,165.15)
  BOTTOM w0.152: v3(258.69,145.77) G2.Y47 ; U48.T11 v3(253.31,165.15)
MDA11: length 28.6
  IN03 w0.076: v3(258.65,144.99) 259.01,145.36 259.53,145.36
  IN03 w0.14: v3(251.71,165.15) U48.T13 254.5,165.55 259.39,160.66 259.39,158.36 258.41,157.38 258.41,155.34 258.08,155.01 258.08,149.4 259.8,147.67 259.8,145.62 259.53,145.36
  BOTTOM w0.152: U48.T13 v3(251.71,165.15) ; v3(258.65,144.99) 258.32,144.67 G2.Y46
MDA12: length 26.3
  IN03 w0.14: v3(259.8,153.4) 259.67,153.28 259.23,153.28 258.92,153.58 258.92,154.14 259.46,154.68 259.46,156.64 260.51,157.68 260.51,161.12 254.48,167.15 253.71,167.15 253.31,167.55 v3(253.31,167.55)
  BOTTOM w0.102: 259.29,152.9 259.08,152.68 259.08,150.68 258.91,150.51 258.91,149.53 259.07,149.37 259.07,148.63 259.34,148.37 259.34,148.04 259.69,147.69 G2.V50
  BOTTOM w0.152: U48.N11 v3(253.31,167.55) ; 259.29,152.9 v3(259.8,153.4)
MDA13: length 29.7
  IN03 w0.14: v3(252.51,167.55) 252.91,167.15 252.91,166.55 253.11,166.35 254.49,166.35 259.95,160.89 259.95,157.95 258.96,156.96 258.96,154.97 258.51,154.52 258.51,152.21 259.06,151.66 259.06,149.29 260.25,148.09 260.25,145.38 259.82,144.94 v3(259.28,144.94)
  BOTTOM w0.152: U48.N13 252.11,167.95 v3(252.51,167.55) ; G2.V47 259.28,144.96 v3(259.28,144.94)
MDA14: length 25.6
  IN03 w0.14: v3(260.05,150.47) 260.05,150.47 260.24,150.66 260.24,151.93 260.48,152.18 260.48,155.21 260.91,155.63 260.91,156.48 261.68,157.24 261.68,161.53 254.46,168.75 253.71,168.75 v3(253.31,168.35)
  BOTTOM w0.102: G2.U52 260.43,148.91 260.43,150.09 v3(260.05,150.47)
  BOTTOM w0.152: U48.M11 v3(253.31,168.35)
MDA15: length 27
  IN03 w0.14: v3(251.71,168.35) 252.11,167.95 254.47,167.95 261.08,161.34 261.08,157.45 260.22,156.59 260.22,153.22 v3(259.8,152.79)
  BOTTOM w0.102: G2.V51 259.69,148.37 259.29,148.76 259.29,149.53 259.16,149.66 259.16,150.37 259.36,150.56 259.36,152.35 259.51,152.5
  BOTTOM w0.152: U48.M13 v3(251.71,168.35) ; 259.51,152.5 v3(259.8,152.79)
MDA16: length 45.3
  IN03 w0.076: v3(252.34,142.97) 251.88,143.42 251.88,146.68 252.11,146.91
  IN03 w0.14: 252.11,146.91 252.11,157.77 246.79,163.1 246.79,175.52 250.78,179.51 252.35,179.51 253.31,178.55 v3(253.31,177.95)
  BOTTOM w0.152: U48.A11 v3(253.31,177.95) ; G2.AJ44 252.04,143.27 v3(252.34,142.97)
MDA17: length 36.6
  IN03 w0.14: v3(253.63,149.37) 253.83,149.57 253.83,158.43 248.46,163.79 248.46,173.52 250.29,175.34 250.29,176.48 250.55,176.75 251.07,176.75 251.31,176.98 251.31,177.55 v3(251.71,177.95)
  BOTTOM w0.152: G2.AG48 253.73,146.41 253.73,149.27 v3(253.63,149.37) ; U48.A13 v3(251.71,177.95)
MDA18: length 46.6
  IN03 w0.076: 253.36,143.27 252.69,143.27 v3(252.28,143.67)
  IN03 w0.14: 253.36,143.27 253.59,143.5 253.59,145.98 252.36,147.22 252.36,149.47 252.68,149.79 252.68,158 247.34,163.33 247.34,175.25 251.04,178.94 252.11,178.94 252.69,178.36 252.69,177.76 252.9,177.55 253.71,177.55 v3(254.11,177.15)
  BOTTOM w0.152: v3(254.11,177.15) 253.71,176.75 U48.B11 ; G2.AJ45 v3(252.28,143.67)
MDA19: length 38.1
  IN03 w0.14: v3(253.09,147.07) 253.18,147.17 253.18,149.57 253.27,149.66 253.27,158.19 247.9,163.56 247.9,173.85 249.65,175.59 249.65,176.71 251.31,178.37 251.89,178.37 252.13,178.13 252.13,177.53 v3(252.51,177.15)
  BOTTOM w0.152: G2.AG49 v3(253.09,147.07) ; v3(252.51,177.15) 252.11,176.75 U48.B13
MDA20: length 35.6
  IN03 w0.14: v3(253.31,174.75) 253.71,174.35 253.71,173.4 251.31,171 251.31,168.52 251.31,168.51 251.31,168.18 251.31,168.18 251.31,164.11 256.07,159.35 256.07,156.73 255.97,156.64 255.97,145.25 v3(255.09,144.37)
  BOTTOM w0.102: G2.AF46 254.79,144.67 v3(255.09,144.37)
  BOTTOM w0.152: U48.E11 v3(253.31,174.75)
MDA21: length 35.2
  IN03 w0.14: v3(254.38,145.07) 253.99,145.47 253.99,146.3 253.74,146.56 253.74,148.06 254.39,148.71 254.39,158.66 249.02,164.03 249.02,173.19 250.18,174.35 251.31,174.35 v3(251.71,173.95)
  BOTTOM w0.152: G2.AF47 v3(254.38,145.07) ; U48.E13 v3(251.71,173.95)
MDA22: length 34.1
  IN03 w0.14: v3(254.46,146.26) 254.46,147.99 254.95,148.48 254.95,158.89 249.59,164.25 249.59,172.7 250.44,173.55 252.91,173.55 v3(253.31,173.95)
  BOTTOM w0.152: v3(254.46,146.26) G2.AF48 ; U48.F11 v3(253.31,173.95)
MDA23: length 31.9
  IN03 w0.14: v3(251.71,173.15) 251.71,173.15 251.71,172.24 250.51,171.04 250.51,164.12 255.51,159.12 255.51,147.88 255.61,147.78 255.61,145.49 v3(255.19,145.07)
  BOTTOM w0.152: U48.F13 v3(251.71,173.15) ; G2.AD47 v3(255.19,145.07)
MDA24: length 34.5
  IN10 w0.14: v3(258.91,177.95) 258.13,177.95 255.49,175.31 255.49,172.46 254.6,171.57 254.6,148.71 255.35,147.96 255.35,147.23 v3(255.18,147.07)
  BOTTOM w0.152: U48.A4 v3(258.91,177.95) ; G2.AD49 v3(255.18,147.07)
MDA25: length 38.4
  IN10 w0.14: v3(255.11,146.26) 254.45,146.92 254.45,147.93 254.04,148.33 254.04,164.3 253.71,164.63 253.71,172.1 254.56,172.95 254.56,175.35 257.61,178.4 260.06,178.4 v3(260.51,177.95)
  BOTTOM w0.152: U48.A2 260.91,177.55 v3(260.51,177.95) ; G2.AD48 v3(255.11,146.26)
MDA26: length 35.6
  IN10 w0.14: v3(256.48,144.97) 255.73,145.72 255.73,148.26 255.22,148.77 255.22,170.6 256.09,171.48 256.09,174.94 257.9,176.75 258.51,176.75 v3(258.91,177.15)
  BOTTOM w0.152: G2.AC46 v3(256.48,144.97) ; U48.B4 v3(258.91,177.15)
MDA27: length 35.6
  IN10 w0.14: v3(260.51,177.15) 260.11,176.75 260.11,176.12 259.94,175.95 259.08,175.95 259.07,175.95 258.45,175.95 256.65,174.15 256.65,171.25 255.77,170.37 255.77,148.98 256.08,148.68 256.08,146.07 v3(256.48,145.67)
  BOTTOM w0.152: G2.AC47 v3(256.48,145.67) ; U48.B2 v3(260.51,177.15)
MDA28: length 34
  IN10 w0.14: v3(259.71,173.95) 259.71,173.95 259.31,174.35 257.76,174.35 257.16,173.74 257.16,170.86 256.4,170.1 256.4,160.68 256.88,160.19 256.88,159.26 256.42,158.8 256.42,149.03 257.66,147.79 257.66,145.44 v3(257.29,145.07)
  BOTTOM w0.152: G2.AA47 v3(257.29,145.07) ; U48.E4 v3(259.71,173.95)
MDA29: length 34.9
  IN10 w0.14: v3(257.29,144.37) 257.95,145.03 257.95,148.38 256.98,149.35 256.98,158.28 258,159.3 258,160.23 256.96,161.28 256.96,169.88 257.69,170.61 257.69,173.38 257.86,173.55 260.11,173.55 v3(260.51,173.95)
  BOTTOM w0.152: U48.E2 v3(260.51,173.95) ; G2.AA46 v3(257.29,144.37)
MDA30: length 32.6
  IN10 w0.14: v3(257.29,143.67) 258.23,144.61 258.23,148.98 257.53,149.68 257.53,158.04 258.56,159.07 258.56,160.47 257.52,161.51 257.52,169.64 258.45,170.57 258.45,172.69 258.91,173.15 v3(258.91,173.15)
  BOTTOM w0.152: G2.AA45 v3(257.29,143.67) ; U48.F4 v3(258.91,173.15)
MDA31: length 35
  IN10 w0.076: 259.51,143.27 259.05,143.27 258.75,142.97 v3(258.58,142.97)
  IN10 w0.14: v3(260.51,173.15) 260.11,172.75 259.47,172.75 259.06,172.34 259.06,170.36 258.08,169.38 258.08,161.75 259.12,160.7 259.12,158.84 258.09,157.81 258.09,150.33 259.8,148.62 259.8,143.56 259.51,143.27
  BOTTOM w0.152: U48.F2 v3(260.51,173.15) ; G2.Y44 v3(258.58,142.97)
MDA32: length 22.8
  IN03 w0.14: v3(244.69,148.47) 245.12,148.9 245.12,149.63 242.11,152.64 240.61,152.64 238.92,154.33 238.13,154.33 234.81,157.65 234.81,163.89 v3(235.27,164.35)
  BOTTOM w0.152: U2022.A4 v3(235.27,164.35) ; G2.AW51 v3(244.69,148.47)
MDA33: length 21.4
  IN03 w0.14: v3(233.67,164.35) 233.44,164.12 233.44,157.35 240.97,149.82 242.74,149.82 243.29,149.27 v3(243.29,149.17)
  BOTTOM w0.152: U2022.A2 v3(233.67,164.35) ; G2.BA52 v3(243.29,149.17)
MDA34: length 23.6
  IN03 w0.14: v3(235.27,165.15) 235.76,164.67 235.76,161.29 236.46,160.59 236.46,157.64 240.9,153.2 242.11,153.2 245.38,149.92 245.38,148.47 v3(244.69,147.77)
  BOTTOM w0.152: U2022.B4 v3(235.27,165.15) ; G2.AW50 v3(244.69,147.77)
MDA35: length 23.4
  IN03 w0.14: v3(243.88,148.46) 243.69,148.66 243.69,150.57 242.18,152.08 240.3,152.08 238.92,153.46 238.2,153.46 234.07,157.58 234.07,164.75 v3(233.67,165.15)
  BOTTOM w0.152: v3(243.88,148.46) G2.BA51 ; U2022.B2 v3(233.67,165.15)
MDA36: length 30.5
  IN03 w0.14: v3(235.27,168.35) 234.87,167.95 232.65,167.95 231.77,167.07 231.77,157.42 241.83,147.37 242.88,147.37 v3(243.29,147.77)
  BOTTOM w0.152: G2.BA50 v3(243.29,147.77) ; U2022.E4 v3(235.27,168.35)
MDA37: length 26.1
  IN03 w0.14: v3(242.58,147.77) 242.23,147.77 232.36,157.64 232.36,166.86 232.65,167.15 233.27,167.15 v3(233.67,167.55)
  BOTTOM w0.152: G2.BB50 v3(242.58,147.77) ; U2022.E2 v3(233.67,167.55)
MDA38: length 34.5
  IN03 w0.14: v3(243.29,146.47) 242.87,146.88 240.73,146.88 230.61,157 230.61,167.86 232.4,169.65 234.77,169.65 v3(235.27,169.15)
  BOTTOM w0.152: G2.BA49 v3(243.29,146.47) ; U2022.F4 v3(235.27,169.15)
MDA39: length 32.3
  IN03 w0.14: v3(233.67,168.35) 233.67,168.35 233.28,168.75 232.63,168.75 231.21,167.33 231.21,157.19 241.27,147.13 243.28,147.13 243.93,146.47 v3(244.69,146.47)
  BOTTOM w0.152: G2.AW49 v3(244.69,146.47) ; U2022.F2 v3(233.67,168.35)
MDA40: length 22
  IN10 w0.14: v3(241.67,164.35) 240.54,163.22 240.54,153.4 242.19,151.75 242.68,151.75 245.09,149.34 245.09,147.27 v3(245.99,146.37)
  BOTTOM w0.152: U2022.A11 v3(241.67,164.35) ; G2.AV48 v3(245.99,146.37)
MDA41: length 21.1
  IN10 w0.14: v3(243.27,164.35) 243.27,164.33 241.66,162.72 241.66,153.86 245.85,149.68 245.85,148.79 246.87,147.77 246.87,147.15 v3(246.78,147.07)
  BOTTOM w0.152: G2.AT49 v3(246.78,147.07) ; U2022.A13 v3(243.27,164.35)
MDA42: length 26.4
  IN10 w0.14: v3(246.79,145.07) 247.23,145.51 247.23,147.92 246.22,148.94 246.22,149.82 242.22,153.81 242.22,162.48 243.68,163.94 243.68,165.32 243.45,165.55 242.07,165.55 v3(241.67,165.15)
  BOTTOM w0.152: U2022.B11 v3(241.67,165.15) ; G2.AT47 v3(246.78,145.07)
MDA43: length 23.5
  IN10 w0.14: v3(246.78,146.37) 245.5,147.65 245.5,149.52 242.79,152.23 242.51,152.23 241.1,153.63 241.1,162.96 242.07,163.93 242.07,164.54 242.29,164.75 242.87,164.75 v3(243.27,165.15)
  BOTTOM w0.152: U2022.B13 v3(243.27,165.15) ; G2.AT48 v3(246.78,146.37)
MDA44: length 28.6
  IN10 w0.14: v3(246.79,144.37) 247.63,145.21 247.63,148.18 246.55,149.25 246.55,149.99 242.78,153.76 242.78,162.25 243.92,163.39 243.92,165.88 243.45,166.35 242.26,166.35 242.07,166.54 242.07,167.15 v3(241.67,167.55)
  BOTTOM w0.152: G2.AT46 v3(246.78,144.37) ; U2022.E11 v3(241.67,167.55)
MDA45: length 28.6
  IN10 w0.14: v3(243.27,168.35) U2022.E13 240.69,167.95 239.99,167.25 239.99,153.17 240.77,152.38 240.77,151.66 v3(240.46,151.35)
  BOTTOM w0.102: G2.AV51 245.69,148.39 246.01,148.72 246.01,149.56 245.16,150.41 241.2,150.41 240.89,150.72
  BOTTOM w0.152: v3(240.46,151.35) 240.46,151.15 240.89,150.72 ; U2022.E13 v3(243.27,168.35)
MDA46: length 27.5
  IN10 w0.14: v3(241.67,168.35) U2022.F11 240.14,168.75 239.43,168.04 239.43,152.89 239.66,152.66 239.66,152.23 v3(239.53,152.09)
  BOTTOM w0.102: G2.AV52 245.69,149.31 244.89,150.11 240.91,150.11 240.76,150.26
  BOTTOM w0.152: U2022.F11 v3(241.67,168.35) ; v3(239.53,152.09) 239.53,151.49 240.76,150.26
MDA47: length 32.7
  IN10 w0.14: v3(238.98,152.48) 238.87,152.59 238.87,168.59 239.82,169.55 242.87,169.55 v3(243.27,169.15)
  BOTTOM w0.102: 243.05,149.62 243.09,149.58 244.88,149.58 245.34,149.12 245.34,147.12 G2.AV49
  BOTTOM w0.152: U2022.F13 v3(243.27,169.15) ; 243.05,149.62 242.84,149.83 240.55,149.83 238.89,151.49 238.89,152.38 v3(238.98,152.48)
MDA48: length 41.8
  IN10 w0.14: v3(252.28,146.37) 252.28,153.79 252.38,153.88 252.38,157.63 248.63,161.37 248.63,168.15 248.39,168.39 248.39,176.18 245.09,179.48 242.34,179.48 241.52,178.65 241.52,178.11 v3(241.67,177.95)
  BOTTOM w0.152: U2022.U11 241.27,177.55 v3(241.67,177.95) ; v3(252.28,146.37) G2.AJ48
MDA49: length 38.8
  IN10 w0.14: v3(252.28,144.97) 251.42,145.84 251.42,148.55 251.26,148.71 251.26,157.16 247.51,160.9 247.51,167.69 247.27,167.93 247.27,175.32 244.24,178.35 243.68,178.35 v3(243.27,177.95)
  BOTTOM w0.152: G2.AJ46 v3(252.28,144.97) ; U2022.U13 v3(243.27,177.95)
MDA50: length 41.4
  IN10 w0.14: v3(241.67,177.15) 242.07,177.55 242.07,178.16 242.83,178.91 244.47,178.91 247.83,175.55 247.83,168.16 248.07,167.92 248.07,161.14 251.82,157.39 251.82,154.43 251.81,154.43 251.81,146.14 v3(252.28,145.67)
  BOTTOM w0.152: U2022.T11 v3(241.67,177.15) ; v3(252.28,145.67) G2.AJ47
MDA51: length 34.6
  IN10 w0.14: v3(250.83,147.22) 250.86,147.24 250.86,148.16 250.7,148.32 250.7,156.92 246.95,160.67 246.95,167.45 246.71,167.69 246.71,174.28 244.24,176.75 243.67,176.75 v3(243.27,177.15)
  BOTTOM w0.152: v3(243.27,177.15) 242.87,176.75 U2022.T13 ; G2.AK49 v3(250.83,147.22)
MDA52: length 35.9
  IN10 w0.14: v3(250.18,145.67) 249.87,145.99 249.87,147.69 250.14,147.96 250.14,156.69 246.39,160.44 246.39,167.22 246.16,167.46 246.16,173.31 244.32,175.15 242.08,175.15 v3(241.68,174.75)
  BOTTOM w0.152: G2.AM47 249.89,145.37 v3(250.18,145.67) ; U2022.N11 v3(241.68,174.75)
MDA53: length 34.2
  IN10 w0.14: v3(250.28,144.92) 249.58,145.62 249.58,156.45 245.84,160.2 245.84,166.98 245.6,167.22 245.6,173.08 244.32,174.35 243.68,174.35 v3(243.28,173.95)
  BOTTOM w0.152: U2022.N13 v3(243.28,173.95) ; v3(250.28,144.92) 250.14,144.92 G2.AM46
MDA54: length 35.8
  IN10 w0.14: v3(241.68,173.95) 242.07,173.55 244.33,173.55 244.73,173.16 244.73,167.3 245.28,166.75 245.28,157.89 243.98,156.59 243.98,153.58 245.69,151.87 248.27,151.87 248.92,151.21 248.92,148.71 249.3,148.33 249.3,146.78 v3(248.89,146.37)
  BOTTOM w0.152: U2022.M11 v3(241.68,173.95) ; G2.AN48 v3(248.89,146.37)
MDA55: length 31.9
  IN10 w0.14: v3(243.28,173.15) 243.28,171.88 243.8,171.35 243.8,167.01 244.06,166.75 244.48,166.75 244.72,166.51 244.72,158.12 243.42,156.82 243.42,153.63 245.73,151.32 247.77,151.32 248.45,150.64 248.45,148.27 248.89,147.83 v3(248.89,147.06)
  BOTTOM w0.152: G2.AN49 v3(248.89,147.06) ; U2022.M13 v3(243.28,173.15)
MDA56: length 45.6
  IN03 w0.14: v3(235.27,177.15) 235.73,177.61 237.31,177.61 239.07,175.84 239.07,172.58 240.42,171.23 240.42,162.89 243.26,160.06 246.64,160.06 250.11,156.58 250.11,148.76 249.53,148.18 249.53,143.62 v3(250.18,142.97)
  BOTTOM w0.152: G2.AM44 v3(250.18,142.97) ; U2022.U4 v3(235.27,177.15)
MDA57: length 47.5
  IN03 w0.14: v3(250.18,143.67) 249.77,144.08 249.77,147.62 250.59,148.44 250.59,156.9 246.75,160.73 243.37,160.73 241.27,162.83 241.27,170.16 241.05,170.39 241.05,171.46 239.62,172.88 239.62,176.14 237.83,177.93 235.39,177.93 235,177.55 234.07,177.55 v3(233.67,177.15)
  BOTTOM w0.152: U2022.U2 v3(233.67,177.15) ; G2.AM45 v3(250.18,143.67)
MDA58: length 42.9
  IN03 w0.14: v3(248.89,143.67) 249.29,144.07 249.29,148.73 249.67,149.11 249.67,156.23 246.54,159.36 243.01,159.36 239.72,162.65 239.72,170.72 238.56,171.88 238.56,175.36 237.17,176.75 236.47,176.75 v3(236.07,177.15)
  BOTTOM w0.152: U2022.T4 v3(236.07,177.15) ; G2.AN45 v3(248.89,143.67)
MDA59: length 45.3
  IN03 w0.14: v3(248.89,144.37) 248.03,144.37 247.24,143.58 247.24,142.91 246.94,142.61 246.34,142.61 245.48,143.47 245.48,146.67 245.86,147.06 245.86,149.97 241.96,153.87 241.7,153.87 241.47,154.09 241.47,156.94 236.7,161.72 236.7,169.1 235.86,169.93 235.86,170.73 235.44,171.15 235.11,171.15 233.92,171.15 233.27,171.79 233.27,175.21 233.67,175.61 v3(233.67,176.35)
  BOTTOM w0.152: G2.AN46 v3(248.89,144.37) ; U2022.T2 v3(233.67,176.35)
MDA60: length 35.7
  IN03 w0.14: v3(235.27,173.95) 235.67,173.55 236.26,173.55 236.47,173.33 236.47,172.9 237.44,171.93 237.44,171.13 238.38,170.18 238.38,162.4 243.15,157.63 243.15,154.2 245.99,151.37 247.73,151.37 248.19,150.91 248.19,148.74 247.69,148.23 247.69,146.76 v3(248.08,146.37)
  BOTTOM w0.152: v3(248.08,146.37) 247.79,146.07 G2.AR48 ; U2022.N4 v3(235.27,173.95)
MDA61: length 40
  IN03 w0.076: v3(248.89,145.07) 248.48,145.47 248.48,146.67
  IN03 w0.14: v3(234.48,173.95) 234.88,174.35 237.05,174.35 238.01,173.38 238.01,171.52 239.05,170.49 239.05,162.53 243.71,157.87 243.71,154.18 246.09,151.81 248.19,151.81 248.76,151.24 248.76,148.67 247.93,147.84 247.93,146.99 248.14,146.77 248.38,146.77 248.48,146.67
  BOTTOM w0.152: U2022.N2 234.07,174.35 v3(234.48,173.95) ; G2.AN47 v3(248.89,145.07)
MDA62: length 33.4
  IN03 w0.14: v3(248.08,145.67) 247.45,146.3 247.45,148.09 246.53,149.01 246.53,150.33 242.59,154.27 242.59,157.4 237.82,162.17 237.82,169.88 236.99,170.71 236.99,171.41 236.07,172.32 v3(236.07,173.15)
  BOTTOM w0.152: G2.AR47 v3(248.08,145.67) ; U2022.M4 v3(236.07,173.15)
MDA63: length 36
  IN03 w0.14: v3(248.08,144.97) 247.2,145.85 247.2,147.39 246.25,148.34 246.25,150.1 242.03,154.32 242.03,157.17 237.27,161.94 237.27,169.42 236.44,170.24 236.44,171.02 235.51,171.95 234.64,171.95 234.12,171.95 233.67,172.39 v3(233.67,173.15)
  BOTTOM w0.152: G2.AR46 v3(248.08,144.97) ; U2022.M2 v3(233.67,173.15)
MDB0: length 27.1
  IN10 w0.14: v3(266.98,134.57) 267.89,135.48 270.3,135.48 272.78,137.96 275.74,137.96 286.44,148.65 287.04,148.65 v3(287.22,148.47)
  BOTTOM w0.152: G2.H32 v3(266.98,134.57) ; v3(287.22,148.47) 287.28,148.54 U2023.U4
MDB1: length 23.7
  IN10 w0.14: v3(273.3,134.87) 273.73,135.3 276.25,135.3 287.3,146.34 287.3,146.53 v3(287.3,146.54)
  BOTTOM w0.102: v3(273.3,134.87) 272.86,135.31 271.9,135.31 271.81,135.22 269.84,135.22 G2.D32
  BOTTOM w0.152: U2023.U2 v3(287.3,146.54)
MDB2: length 22.3
  IN10 w0.14: v3(272.04,135.72) 273.14,136.82 276.19,136.82 287.11,147.74 287.7,147.74 v3(288.1,148.14)
  BOTTOM w0.152: U2023.T4 v3(288.1,148.14) ; v3(272.04,135.72) 271.88,135.57 G2.A33
MDB3: length 23.8
  IN10 w0.14: v3(272.71,134.87) 273.02,135.17 273.02,136.03 273.24,136.25 276.41,136.25 287.1,146.94 287.7,146.94 v3(288.1,146.54)
  BOTTOM w0.102: v3(272.71,134.87) 272.3,134.45 271.49,134.45 271.07,134.87 G2.B32
  BOTTOM w0.152: U2023.T2 v3(288.1,146.54)
MDB4: length 31.9
  IN10 w0.14: v3(269.94,134.42) 269.98,134.47 270.7,134.47 271.27,133.9 278.42,133.9 288,143.48 290.3,143.48 291.7,144.88 291.7,147.74 v3(291.3,148.14)
  BOTTOM w0.152: U2023.N4 v3(291.3,148.14) ; G2.E32 268.99,134.87 269.33,134.52 269.84,134.52 v3(269.94,134.42)
MDB5: length 31.4
  IN10 w0.14: v3(267.69,134.49) 268.39,135.18 270.68,135.18 272.88,137.38 275.95,137.38 286.63,148.05 287.41,148.05 287.89,148.54 289.97,148.54 290.1,148.41 290.1,146.94 v3(290.5,146.54)
  BOTTOM w0.152: G2.G32 267.39,134.8 v3(267.69,134.49) ; U2023.N2 v3(290.5,146.54)
MDB6: length 36.3
  IN10 w0.14: v3(292.1,148.14) 292.69,147.55 292.69,145.08 290.53,142.92 288.24,142.92 278.66,133.34 266.11,133.34 v3(265.69,133.77)
  BOTTOM w0.152: G2.J30 v3(265.69,133.77) ; U2023.M4 v3(292.1,148.14)
MDB7: length 29.9
  IN10 w0.14: v3(268.39,134.57) 268.68,134.86 270.74,134.86 271.15,134.46 278.19,134.46 287.77,144.04 290.07,144.04 290.9,144.87 290.9,146.14 v3(291.3,146.54)
  BOTTOM w0.152: U2023.M2 v3(291.3,146.54) ; G2.F32 v3(268.39,134.57)
MDB8: length 30.9
  IN03 w0.14: v3(266.39,137.37) 266.66,137.1 270.53,137.1 272.55,139.12 274.71,139.12 284.31,148.73 284.31,150.43 287.3,153.42 v3(287.3,154.54)
  BOTTOM w0.152: U2023.U11 v3(287.3,154.54) ; G2.H36 v3(266.39,137.37)
MDB9: length 30.9
  IN03 w0.076: 267.38,139.22 267.38,138.26 v3(267.09,137.97)
  IN03 w0.14: 267.38,139.22 267.8,139.64 270.7,139.64 271.87,140.81 274.01,140.81 282.64,149.43 282.64,151.22 285.49,154.07 285.49,154.96 286.66,156.13 287.3,156.13 v3(287.3,156.14)
  BOTTOM w0.152: G2.G36 v3(267.09,137.97) ; U2023.U13 v3(287.3,156.14)
MDB10: length 32.6
  IN03 w0.14: v3(288.1,154.54) 287.7,154.94 287.08,154.94 286.63,154.49 286.63,153.6 283.75,150.72 283.75,148.96 274.48,139.68 272.5,139.68 270.31,137.49 266.91,137.49 266.62,137.78 265.87,137.78 v3(265.69,137.97)
  BOTTOM w0.152: U2023.T11 288.5,154.14 v3(288.1,154.54) ; G2.J36 v3(265.69,137.97)
MDB11: length 30.8
  IN03 w0.076: v3(267.79,137.97) 267.79,138.11 268.17,138.49 268.17,139.05
  IN03 w0.14: 268.17,139.05 268.39,139.27 271.19,139.27 272.17,140.24 274.24,140.24 283.19,149.2 283.19,150.96 286.06,153.83 286.06,154.72 287.08,155.74 287.7,155.74 v3(288.1,156.14)
  BOTTOM w0.152: G2.F36 v3(267.79,137.97) ; U2023.T13 v3(288.1,156.14)
MDB12: length 33.2
  IN03 w0.076: 270.38,135.55 268.94,135.55 268.8,135.7 267.95,135.7 v3(267.69,135.97)
  IN03 w0.14: v3(290.5,154.54) 290.1,154.14 290.1,153.51 288.84,152.24 287.93,152.24 285.43,149.75 285.43,148.26 275.18,138.01 272.83,138.01 270.38,135.55
  BOTTOM w0.152: G2.F33 v3(267.69,135.97) ; U2023.N11 290.9,154.14 v3(290.5,154.54)
MDB13: length 32.5
  IN03 w0.14: v3(269.83,135.94) 269.83,136.31 270.15,136.63 270.76,136.63 272.28,138.15 272.69,138.57 274.94,138.57 284.87,148.49 284.87,150.08 287.74,152.95 288.75,152.95 289.3,153.5 289.3,155.54 289.49,155.74 290.1,155.74 v3(290.5,156.14)
  BOTTOM w0.152: v3(269.83,135.94) 269.83,135.91 G2.D33 ; U2023.N13 v3(290.5,156.14)
MDB14: length 37.2
  IN03 w0.076: v3(265.69,134.57) 266.33,135.21 268.65,135.21 268.79,135.07 270.8,135.07
  IN03 w0.14: v3(291.3,154.54) 291.7,154.14 291.7,152.73 289.56,150.59 288.28,150.59 286.65,148.96 286.65,147.9 275.65,136.89 272.62,136.89 270.8,135.07
  BOTTOM w0.152: U2023.M11 v3(291.3,154.54) ; v3(265.69,134.57) 265.98,134.87 G2.J32
MDB15: length 36.3
  IN03 w0.076: 270.61,135.31 268.9,135.31 268.75,135.46 267.5,135.46 v3(267.09,135.87)
  IN03 w0.14: v3(291.3,156.14) 290.9,155.74 290.9,153.11 289.2,151.41 288.14,151.41 286.03,149.3 286.03,148.06 275.41,137.45 272.74,137.45 270.61,135.31
  BOTTOM w0.152: U2023.M13 v3(291.3,156.14) ; G2.G33 v3(267.09,135.87)
MDB16: length 50.9
  IN03 w0.14: v3(269.08,144.27) 269.46,144.64 269.78,144.96 271.72,144.96 274.08,147.32 274.08,149.54 280.55,156.01 280.55,158.44 284.43,162.33 297.34,162.33 302.51,157.15 302.51,155.35 v3(300.9,153.74)
  BOTTOM w0.152: U2023.A11 v3(300.9,153.74) ; v3(269.08,144.27) G2.E45
MDB17: length 46
  IN03 w0.14: v3(300.9,155.34) 301.25,155.69 301.25,157.31 297.45,161.11 284.01,161.11 281.11,158.22 281.11,155.77 274.68,149.34 274.68,147.11 272.02,144.45 271.04,144.45 270.7,144.12 269.94,144.12 v3(269.79,144.27)
  BOTTOM w0.152: G2.D45 v3(269.79,144.27) ; U2023.A13 v3(300.9,155.34)
MDB18: length 48.5
  IN03 w0.14: v3(267.79,144.27) 268.25,143.8 272.16,143.8 275.32,146.96 275.32,149.19 281.67,155.54 281.67,157.5 284.72,160.55 297.22,160.55 300.69,157.09 300.69,155.99 300.5,155.8 300.5,154.14 v3(300.1,153.74)
  BOTTOM w0.152: U2023.B11 v3(300.1,153.74) ; v3(267.79,144.27) G2.F45
MDB19: length 45.4
  IN03 w0.14: v3(266.91,143.88) 267.41,143.39 272.28,143.39 272.55,143.39 276.43,147.27 276.43,149.51 282.23,155.31 282.23,156.58 285.63,159.98 296.91,159.98 299.7,157.19 299.7,156.54 v3(300.1,156.14)
  BOTTOM w0.152: G2.G45 266.99,143.97 v3(266.91,143.88) ; U2023.B13 v3(300.1,156.14)
MDB20: length 41.2
  IN03 w0.14: v3(269.79,142.17) 269.96,141.99 270.58,141.99 271.15,142.56 273.31,142.56 277.55,146.8 277.55,149.05 283.35,154.85 283.35,156.12 286.07,158.84 295.83,158.84 297.3,157.37 297.3,154.94 v3(297.7,154.54)
  BOTTOM w0.152: v3(297.7,154.54) 297.3,154.14 U2023.E11 ; G2.D42 v3(269.79,142.17)
MDB21: length 41.6
  IN03 w0.14: v3(269.09,142.17) 269.89,142.98 272.93,142.98 276.99,147.03 276.99,149.28 282.79,155.08 282.79,156.35 285.86,159.42 296.27,159.42 298.1,157.6 298.1,156.54 v3(297.7,156.14)
  BOTTOM w0.152: U2023.E13 297.3,155.74 v3(297.7,156.14) ; v3(269.09,142.17) G2.E42
MDB22: length 41.6
  IN03 w0.14: v3(296.9,154.54) 296.5,154.94 296.5,157.16 296.07,157.59 285.61,157.59 283.91,155.89 283.91,154.61 278.11,148.81 278.11,146.56 273.57,142.03 271.52,142.03 271.08,141.59 268.37,141.59 v3(267.79,142.17)
  BOTTOM w0.152: G2.F42 v3(267.79,142.17) ; U2023.F11 v3(296.9,154.54)
MDB23: length 39.6
  IN03 w0.14: v3(266.39,140.87) 266.8,141.29 269.29,141.29 269.45,141.13 271.48,141.13 271.72,141.37 273.7,141.37 278.67,146.33 278.67,148.58 284.47,154.38 284.47,155.66 285.35,156.54 294.43,156.54 295.7,156.54 296.1,156.14 v3(296.1,156.14)
  BOTTOM w0.152: G2.H41 v3(266.39,140.87) ; U2023.F13 296.5,155.74 v3(296.1,156.14)
MDB24: length 42.7
  IN10 w0.14: v3(269.1,140.8) 269.28,140.98 271.37,140.98 272.63,142.24 274,142.24 285.08,153.32 294.7,153.32 295.34,152.67 296.03,151.99 300.34,151.99 301.14,151.19 301.14,149.17 v3(300.1,148.14)
  BOTTOM w0.152: G2.E41 269.1,140.85 v3(269.1,140.8) ; U2023.A4 v3(300.1,148.14)
MDB25: length 46.9
  IN10 w0.14: v3(267.79,140.07) 267.79,140.23 268.03,140.47 268.03,140.81 268.47,141.25 270.87,141.25 272.67,143.05 274.03,143.05 285.11,154.14 295.05,154.14 295.9,153.29 298.3,153.29 299.17,152.42 300.99,152.42 301.95,151.45 301.95,148.39 300.9,147.34 v3(300.9,147.34)
  BOTTOM w0.152: U2023.A2 v3(300.9,147.34) ; G2.F39 v3(267.79,140.07)
MDB26: length 40.5
  IN10 w0.14: v3(300.1,148.94) 300.55,149.39 300.55,150.62 299.78,151.4 294.49,151.4 293.13,152.76 285.31,152.76 274.23,141.68 272.66,141.68 271.7,140.72 269.74,140.72 v3(269.09,140.07)
  BOTTOM w0.152: U2023.B4 299.7,148.54 v3(300.1,148.94) ; v3(269.09,140.07) G2.E39
MDB27: length 39.8
  IN10 w0.14: v3(269.79,140.07) 269.94,139.92 271.52,139.92 272.72,141.12 274.46,141.12 285.55,152.2 292.86,152.2 294.25,150.81 298.82,150.81 299.7,149.93 299.7,147.74 v3(300.1,147.34)
  BOTTOM w0.152: G2.D39 v3(269.79,140.07) ; U2023.B2 v3(300.1,147.34)
MDB28: length 40.2
  IN10 w0.14: v3(296.9,148.14) 297.3,148.54 298.03,148.54 298.23,148.74 298.23,150.06 298.04,150.25 293.96,150.25 292.56,151.64 285.78,151.64 274.7,140.56 272.86,140.56 271.84,139.54 268.87,139.54 268.54,139.21 v3(268.54,138.61)
  BOTTOM w0.152: v3(268.54,138.61) G2.F38 ; U2023.E4 v3(296.9,148.14)
MDB29: length 36.2
  IN10 w0.14: v3(269.1,138.7) 269.53,139.13 272.15,139.13 272.9,139.88 274.8,139.88 285.84,150.92 292.46,150.92 293.65,149.73 295.57,149.73 295.94,149.36 296.3,149.36 296.5,149.16 296.5,147.74 v3(296.9,147.34)
  BOTTOM w0.152: U2023.E2 v3(296.9,147.34) ; v3(269.1,138.7) 268.79,139.02 G2.E38
MDB30: length 33.2
  IN10 w0.14: v3(269.79,137.97) 270.14,137.61 271.22,137.61 272.83,139.22 274.94,139.22 285.97,150.25 292.37,150.25 293.37,149.25 295.4,149.25 295.72,148.94 v3(296.1,148.94)
  BOTTOM w0.152: G2.D36 v3(269.79,137.97) ; U2023.F4 296.5,148.54 v3(296.1,148.94)
MDB31: length 34.7
  IN10 w0.14: v3(269.09,137.97) 269.92,137.14 271.35,137.14 272.87,138.65 275.16,138.65 286.02,149.52 292.23,149.52 293,148.75 295.31,148.75 295.7,148.36 295.7,147.74 v3(296.1,147.34)
  BOTTOM w0.152: U2023.F2 296.5,146.94 v3(296.1,147.34) ; G2.E36 v3(269.09,137.97)
MDB32: length 20.6
  IN03 w0.14: v3(263.87,151.21) 263.87,151.21 263.87,152.22 268.94,157.29 268.94,162.52 270.33,163.9 v3(270.33,164.35)
  BOTTOM w0.102: G2.M50 263.89,147.67 263.54,148.02 263.54,148.32 263.29,148.57 263.29,149.81 263.42,149.94 263.42,150.75 263.87,151.21 v3(263.87,151.21)
  BOTTOM w0.152: U55.A4 v3(270.33,164.35)
MDB33: length 21.6
  IN03 w0.14: v3(262.88,146.32) 262.78,146.42 262.78,152.71 267.77,157.7 267.77,163.4 v3(268.73,164.35)
  BOTTOM w0.152: G2.P48 262.74,146.32 v3(262.88,146.32) ; U55.A2 v3(268.73,164.35)
MDB34: length 21
  IN03 w0.14: v3(263.87,149.94) 264.57,150.64 264.57,152.05 269.5,156.97 269.5,162 270.82,163.32 270.82,164.65 v3(270.33,165.15)
  BOTTOM w0.102: v3(263.87,149.94) 263.49,149.56 263.49,148.75 263.89,148.36 G2.M51
  BOTTOM w0.152: U55.B4 v3(270.33,165.15)
MDB35: length 22.1
  IN03 w0.14: v3(269.53,165.15) 269.13,164.75 269.13,163.74 268.38,163 268.38,157.52 263.34,152.48 263.34,149.22 263.92,148.63 263.92,147.61 v3(263.48,147.17)
  BOTTOM w0.152: U55.B2 v3(269.53,165.15) ; G2.M49 v3(263.48,147.17)
MDB36: length 30.3
  IN03 w0.14: v3(262.79,145.67) 262.48,145.97 262.48,148.01 261.35,149.14 261.35,154.36 261.72,154.74 263.22,154.74 266.59,158.1 266.59,167.03 267.51,167.95 269.93,167.95 v3(270.33,168.35)
  BOTTOM w0.152: U55.E4 v3(270.33,168.35) ; G2.P47 v3(262.79,145.67)
MDB37: length 22.8
  IN03 w0.14: v3(268.73,167.55) 268.33,167.15 267.7,167.15 267.19,166.64 267.19,157.91 262.22,152.94 262.22,150.9 v3(261.79,150.47)
  BOTTOM w0.102: G2.P52 262.49,149.77 v3(261.79,150.47)
  BOTTOM w0.152: U55.E2 v3(268.73,167.55)
MDB38: length 34
  IN03 w0.14: v3(261.48,144.37) 261.89,144.78 261.89,147.67 260.52,149.05 260.52,151.28 260.77,151.53 260.77,154.94 261.75,155.91 262.82,155.91 265.46,158.55 265.46,168.27 266.84,169.65 269.83,169.65 v3(270.33,169.15)
  BOTTOM w0.152: U55.F4 v3(270.33,169.15) ; G2.R46 v3(261.48,144.37)
MDB39: length 30.8
  IN03 w0.14: v3(262.88,144.82) 262.18,145.52 262.18,147.84 260.93,149.08 260.93,151.03 261.05,151.15 261.05,154.61 261.75,155.31 263.01,155.31 266.03,158.33 266.03,167.53 267.24,168.75 268.33,168.75 v3(268.73,168.35)
  BOTTOM w0.152: G2.P46 262.64,144.82 v3(262.88,144.82) ; U55.F2 v3(268.73,168.35)
MDB40: length 23.4
  IN10 w0.076: 264.76,152.84 264.76,150.25
  IN10 w0.14: 264.76,152.84 273.8,161.88 273.8,161.89 276.26,164.35 v3(276.73,164.35) ; 264.76,150.25 v3(265.49,149.52)
  BOTTOM w0.102: G2.L50 264.59,147.71 264.93,148.06 264.93,148.31 265.18,148.56 265.18,148.87 265.49,149.17 v3(265.49,149.52)
  BOTTOM w0.152: U55.A11 v3(276.73,164.35)
MDB41: length 24.1
  IN10 w0.14: v3(278.33,164.35) 278.54,164.13 278.54,162.38 271.37,155.21 270.64,155.21 266.97,151.54 266.97,150.46 266.48,149.96 265.77,149.96 v3(265.54,150.19)
  BOTTOM w0.102: G2.L51 264.59,148.42 264.92,148.76 264.92,149.86 265.04,149.98
  BOTTOM w0.152: U55.A13 v3(278.33,164.35) ; v3(265.54,150.19) 265.25,150.19 265.04,149.98
MDB42: length 23
  IN10 w0.076: 265,152.29 265,151.36
  IN10 w0.14: 265,152.29 276.18,163.47 276.58,163.47 277.13,164.02 277.13,164.75 276.73,165.15 v3(276.73,165.15) ; 265,151.36 v3(265.53,150.83)
  BOTTOM w0.102: G2.L52 264.59,150.11 264.77,150.29
  BOTTOM w0.152: v3(265.53,150.83) 265.3,150.83 264.77,150.29 ; U55.B11 v3(276.73,165.15)
MDB43: length 26.2
  IN10 w0.14: v3(265.4,152.1) 265.65,152.35 265.86,152.35 269.37,155.87 271.24,155.87 277.93,162.56 277.93,164.75 v3(278.33,165.15)
  BOTTOM w0.102: G2.L49 264.24,147.12 264.24,149.02 264.29,149.08 264.29,150.54
  BOTTOM w0.152: 264.29,150.54 264.53,150.77 264.53,151.36 265.27,152.1 v3(265.4,152.1) ; U55.B13 v3(278.33,165.15)
MDB44: length 33.6
  IN10 w0.076: 264.27,153.95 264.27,149.56
  IN10 w0.14: 264.27,153.95 268.63,158.31 268.63,158.31 274.42,164.09 274.42,167.26 275.1,167.95 U55.E11 v3(276.73,167.55) ; 264.27,149.56 264.51,149.33 264.51,148.62 264.27,148.39 264.27,144.36 v3(263.47,143.55)
  BOTTOM w0.1: v3(263.47,143.55) 263.53,143.61 263.96,143.61 264.19,143.84 264.19,144.36 G2.M46
  BOTTOM w0.152: U55.E11 v3(276.73,167.55)
MDB45: length 31.2
  IN10 w0.076: 264.51,153.39 264.51,149.86
  IN10 w0.14: 264.51,149.86 265.11,149.27 265.11,148.37 264.51,147.78 264.51,146.04 v3(264.88,145.67) ; 264.51,153.39 268.87,157.75 268.87,157.75 275.35,164.23 275.35,166.77 275.73,167.15 277.74,167.15 277.93,167.34 U55.E13 v3(278.33,168.35)
  BOTTOM w0.152: G2.L47 264.59,145.37 v3(264.88,145.67) ; U55.E13 v3(278.33,168.35)
MDB46: length 30.6
  IN10 w0.14: v3(263.47,146.34) 263.89,146.75 263.89,147.72 263.47,148.14 263.47,151.63 263.9,152.07 263.9,154.37 273.47,163.94 273.47,167.33 274.89,168.75 276.33,168.75 v3(276.73,168.35)
  BOTTOM w0.152: U55.F11 v3(276.73,168.35) ; v3(263.47,146.34) 263.62,146.34 G2.M48
MDB47: length 35.5
  IN10 w0.14: v3(278.33,169.15) 277.93,169.55 274.37,169.55 272.65,167.82 272.65,163.91 263.48,154.74 263.48,152.45 263.03,152 263.03,148.13 262.38,147.48 262.38,145.49 262.6,145.27 263.39,145.27 v3(263.58,145.07)
  BOTTOM w0.152: U55.F13 v3(278.33,169.15) ; G2.M47 v3(263.58,145.07)
MDB48: length 49.1
  IN10 w0.14: v3(269.18,145.77) 272.2,145.77 274.05,147.61 274.05,150.55 282.1,158.6 282.86,158.6 283.72,159.47 283.72,165.16 284.09,165.53 284.09,174.4 282.5,175.99 282.5,177.37 280.36,179.51 278,179.51 276.73,178.23 v3(276.73,177.95)
  BOTTOM w0.152: U55.U11 276.33,177.55 v3(276.73,177.95) ; G2.D48 v3(269.18,145.77)
MDB49: length 39
  IN10 w0.14: v3(278.33,177.95) 278.73,177.55 279.29,177.55 279.71,177.13 279.71,175.22 280.85,174.08 280.85,173.18 282.32,171.72 282.32,166.96 281.88,166.52 281.88,160.83 272.37,151.32 272.37,148.32 272.09,148.05 271.66,148.05 271.49,148.21 270.93,148.21 v3(270.49,147.77)
  BOTTOM w0.152: U55.U13 v3(278.33,177.95) ; G2.C50 v3(270.49,147.77)
MDB50: length 45.6
  IN10 w0.14: v3(276.73,177.15) 277.13,177.55 277.13,178.14 277.93,178.94 279.75,178.94 281.55,177.15 281.55,176.15 283.5,174.2 283.5,166.18 283.14,165.83 283.14,160.44 273.49,150.78 273.49,147.72 272.55,146.78 270.9,146.78 v3(270.49,146.37)
  BOTTOM w0.152: U55.T11 v3(276.73,177.15) ; G2.C48 v3(270.49,146.37)
MDB51: length 42.7
  IN10 w0.14: v3(278.33,177.15) 277.93,177.55 277.93,178.15 278.15,178.37 279.52,178.37 280.49,177.4 280.49,175.57 282.93,173.12 282.93,166.64 282.54,166.24 282.54,160.63 272.93,151.02 272.93,147.75 272.24,147.07 v3(270.49,147.07)
  BOTTOM w0.152: U55.T13 v3(278.33,177.15) ; G2.C49 v3(270.49,147.07)
MDB52: length 38
  IN10 w0.14: v3(276.73,174.75) 276.75,174.75 277.13,174.37 277.13,173.73 277.31,173.55 279.36,173.55 279.68,173.23 279.68,172.51 281.11,171.08 281.11,167.72 280.58,167.19 280.58,161.11 269.92,150.45 269.79,150.45 269.1,149.76 269.1,149.48 268.28,148.66 268.28,148.11 268.55,147.84 268.55,147 v3(269.09,146.47)
  BOTTOM w0.152: G2.E49 v3(269.09,146.47) ; U55.N11 v3(276.73,174.75)
MDB53: length 36.3
  IN10 w0.14: v3(278.33,174.75) 278.73,174.35 279.72,174.35 280.27,173.8 280.27,172.93 281.68,171.52 281.68,167.16 281.25,166.73 281.25,160.98 270.81,150.54 270.81,149.43 270.27,148.89 268.92,148.89 268.66,148.63 268.66,148.2 v3(269.09,147.77)
  BOTTOM w0.152: U55.N13 v3(278.33,174.75) ; G2.E50 v3(269.09,147.77)
MDB54: length 35.9
  IN10 w0.076: v3(267.69,146.37) 267.28,146.77 266.84,146.77
  IN10 w0.14: 266.84,146.77 266.48,147.13 266.48,148.64 279.33,161.48 279.33,163.87 278.84,164.36 278.84,171.05 276.72,173.16 276.72,173.95 v3(276.73,173.95)
  BOTTOM w0.152: U55.M11 v3(276.73,173.95) ; G2.F49 v3(267.69,146.37)
MDB55: length 34.3
  IN10 w0.14: v3(267.79,145.77) G2.F48 268.09,147.78 267.81,148.06 267.81,148.63 268.52,149.33 268.52,149.83 279.9,161.22 279.9,170.93 278.33,172.5 v3(278.33,173.15)
  BOTTOM w0.152: v3(267.79,145.77) G2.F48 ; U55.M13 278.33,173.15 v3(278.33,173.15)
MDB56: length 37.9
  IN03 w0.14: v3(271.13,177.15) 271.13,177.15 271.57,177.59 272.41,177.59 274.17,175.83 274.17,172.69 275.41,171.45 275.41,161.13 275.76,160.78 275.76,155.97 270.34,150.55 269.94,150.55 269.39,150.01 269.39,149.5 268.62,148.72 268.62,148.1 v3(267.69,147.17)
  BOTTOM w0.152: v3(271.13,177.15) 270.73,177.55 U55.U4 ; v3(267.69,147.17) 267.79,147.17 G2.F50
MDB57: length 38.1
  IN03 w0.14: v3(269.53,177.15) 270.38,178.01 272.86,178.01 274.65,176.22 274.65,173.02 276.33,171.34 276.33,156.36 276.32,156.36 276.32,155.75 270.7,150.12 270.09,150.12 v3(269.91,149.95)
  BOTTOM w0.152: G2.D52 269.44,148.91 269.44,149.48 v3(269.91,149.95) ; U55.U2 269.13,177.55 v3(269.53,177.15)
MDB58: length 34.8
  IN03 w0.14: v3(271.13,176.35) 271.53,175.95 272.13,175.95 273.18,174.9 273.18,171.38 274.02,170.54 274.02,156.86 270.68,153.53 270.68,152.4 268.66,150.38 268.36,150.38 265.74,147.77 v3(265.69,147.77)
  BOTTOM w0.152: U55.T4 v3(271.13,176.35) ; G2.J50 v3(265.69,147.77)
MDB59: length 39.9
  IN03 w0.14: v3(268.73,177.15) U55.T2 272.23,176.75 273.73,175.25 273.73,171.68 274.67,170.74 274.67,160.6 275.15,160.11 275.15,156.28 268.67,149.8 268.67,149.46 266.61,147.4 266.61,146.74 v3(266.98,146.37)
  BOTTOM w0.152: G2.H48 v3(266.98,146.37) ; U55.T2 v3(268.73,177.15)
MDB60: length 32.6
  IN03 w0.14: v3(270.33,173.95) 270.77,174.39 272.15,174.39 272.62,173.92 272.62,171.11 273.33,170.39 273.33,160.84 272.56,160.07 272.56,156.28 270.09,153.81 270.09,152.47 268.55,150.92 v3(267.59,150.92)
  BOTTOM w0.102: G2.H51 266.69,148.39 267.27,148.97 267.27,149.34
  BOTTOM w0.152: 267.27,149.34 267.27,150.32 267.59,150.64 v3(267.59,150.92) ; U55.N4 v3(270.33,173.95)
MDB61: length 31.7
  IN03 w0.14: v3(269.53,173.95) 269.93,173.55 271.3,173.55 271.53,173.32 271.53,172.75 271.95,172.33 271.95,170.92 272.74,170.13 272.74,161.1 272,160.36 272,156.63 267.1,151.73 267.1,149.95 265.71,148.57 v3(265.58,148.57)
  BOTTOM w0.152: G2.J51 v3(265.58,148.57) ; v3(269.53,173.95) 269.13,174.35 U55.N2
MDB62: length 30.3
  IN03 w0.14: v3(266.51,150.83) 266.51,151.97 271.44,156.9 271.44,160.68 272.18,161.42 272.18,169.85 271.08,170.96 271.08,172.33 270.33,173.08 v3(270.33,173.15)
  BOTTOM w0.152: U55.M4 v3(270.33,173.15) ; G2.H49 266.35,147.1 266.35,149.13 266.51,149.3 v3(266.51,150.83)
MDB63: length 30.4
  IN03 w0.14: v3(268.72,173.95) 269.13,173.55 269.13,170.57 269.35,170.35 270.85,170.35 271.58,169.62 271.58,161.68 270.89,160.98 270.89,157.24 266.08,152.43 v3(266.08,152.02)
  BOTTOM w0.102: G2.H52 266.92,149.1 266.92,149.3
  BOTTOM w0.152: v3(266.08,152.02) 266.92,151.17 266.92,149.3 ; v3(268.72,173.95) 269.12,173.55 U55.M2
MDC0: length 20.2
  IN10 w0.14: v3(269.89,117) 270.67,116.22 272.03,116.22 272.27,115.99 280.82,115.99 283.71,113.09 v3(287.43,113.09)
  BOTTOM w0.152: v3(287.43,113.09) 287.82,113.48 U2025.U4 ; v3(269.89,117) 270.19,116.71 G2.C6
MDC1: length 20.7
  IN10 w0.14: v3(287.43,111.49) 287.04,111.49 287.04,111.49 284.52,111.49 280.58,115.43 v3(273.22,115.43)
  BOTTOM w0.152: v3(273.22,115.43) 272.34,116.31 269.85,116.31 G2.D6 ; v3(287.43,111.49) 287.82,111.88 U2025.U2
MDC2: length 20.5
  IN10 w0.14: v3(272.41,117.01) 272.88,117.47 274.4,117.47 274.71,117.16 281.23,117.16 284.05,114.34 288.35,114.34 288.63,114.06 288.63,113.49 v3(288.23,113.09)
  BOTTOM w0.152: v3(272.41,117.01) 272.07,116.67 G2.A6 ; U2025.T4 288.62,113.48 v3(288.23,113.09)
MDC3: length 21.1
  IN10 w0.14: v3(288.23,111.49) 287.83,111.89 287.83,113.29 287.42,113.69 283.9,113.69 280.99,116.6 271.55,116.6 v3(271.18,116.97)
  BOTTOM w0.152: v3(288.23,111.49) 288.62,111.88 U2025.T2 ; v3(271.18,116.97) 270.89,116.67 G2.B6
MDC4: length 28.4
  IN10 w0.14: v3(291.43,113.09) 291.03,112.69 291.03,110.38 288.86,108.21 278.84,108.21 276.72,110.34 276.72,112.04 274.62,114.14 272.01,114.14 v3(271.18,114.97)
  BOTTOM w0.152: G2.B4 v3(271.18,114.97) ; v3(291.43,113.09) 291.03,113.48 U2025.N4
MDC5: length 22.8
  IN10 w0.14: v3(290.63,111.49) 290.63,111.49 290.23,111.09 290.23,110.38 289.92,110.08 286.97,110.08 286.23,110.82 284.39,110.82 280.61,114.61 275.04,114.61 275.04,114.61 273.16,114.61 272.77,114.61 v3(272.74,114.64)
  BOTTOM w0.152: G2.A4 271.71,115.14 272.24,115.14 v3(272.74,114.64) ; U2025.N2 291.02,111.88 v3(290.63,111.49)
MDC6: length 31
  IN10 w0.14: v3(292.23,113.09) 292.86,112.46 292.86,109.91 290.04,107.1 278.37,107.1 275.6,109.87 275.6,111.1 273.37,113.33 v3(272.73,113.33)
  BOTTOM w0.152: v3(292.23,113.09) 291.83,113.48 U2025.M4 ; G2.B3 271.24,114.22 271.84,114.22 v3(272.73,113.33)
MDC7: length 28.9
  IN10 w0.14: v3(270.49,114.97) 270.99,114.47 271.29,114.47 271.95,113.8 273.96,113.8 276.16,111.6 276.16,110.1 278.61,107.65 289.55,107.65 291.83,109.93 291.83,111.09 v3(291.43,111.49)
  BOTTOM w0.152: G2.C4 v3(270.49,114.97) ; U2025.M2 291.82,111.88 v3(291.43,111.49)
MDC8: length 19.3
  IN03 w0.14: v3(287.43,119.49) 287.37,119.54 272.36,119.54 271.37,118.55 270.3,118.55 v3(269.79,119.07)
  BOTTOM w0.152: G2.D9 v3(269.79,119.07) ; U2025.U11 287.83,119.09 v3(287.43,119.49)
MDC9: length 18.8
  IN03 w0.14: v3(287.43,121.09) 286.44,120.1 271.52,120.1 v3(270.49,119.07)
  BOTTOM w0.152: G2.C9 v3(270.49,119.07) ; v3(287.43,121.09) 287.83,120.69 U2025.U13
MDC10: length 21.4
  IN03 w0.14: v3(268.93,119.2) 270.01,118.12 271.86,118.12 272.12,118.38 273.62,118.38 274.22,118.98 287.72,118.98 v3(288.23,119.49)
  BOTTOM w0.152: G2.E9 268.93,118.92 v3(268.93,119.2) ; U2025.T11 v3(288.23,119.49)
MDC11: length 19.2
  IN05 w0.076: 287.13,120.68 287.82,120.68 288.23,121.08 v3(288.23,121.09)
  IN05 w0.14: v3(272.26,118.84) 273.26,119.84 286.3,119.84 287.13,120.68
  BOTTOM w0.152: v3(272.26,118.84) 271.84,118.42 271.24,118.42 G2.B9 ; v3(288.23,121.09) 288.63,120.69 U2025.T13
MDC12: length 23.4
  IN03 w0.14: v3(272.99,117.01) 273.96,116.04 283.94,116.04 284.23,115.74 287.87,115.74 290.23,118.1 290.23,119.09 v3(290.63,119.49)
  BOTTOM w0.152: v3(272.99,117.01) 272.3,117.7 271.25,117.7 G2.B8 ; v3(290.63,119.49) 291.03,119.09 U2025.N11
MDC13: length 23.3
  IN03 w0.14: v3(274.15,117.01) 274.57,116.6 283.93,116.6 284.25,116.92 288.18,116.92 289.43,118.17 289.43,119.69 289.63,119.89 290.03,119.89 290.23,120.08 290.23,120.69 v3(290.63,121.09)
  BOTTOM w0.152: U2025.N13 v3(290.63,121.09) ; G2.A8 273.11,118.07 274.15,117.03 v3(274.15,117.01)
MDC14: length 28.6
  IN03 w0.14: v3(268.39,116.37) 268.63,116.12 272.08,116.12 272.64,115.56 272.64,115.32 273.35,114.61 288.79,114.61 291.83,117.65 291.83,119.09 v3(291.43,119.49)
  BOTTOM w0.152: U2025.M11 291.83,119.09 v3(291.43,119.49) ; G2.F6 v3(268.39,116.37)
MDC15: length 28.7
  IN03 w0.14: v3(291.43,121.09) 291.03,120.69 291.03,118.01 288.2,115.18 282.76,115.18 282.47,115.48 273.78,115.48 272.7,116.56 268.9,116.56 v3(268.49,116.97)
  BOTTOM w0.152: v3(268.49,116.97) G2.E6 ; v3(291.43,121.09) 291.83,120.68 U2025.M13
MDC16: length 43.1
  IN03 w0.076: 268.86,126.35 268.66,126.55 268.15,126.55 267.98,126.38 267.98,125.77 v3(267.69,125.47)
  IN03 w0.14: v3(301.02,118.69) 301.03,118.69 302.55,120.2 302.55,122.88 299.55,125.88 271.54,125.88 271.07,126.35 268.86,126.35
  BOTTOM w0.152: G2.F18 v3(267.69,125.47) ; v3(301.02,118.69) 300.63,119.08 U2025.A11
MDC17: length 38.3
  IN03 w0.14: v3(267.09,125.37) 267.52,124.93 270.55,124.93 271.16,124.32 285.65,124.32 285.95,124.62 299.19,124.62 301.43,122.38 301.43,121.49 v3(301.03,121.08)
  BOTTOM w0.152: G2.G18 v3(267.09,125.37) ; U2025.A13 v3(301.03,121.08)
MDC18: length 40.8
  IN03 w0.14: v3(300.22,118.69) 300.23,118.69 300.63,119.09 300.63,119.66 300.86,119.88 301.26,119.88 301.99,120.62 301.99,122.64 299.45,125.18 285.69,125.18 285.39,124.88 271.73,124.88 270.54,126.07 269.78,126.07 v3(269.09,125.37)
  BOTTOM w0.152: U2025.B11 299.83,119.08 v3(300.22,118.69) ; v3(269.09,125.37) G2.E18
MDC19: length 39.8
  IN03 w0.14: v3(300.22,120.29) 300.63,120.69 300.63,122.38 298.95,124.06 286.29,124.06 285.56,123.33 271.52,123.33 270.37,124.48 267.28,124.48 v3(266.21,125.54)
  BOTTOM w0.152: v3(300.22,120.29) 299.83,120.68 U2025.B13 ; G2.H18 v3(266.21,125.54)
MDC20: length 34
  IN03 w0.14: v3(269.96,123.54) 270.17,123.33 270.82,123.33 271.39,122.77 285.79,122.77 286.53,123.5 297.45,123.5 298.22,122.72 298.22,119.88 297.83,119.49 v3(297.82,119.49)
  BOTTOM w0.152: U2025.E11 297.43,119.09 v3(297.82,119.49) ; v3(269.96,123.54) 269.96,123.46 269.49,122.99 G2.D15
MDC21: length 33.1
  IN03 w0.14: v3(268.87,123.55) 269.44,122.98 270.58,122.98 271.35,122.21 286.03,122.21 286.71,122.89 290.55,122.89 290.85,122.59 292.65,122.59 292.95,122.89 296.63,122.89 297.42,122.1 297.42,120.69 v3(297.02,120.29)
  BOTTOM w0.152: G2.E15 268.79,123.46 v3(268.87,123.55) ; v3(297.02,120.29) 297.42,120.68 U2025.E13
MDC22: length 34.1
  IN03 w0.14: v3(267.69,123.97) 269.06,122.59 270.36,122.59 271.3,121.65 286.26,121.65 286.94,122.33 296.37,122.33 296.62,122.08 296.62,119.89 v3(297.02,119.49)
  BOTTOM w0.152: G2.G17 267.39,124.32 267.69,124.02 v3(267.69,123.97) ; U2025.F11 296.63,119.09 v3(297.02,119.49)
MDC23: length 33
  IN03 w0.14: v3(266.39,124.07) 266.64,123.82 266.64,122.87 266.98,122.53 267.95,122.53 268.26,122.21 270.13,122.21 271.26,121.09 286.44,121.09 286.84,121.49 294.08,121.49 294.48,121.08 v3(296.22,121.08)
  BOTTOM w0.152: v3(296.22,121.08) 296.62,120.68 U2025.F13 ; G2.H17 v3(266.39,124.07)
MDC24: length 41.6
  IN10 w0.14: v3(265.69,123.27) 266.59,122.36 271.77,122.36 272.57,121.57 276.36,121.57 276.67,121.26 285.05,121.26 288.53,117.77 293.52,117.77 294.03,117.26 298.81,117.26 299.58,116.49 300.3,116.49 301.42,115.36 301.42,114.29 301.02,113.89 v3(301.02,113.89)
  BOTTOM w0.152: v3(301.02,113.89) 300.63,113.49 U2025.A4 ; G2.J15 v3(265.69,123.27)
MDC25: length 44.8
  IN10 w0.14: v3(301.02,112.29) 302.13,113.4 302.13,115.49 300.48,117.14 299.53,117.14 298.46,118.21 288.85,118.21 288.63,118.43 288.63,119.74 288.48,119.89 287.21,119.89 285.28,121.81 276.61,121.81 276.45,121.98 272.86,121.98 272.23,122.6 267.05,122.6 v3(266.23,123.42)
  BOTTOM w0.152: U2025.A2 300.63,111.9 v3(301.02,112.29) ; G2.H15 v3(266.23,123.42)
MDC26: length 36.2
  IN10 w0.14: v3(268.87,121.72) 268.96,121.81 271.1,121.81 272.27,120.64 275.18,120.64 275.67,120.14 284.08,120.14 287.28,116.94 293.01,116.94 293.71,116.24 298.58,116.24 299.82,115 299.82,114.29 v3(300.22,113.89)
  BOTTOM w0.152: G2.E14 268.79,121.81 v3(268.87,121.72) ; v3(300.22,113.89) 299.83,113.49 U2025.B4
MDC27: length 40.2
  IN10 w0.14: v3(300.22,112.29) 300.22,113.12 300.62,113.52 300.62,115.32 300.14,115.8 299.67,115.8 298.7,116.77 293.82,116.77 293.23,117.35 288.01,117.35 284.66,120.7 276.22,120.7 275.82,121.1 272.37,121.1 271.35,122.12 267.94,122.12 v3(267.68,121.86)
  BOTTOM w0.152: v3(300.22,112.29) 299.83,111.9 U2025.B2 ; G2.F14 v3(267.68,121.86)
MDC28: length 36.9
  IN10 w0.14: v3(266.39,119.87) 267.22,120.7 271.58,120.7 272.12,120.15 274.64,120.15 275.21,119.58 283.62,119.58 286.68,116.52 292.72,116.52 293.61,115.63 296.9,115.63 297.43,115.1 297.43,113.49 v3(297.02,113.09)
  BOTTOM w0.152: G2.H11 v3(266.39,119.87) ; U2025.E4 297.42,113.48 v3(297.02,113.09)
MDC29: length 37
  IN10 w0.14: v3(297.02,111.49) 296.62,111.89 296.62,114.15 296.4,114.38 295.99,114.38 295.41,114.96 293.5,114.96 292.36,116.1 285.86,116.1 285.09,116.87 284.69,116.87 282.54,119.02 274.76,119.02 274.11,119.67 271.89,119.67 271.45,120.11 270.9,120.11 270.56,120.44 267.79,120.44 267.39,120.03 267.39,119.37 v3(267.44,119.32)
  BOTTOM w0.102: v3(267.44,119.32) 267.39,119.37 G2.G11
  BOTTOM w0.152: v3(297.02,111.49) 297.42,111.88 U2025.E2
