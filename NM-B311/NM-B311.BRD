# Allegro board NM-B311.BRD (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V_USB1 on BOTTOM, IN10: 15.84,62.82 15.84,59.39 14.7,58.25 6.95,58.25 6.06,59.13 6.06,63.45 9.75,67.14 15.72,67.14 16.1,66.75 16.1,63.07
+5V_USB1 on IN08: 15.84,62.82 15.84,59.39 14.7,58.25 7.08,58.25 6.06,59.26 6.06,63.45 9.75,67.14 15.72,67.14 16.1,66.75 16.1,63.07
+5V_USB2 on TOP (solid shape): outline of 142 points within 8.79,31.7 20.67,39.32
+5V_USB2 on BOTTOM: 7.23,38.74 17.11,38.74 18.13,37.72 18.13,34.32 17.88,34.06 11.86,34.06 11.32,33.53 11.32,32.34 10.89,31.91 7.56,31.91 6.75,32.72 6.75,38.21 6.73,38.23
+5V_USB_KB on BOTTOM (solid shape): outline of 693 points within 60.67,10.85 91.82,17.99
+5VA_AUD on BOTTOM: 291.18,37.77 291.18,37.29 291.05,37.16 290.49,37.16 290.32,37.34 290.32,39.7 289.86,40.16 289.86,40.29 289.99,40.41 290.25,40.41 290.63,40.03 291.46,40.03 291.59,39.9 291.59,38.18
+5VALW on TOP (solid shape): 271.75,51.13 273.78,51.13 274.03,50.88 274.03,49.61 273.53,49.1 270.99,49.1 270.73,49.36 270.73,51.26 270.99,51.51 271.37,51.51
+5VALW on BOTTOM (solid shape): 302.74,44.6 303.75,44.6 304.01,44.35 304.01,41.43 303.63,41.05 301.72,41.05 300.96,40.29 300.48,40.29 300.3,40.46 300.3,44.65 300.51,44.86 302.48,44.86
+5VALW on TOP: 17.75,69.8 15.08,69.8 14.83,70.06 14.83,71.71 15.21,72.09 17.49,72.09 17.88,71.71 17.88,69.93
+5VALW on TOP: 273.27,193.75 273.27,188.29 273.78,187.79 275.18,187.79 275.43,188.04 275.43,193.5 274.8,194.14 273.65,194.14
+5VALW on TOP: 40.74,73.61 43.28,73.61 43.48,73.41 43.48,70.77 42.51,69.8 40.66,69.8 40.35,70.11 40.35,73.23
+5VALW on TOP: 102.33,87.42 102.82,87.42 102.87,87.38 102.87,85.19 102.46,84.79 100.17,84.79 99.66,85.3 99.66,87.2 99.92,87.46 102.29,87.46
+5VALW on TOP: 270.64,16.76 270.64,16.13 270.76,16 272.54,16 272.67,16.13 272.67,17.91 272.54,18.03 272.16,18.03 271.91,18.29 271.91,20.32 271.78,20.45 269.87,20.45 269.75,20.32 269.75,18.54 270,18.29 270,17.4
+5VALW on TOP: 18.76,18.49 20.29,18.49 20.42,18.37 20.42,17.73 20.54,17.61 23.08,17.61 23.34,17.35 23.34,10.48 23.38,10.44 23.87,10.44 23.91,10.39 23.91,10.01 23.88,9.98 23.38,9.98 23.37,9.97 23.37,9.25 23.39,9.23 23.9,9.23 23.92,9.21 23.92,8.8 23.9,8.78 23.39,8.78 23.37,8.76 23.37,8.07 23.17,7.87 19.13,7.87 18.76,8.24
+5VALW on BOTTOM: 175.36,182.62 175.36,181.69 175.48,181.56 176.86,181.56 177.01,181.7 177.01,182.56 176.91,182.66 175.39,182.66
+5VALW on BOTTOM: 209.39,184.23 209.39,183.72 209.01,183.34 209.01,182.32 208.88,182.2 208.88,179.78 209.01,179.66 209.77,179.66 210.03,179.91 210.03,182.71 210.66,183.34 210.66,183.98 210.28,184.36 209.52,184.36
+5VALW on BOTTOM: 59.15,11.89 57.88,11.89 57.75,12.02 56.23,12.02 56.1,12.14 56.1,13.29 56.36,13.54 58.9,13.54 59.15,13.29
+5VALW on BOTTOM: 16.61,42.75 16.61,40.72 16.99,40.34 16.99,39.32 16.73,39.07 13.3,39.07 12.8,39.58 12.8,42.88 12.92,43.01 16.35,43.01
+5VALW on BOTTOM: 117.19,190.71 119.35,190.71 119.48,190.58 119.48,189.94 119.35,189.82 118.59,189.82 118.33,189.56 118.33,188.67 118.21,188.55 117.06,188.55 116.94,188.67 116.94,190.45
+5VALW on BOTTOM: 198.47,184.23 198.47,183.72 198.09,183.34 198.09,182.32 198.22,182.2 199.23,182.2 199.74,182.71 199.74,183.98 199.36,184.36 198.6,184.36
+5VALW on BOTTOM: 272.26,195.91 274.8,195.91 275.05,195.66 275.05,193.12 274.8,192.87 272.38,192.87 272.13,193.12 272.13,193.5 272.26,193.63 273.15,193.63 273.4,193.88 273.4,195.15 273.27,195.28 272.26,195.28 272.13,195.41 272.13,195.79
+5VALW on BOTTOM: 187.46,182.24 188.68,182.24 188.84,182.4 188.84,183.2 188.76,183.28 187.41,183.28 187.31,183.18 187.31,182.4
+5VALW on IN03: 59.79,69.93 53.44,69.93 53.44,77.3 55.21,79.07 57.25,79.07 67.79,89.61 75.66,89.61 90.14,104.09 98.01,104.09 107.66,113.74 107.66,121.49 112.68,126.51 118.46,126.51 118.46,165.69 123.72,170.95 130.22,170.95 131.92,169.24 131.92,162.89 131.29,162.26 127.22,162.26 126.21,161.24 126.21,118.06 107.54,99.39 107.54,91.52 105,88.98 105,87.71 105.56,87.15 107.29,87.15 107.95,86.49 107.95,85.98 107.7,85.72 106.93,85.72 106.55,85.34 106.55,78.98 104.36,76.79 96.49,76.79 93.31,79.96 69.82,79.96
+5VALW on IN03: outline of 161 points within 149.45,180.55 203.04,193.55
+5VALW on IN03: outline of 148 points within 222.68,40.39 309.47,200.74
+5VALW on IN05: 127.35,43.26 193.77,43.26 195.42,44.91 213.96,44.91 214.98,43.89 224.12,43.89 224.89,43.13 228.7,43.13 229.2,42.62 229.2,38.71 228.29,37.8 204.37,37.8 203.33,38.84 200.66,38.84 199.62,37.8 127.22,37.8 126.59,38.43 126.59,42.5
+5VALW on IN05: 116.43,190.2 117.95,190.2 118.21,189.94 118.21,181.05 128.49,170.77 130.02,170.77 130.65,170.13 130.65,168.61 130.4,168.35 128.11,168.35 115.54,180.93 115.54,189.31
+5VALW on VCC06: 18.02,1.02 18.02,13.71 18,13.72 17.43,14.93 16.22,15.5 16.21,15.52 13.43,15.52 13.43,59.75 9.87,63.3 9.87,71.35 11.25,72.72 19.55,72.72 22.7,69.57 22.7,54.54 21.05,52.89 21.05,30.96 31.11,20.91 74.62,20.91 90.37,36.66 110.27,36.66 118.98,45.37 152.81,45.37 154,46.56 187.78,46.56 190.95,49.74 204.59,49.74 204.97,49.36 247.98,49.36 250.39,51.77 295.09,51.77 297,53.67 303.65,53.67 304.26,53.06 304.26,48.7 302.74,47.17 302.74,41.46 301.23,39.96 294,39.96 294,40.11 293.27,40.85 291.13,40.85 289.91,39.63 289.91,36.89 289.8,36.78 278.95,36.78 277.88,35.71 277.88,19.41 277.14,18.67 270.49,18.67 270,19.16 270,21.06 268.99,22.08 268.99,36.13 268.33,36.78 263.43,36.78 263.38,36.73 262.73,37.6 261.72,38 261.71,38.02 124.09,38.02 124.08,38 122.87,37.43 122.3,36.22 122.28,36.21 122.28,28.08 115.66,28.08 115.65,28.06 114.44,27.49 113.86,26.28 113.85,26.27 113.85,1.02 97.52,1.02 97,2.35 95.72,3 95.71,3.01 62.99,3.01 62.98,3 61.7,2.35 61.18,1.02
+5VALW on IN08: 271.37,48.09 273.65,48.09 275.3,46.43 304.01,46.43 305.4,47.83 305.4,52.91 304.13,54.18 298.16,54.18 295.37,56.98 271.49,56.98 270.35,55.83 270.35,49.1
+5VALW on IN08: 61.82,48.21 62.3,47.73 62.3,34.34 53.78,25.82 53.78,20.78 53.02,20.02 50.64,20.02 49.37,18.75 49.37,11.23 47.87,9.73 19.15,9.73 18.51,10.37 18.51,16.46 18.54,16.49 18.54,19.74 13.43,24.84 13.43,47.58 15.84,49.99 15.84,54.18 16.99,55.32 16.99,66.88 14.57,69.29 14.57,71.96 14.95,72.34 18.26,72.34 20.16,70.44 20.16,67.9 20.42,67.64 21.43,67.64 21.94,67.14 21.94,54.94 20.42,53.42 20.42,45.04 18.64,43.26 18.64,42.62 20.29,40.97 20.29,30 21.81,28.48 31.21,28.48 32.18,27.51 41.62,27.51 42.87,28.76 42.87,32.74 49.07,38.94 49.07,43.82 49.12,43.87 49.12,56.62 49.75,57.26 52.67,57.26 52.95,57.53 52.95,61.65 47.97,66.63 44.93,66.63 41.37,70.18 41.37,73.1 41.75,73.49 47.82,73.49 47.84,73.5 48.62,73.5 49.63,74.5 57.3,74.5 61.82,69.98
+5VALW on IN08: 176.75,192.4 176.63,192.27 165.14,192.27 164.85,192.55 164.85,193.21 164.92,193.27 164.92,193.6 165.2,193.88 176.5,193.88 176.75,193.63
+5VALW on IN10: 149.96,185.75 151.35,185.75 151.73,185.37 151.73,181.44 149.32,179.02 149.32,174.83 147.42,172.93 135.35,172.93 133.57,171.15 133.57,168.61 132.81,167.85 128.62,167.85 128.37,168.1 128.37,172.16 136.11,179.91 146.27,179.91 149.45,183.09 149.45,185.25
+5VALW on IN10: 122.14,49.74 132.18,49.74 133.7,48.21 133.7,45.16 130.27,41.74 130.27,38.94 129.89,38.56 127.35,38.56 126.52,39.39 120.05,39.39 118.21,41.23 118.21,45.8
+5VALW on IN10: 13.18,46.05 13.18,38.94 13.68,38.43 19.91,38.43 21.3,39.83 21.3,50.12 23.34,52.15 23.34,70.69 20.16,73.87 15.59,73.87 14.57,72.85 14.57,70.18 17.37,67.39 17.37,50.24
+5VALW_USB_CHG on TOP (solid shape): 26.64,40.47 26.64,38.69 26.13,38.18 26.13,37.16 26,37.04 23.34,37.04 22.96,37.42 22.96,39.2 23.08,39.32 24.07,39.32 24.21,39.17 24.25,39.14 24.72,39.03 25.11,39.32 25.11,39.32 25.11,40.13 25.58,40.59 26.51,40.59
+5VALW_USB_CHG on BOTTOM: 17.24,41.48 17.24,40.59 17.75,40.08 17.75,39.07 20.42,36.4 22.83,36.4 23.27,36.85 25.43,36.85 25.62,37.04 25.62,38.69 25.24,39.07 21.3,39.07 20.42,39.96 20.42,41.35 19.91,41.86 17.62,41.86
+5VALWP on TOP: 33.62,4.4 24.51,4.4 24.13,4.78 24.13,6.35 24.1,6.38 24.1,11.13 24.73,11.76 26.26,11.76 27.4,12.91 29.13,12.91 29.54,12.5 29.54,9.09 30.81,7.82 32.33,7.82 33.62,6.53
+5VD_AUD on TOP: 288.89,39.07 289.07,38.89 289.55,38.89 289.68,39.02 289.68,39.07 289.78,39.17 289.78,40.47 289.66,40.59 289.02,40.59 288.89,40.47
+5VD_AUD on BOTTOM: 289.66,37.16 289.78,37.29 289.78,39.81 289.38,40.21 286.86,40.21 286.61,39.96 286.61,37.29 286.73,37.16
+12V_PUMP on TOP: 281.18,17.91 281.3,17.78 283.59,17.78 283.72,17.65 283.72,15.88 283.84,15.75 286.89,15.75 287.12,15.52 287.12,14.66 287.43,14.35 288.67,14.35 288.8,14.48 288.8,14.86 288.67,14.99 288.16,14.99 288.04,15.11 288.04,17.53 288.67,18.16 288.67,19.18 288.54,19.3 287.91,19.3 287.4,18.8 281.3,18.8 281.18,18.67
+12V_SWF_BOOST on TOP (solid shape): 272.89,60.66 273.01,60.54 273.01,60.43 273.42,60.02 273.48,59.91 273.58,59.82 274.07,59.68 274.27,60.15 278.86,60.15 279.11,59.9 279.11,59.64 279.24,59.52 279.37,59.52 280.07,58.82 284.89,58.82 285.08,58.63 285.08,55.83 284.7,55.45 280.38,55.45 279.24,56.59 277.72,56.59 276.83,57.48 275.84,57.48 274.19,59.13 273.7,59.13 273.32,59.52 272.92,59.52 272.64,59.8 272.64,61.55 272.89,61.55
+12V_SWF_BOOST on BOTTOM (solid shape): 284.7,56.98 284.7,54.82 284.58,54.69 280.44,54.69 280,55.12 280,56.85 280.51,57.36 284.32,57.36
+AVDD33_LAN on BOTTOM: 41.37,64.98 41.5,65.1 41.5,67.9 42.39,67.9 42.39,64.98 42.26,64.85 42.26,64.47 42.01,64.21 40.61,64.21 40.48,64.09 40.48,63.45 40.61,63.33 42.89,63.33 43.28,62.94 44.04,62.94 44.16,62.82 44.16,62.06 43.91,61.8 43.4,61.8 43.28,61.67 39.34,61.67 38.96,62.06 38.96,64.72 39.21,64.98
+AVDDL_LAN on BOTTOM: 52.1,60.02 52.36,60.28 53.88,60.28 54.26,59.9 54.26,58.12 53.88,57.74 52.36,57.74 52.1,57.99
+AVDDL_LAN on IN05: 54.07,60.28 54.07,59.77 53.82,59.52 45.31,59.52 45.18,59.64 45.05,59.64 44.93,59.77 43.63,59.77 43.02,60.38 43.02,63.96 43.19,64.13 44.48,64.13 44.75,63.86 44.75,61.4 45.23,60.91 48.64,60.91 48.74,61.01 48.74,64.72 47.64,65.81 46.93,65.81 46.63,66.12 46.63,66.32 46.86,66.55 48.18,66.55 49.5,65.23 49.5,61.93 49.88,61.55 52.8,61.55
+DVDDL_LAN on TOP: 51.4,65.1 59.53,65.1 59.79,64.85 59.79,63.45 59.4,63.07 53.79,63.07 53.49,63.38 51.23,63.38 51.18,63.33 50.77,63.33 50.51,63.58 50.51,64.21
+DVDDL_LAN on BOTTOM: 55.09,57.36 55.21,57.23 57.12,57.23 57.37,57.48 57.37,58.75 57.25,58.88 55.09,58.88
+DVDDL_LAN on IN10: 57.88,64.98 58.9,64.98 59.79,64.09 59.79,57.48 59.02,56.72 54.83,56.72 54.58,56.98 54.58,58.63 54.83,58.88 56.99,58.88 57.5,59.39 57.5,64.6
+PVCC_AMP on TOP: 266.08,34.24 269.36,34.24 269.62,33.99 270.15,33.99 270.35,34.19 270.35,35.72 270.28,35.79 269.72,35.79 269.59,35.67 269.59,35.31 269.4,35.12 269.22,35.12 269.21,35.13 267.81,35.13 267.63,34.95 266.14,34.95 266.06,34.88 266.06,34.27
+PVCC_AMP on TOP: 276.52,33.76 276.55,33.79 277.11,33.79 277.44,33.46 278.33,33.46 278.4,33.53 278.4,34.04 278.25,34.19 277.95,34.19 276.93,35.21 275.46,35.21 275.08,35.59 274.82,35.59 274.54,35.31 274.54,33.76 274.82,33.48 275.18,33.48 275.46,33.76
+PVCC_AMP on BOTTOM: 277.34,33.48 277.21,33.35 275.05,33.35 274.29,34.12 274.29,38.69 274.16,38.81 270.86,38.81 269.84,37.8 269.84,36.4 270.22,36.02 270.22,34.24 269.91,33.93 267.49,33.93 267.3,34.12 267.3,36.66 265.91,38.05 265.91,38.31 268.07,40.47 268.19,40.47 268.83,41.1 269.8,41.1 270.76,42.06 276.15,42.06 277.34,40.87
+V1.00DX on TOP: 204.95,156.04 206.22,156.04 206.22,159.46 205.07,160.61 203.55,160.61 203.42,160.48 203.42,159.97 203.4,159.95 203.4,157.84 203.42,157.81 203.42,156.92 203.17,156.67 202.66,156.67 201.9,157.43 201.64,157.43 201.26,157.81 200.4,157.81 200.27,157.69 200.27,156.85 200.45,156.67 200.86,156.67 201.75,155.78 204.69,155.78
+V1.0U_VCCST_VCCSFR on TOP: 200.02,156.29 200.96,156.29 201.21,156.04 201.21,154.79 200.88,154.46 200.88,153.5 199.82,153.5 199.23,154.08 199.23,154.61 199.77,155.15 199.77,156.04
+V3.3A_1.8A_VCCPGPPA on IN03: 230.19,52.05 231.03,52.05 231.59,52.61 232.12,52.61 232.91,53.39 232.91,53.93 232.61,54.23 231.39,54.23 229.91,52.76 229.91,52.33
+V3.3A_VCCPGPPD on BOTTOM: 223.49,52.35 223.49,53.29 223.62,53.42 226.28,53.42 227.04,52.66 227.04,52.4 226.66,52.02 225.29,52.02 225.11,52.2 223.64,52.2
+V3.3A_VCCPGPPEF on TOP (solid shape): 229.71,59.52 229.71,58.75 229.91,58.55 229.91,57.51 229.61,57.2 228.42,57.2 228.26,57.36 228.26,59.01 228.34,59.08 228.44,59.08 229,59.64 229.58,59.64
+V3.3A_VCCPSPI on BOTTOM: 227.17,51.51 228.31,51.51 228.44,51.39 228.44,49.23 227.93,48.72 227.93,47.32 227.81,47.2 226.28,47.2 226.16,47.32 226.16,48.7 226.41,48.95 226.41,49.61 227.04,50.24 227.04,51.39
+VCC19P2_1P0 on TOP: 250.41,68.02 249.4,68.02 248.94,67.57 247.59,67.57 247.14,68.02 246.91,68.02 246.81,67.92 244.37,67.92 244.34,67.95 244.22,67.82 241.47,67.82 241.29,67.64 240.66,67.64 239.87,66.86 239.39,66.86 239.21,67.03 239.21,67.52 239.41,67.72 239.9,67.72 241.6,69.42 243.66,69.42 244.37,68.71 247.34,68.71 247.87,68.18 248.63,68.18 249.17,68.71 250.41,68.71
+VCC_RTC on TOP: 242.03,47.58 243.55,47.58 243.81,47.83 243.81,48.59 244.44,48.59 244.44,47.58 243.94,47.07 242.79,47.07 242.67,46.94 242.67,44.4 242.28,44.02 238.5,44.02 236.21,46.31 236.21,47.27 236.52,47.58 237.69,47.58 237.76,47.5 237.76,46.82 238.27,46.31 239.36,46.31 239.62,46.05 239.62,45.67 239.87,45.42 241.52,45.42 241.65,45.55 241.65,46.33 241.88,46.56 241.88,47.43
+VCC_SWF on TOP: 285.08,53.42 284.96,53.55 284.96,54.44 285.34,54.82 285.34,57.99 285.46,58.12 287.75,58.12 288,57.86 288,53.93 287.5,53.42
+VCC_SWF on TOP: 284.83,44.91 284.83,46.43 284.96,46.56 287.12,46.56 287.5,46.94 289,46.94 289.07,46.87 289.07,44.17 288.92,44.02 285.72,44.02
+VCC_SWF on BOTTOM: 286.4,45.04 286.79,44.66 287.62,44.66 287.88,44.91 287.88,46.43 287.5,46.82 286.99,46.82 286.73,47.07 286.73,53.42 286.99,53.67 288.64,53.67 288.89,53.93 288.89,55.07 287.69,56.28 285.66,56.28 285.08,55.71 285.08,47.45 284.19,46.56 284.19,45.29 284.45,45.04
+VCCAAZPLL_1P0_L on IN08: 239.24,57.1 241.01,57.1 241.65,56.47 247.24,56.47 248.38,57.61 255.11,57.61 256.89,55.83 256.89,54.82 256.76,54.69 255.24,54.69 254.73,55.2 253.08,55.2 252.57,54.69 248,54.69 246.98,53.67 240,53.67 238.98,54.69 238.98,56.85
+VCCAMPHYPLL_1P0 on TOP: 224.89,77.04 229.84,77.04 230.09,76.79 230.09,74.88 229.97,74.76 229.33,74.76 228.82,75.26 226.54,75.26 226.26,74.98 226.26,74.25 227.43,73.08 227.48,73.08 227.81,72.75 227.81,71.83 225.9,69.93 224.38,69.93 224,70.31 224,72.85 224.63,73.49 224.63,76.79
+VCCAMPHYPLL_1P0 on BOTTOM: 227.55,73.77 227.55,72.67 227.71,72.52 227.71,71.76 227.55,71.61 227.3,71.61 227.2,71.71 226.79,71.71 226.66,71.83 226.16,71.83 225.17,72.82 225.17,73.23 225.92,73.98 227.34,73.98
+VCCDSW_1P0 on IN05: 233.27,53.55 233.88,53.55 233.88,55.38 234.44,55.93 236.34,55.93 236.58,55.69 237.9,55.69 237.92,55.71 238.68,55.71 238.98,55.4 238.98,54.82 239.29,54.51 239.57,54.51 239.64,54.59 239.69,54.59 240.02,54.26 240.02,53.47 240,53.45 240,52.99 241.34,51.64 250.29,51.64 250.29,52.02 251.81,53.55 251.81,55.07 252.44,55.71 253.46,55.71 255.49,57.74 255.49,58.88 255.24,59.13 255.11,59.13 254.98,59.26 249.14,59.26 247.36,57.48 242.67,57.48 242.16,56.98 241.9,56.98 241.52,57.36 241.52,58.25 240.51,59.26 233.01,59.26 232.35,58.6 232.35,54.97 233.14,54.18 233.14,53.67
+VCCF24_1P0_L on TOP: 249.4,69.04 248.63,68.28 248,68.28 247.87,68.41 247.87,68.56 248.46,69.14 248.46,69.88 248.89,70.31 248.89,72.09 249.52,72.72 249.52,73.61 249.65,73.74 251.2,73.74 251.3,73.84 251.3,74.43 251.4,74.53 251.68,74.53 251.81,74.4 251.81,71.33 250.92,70.44 250.92,69.93 250.41,69.42 249.9,69.42 249.52,69.04
+VCCF100_1P0 on TOP: 243.22,64.47 247.36,64.47 248.13,65.23 250.92,65.23 251.3,65.61 251.68,65.61 251.81,65.74 251.81,66.25 251.5,66.55 248,66.55 247.8,66.75 246.86,66.75 246.48,66.37 244.32,66.37 243.94,66.75 241.01,66.75 240.38,66.12 240.38,64.77 240.51,64.65 243.05,64.65
+VCCF135_1P0 on TOP: 251.96,67.49 251.96,66.88 251.76,66.68 248.03,66.68 247.82,66.88 246.73,66.88 246.63,66.98 240.91,66.98 240.23,66.3 240.23,65.99 239.92,65.69 239.34,65.69 239.24,65.79 239.24,66.04 240.74,67.54 243.38,67.54 243.45,67.62 246.83,67.62 246.91,67.54 247.31,67.54 247.36,67.49 251.33,67.49 251.4,67.57 251.89,67.57
+VCCIO on TOP: 198.85,160.86 198.6,161.12 198.6,162 198.98,162.39 199.1,162.39 199.99,163.27 199.99,163.3 200.6,163.91 204.16,163.91 204.17,163.9 205.59,163.9 205.96,163.53 205.96,161.37 205.45,160.86
+VCCIO on TOP: 127.35,139.02 130.78,139.02 131.03,138.76 131.03,134.83 130.65,134.45 127.22,134.45 126.97,134.7 126.97,138.64
+VCCIO on TOP: 183.74,140.67 183.61,140.8 183.61,143.39 183.13,143.87 183.13,145.39 183.29,145.56 184.63,145.56 184.63,146.38 184.88,146.64 185.39,146.64 185.77,146.26 185.77,145.37 185.26,144.86 185.26,141.56 184.37,140.67
+VCCIO on BOTTOM: 185.55,149.38 185.37,149.56 185.37,149.84 185.52,149.99 185.52,150.17 185.09,150.6 184.04,150.6 183.97,150.52 183.97,148.95 184.12,148.8 185.44,148.8 185.55,148.9
+VCCIO on BOTTOM: 183.77,140.38 183.92,140.24 184.4,140.24 184.6,140.03 185.82,140.03 186.02,140.24 186.05,140.24 186.18,140.37 186.18,140.7 185.67,141.2 185.67,141.59 186.21,142.12 186.21,142.44 185.9,142.75 183.84,142.75 183.77,142.68
+VCCIO on BOTTOM: 131.29,138.64 131.29,134.83 130.52,134.06 127.1,134.06 126.71,134.45 126.71,138.51 127.1,138.89 131.03,138.89
+VCCIO on BOTTOM: 202.41,165.05 206.47,165.05 206.85,164.67 206.85,161.37 206.47,160.99 202.41,160.99 202.15,161.24 202.15,164.8
+VCCIO on BOTTOM: 186.23,143.85 186.11,143.97 185.9,143.97 185.9,145.14 185.92,145.17 186.06,145.17 186.2,145.31 186.2,145.46 185.91,145.75 185.87,145.75 185.69,145.93 184.02,145.93 183.71,145.62 183.71,143.49 183.99,143.21 186.1,143.21 186.23,143.34
+VCCIO on IN03: 186.02,151.34 189.02,151.34 189.83,150.52 191.64,150.52 191.87,150.3 191.87,141.18 191.1,140.41 184.12,140.41 183.1,141.43 183.1,150.57 183.99,151.46 185.9,151.46
+VCCIO on IN05: 173.58,140.67 174.59,139.65 181.32,139.65 182.02,140.35 182.4,140.35 182.59,140.54 182.59,145.49 182.76,145.66 192.08,145.66 192.12,145.62 193.9,145.62 197.07,142.45 197.07,133.68 181.2,117.81 123.16,117.81 122.02,118.95 122.02,134.32 126.21,138.51 131.41,138.51 133.57,136.35 133.57,130.64 138.91,125.3 154.65,125.3 159.99,130.64 164.18,130.64 165.83,132.29 168.62,132.29 170.53,134.19 170.53,140.41 170.78,140.67
+VCCIO on VCC07: 183.08,140.41 182.98,140.52 182.98,149.71 197.3,164.04 205.96,164.04 205.96,142.17 204.21,140.41
+VCCMPHY_1P0 on TOP: 235.05,64.72 235.05,66.12 234.92,66.25 234.54,66.25 234.03,66.75 234.03,67.26 233.9,67.39 233.39,67.39 232.76,68.02 230.73,68.02 230.47,68.28 230.47,74.63 230.85,75.01 230.85,76.66 231.24,77.04 231.87,77.04 234.28,79.45 239.62,79.45 240.89,78.18 240.89,70.18 239.24,68.53 239.24,67.64 238.98,67.39 238.98,65.1 238.73,64.85 236.57,64.85 236.32,64.6 235.17,64.6
+VCCMPHY_1P0 on BOTTOM: 235.35,64.34 235.91,64.34 236.49,64.93 237.08,64.93 237.38,65.23 237.74,65.23 237.87,65.1 238.14,65.1 238.65,65.61 238.65,66.04 238.53,66.17 238.2,66.17 238.12,66.09 238.12,65.87 237.99,65.74 237.69,65.74 237.59,65.84 237.59,66.4 237.23,66.75 235.88,66.75 235.68,66.55 235.27,66.55 235.07,66.35 235.07,65.54 235.12,65.48 235.12,65.08 234.99,64.95 234.99,64.7
+VCCMPHY_1P0 on IN05: 234.41,64.32 238.65,64.32 238.78,64.44 238.78,66.37 238.4,66.75 235.78,66.75 234.26,65.23 234.26,64.47
+VCCPDSW_3P3 on IN05: 235.66,55.83 234.59,55.83 234.03,55.27 234.03,48.03 235.15,46.92 235.57,46.92 237.52,44.96 237.52,44.03 237.81,43.74 238.55,43.74 238.6,43.79 238.6,44.73 237.81,45.52 237.81,45.72 234.82,48.72 234.82,52.84 235.17,53.19 236.11,53.19 236.6,53.67 236.6,54.89
+VCCPFUSE_3P3 on BOTTOM: 249.9,50.24 251.05,50.24 251.17,50.12 251.17,49.23 251.05,49.1 247.87,49.1 246.48,50.5 246.48,51.64 246.86,52.02 247.11,52.02 247.49,51.64 247.49,51.26 247.62,51.13 249.02,51.13
+VCCPHVC_3P3 on TOP: 248.46,58.7 247.49,58.7 247.24,58.45 246.68,58.45 246.53,58.6 245.79,58.6 245.28,58.09 245.28,57.66 245.43,57.51 245.71,57.51 246.17,57.97 246.45,57.97 246.65,57.76 248.46,57.76 248.51,57.81 248.51,58.65
+VCCPRIM_1P0 on TOP: 233.93,64.27 233.93,64.16 232.63,62.87 232.63,58.63 232.89,58.37 239.34,58.37 239.52,58.55 239.52,60.89 239.19,61.22 238.04,61.22 237.92,61.34 237.92,64.19 237.71,64.39 234.06,64.39
+VCCPRIM_1P0 on TOP: 271.75,65.23 272.13,65.61 272.13,71.71 271.62,72.22 266.8,72.22 266.29,71.71 266.29,67.64 266.41,67.52 266.41,65.36 266.54,65.23
+VCCPRIM_1P0 on VCC07: 234.77,56.34 233.52,57.59 233.52,69.32 235.79,71.58 270.12,71.58 270.99,70.71 270.99,57.21 270.12,56.34
+VCCPRTC_3P3 on TOP: 237.84,49.23 236.95,49.23 236.57,49.61 236.57,51.39 237.33,52.15 237.33,53.29 237.41,53.37 237.41,54.18 237.31,54.28 237.18,54.28 237.08,54.38 237.08,55.71 236.93,55.86 236.44,55.86 236.19,55.6 236.19,52.15 235.3,51.26 235.3,48.34 235.68,47.96 237.71,47.96 237.84,48.09
+VCCPUSBDSW_3P3 on TOP: 242.13,63.22 242.13,63.73 241.7,64.16 240.38,64.16 240.28,64.06 240.28,63.35 240.51,63.12 241.47,63.12 241.57,63.02 241.57,62.41 241.6,62.39 245.59,62.39 245.94,62.74 247.8,62.74 248.23,63.17 250.67,63.17 251.3,63.81 251.86,63.81 252.04,63.99 252.04,64.39 251.91,64.52 250.9,64.52 250.82,64.6 246.76,64.6 245.18,63.02 242.34,63.02
+VCCPUSBDSW_3P3 on BOTTOM: 250.92,63.96 250.92,62.82 251.05,62.69 251.89,62.69 251.96,62.77 251.96,64.37 251.86,64.47 251.43,64.47
+VCCSA on TOP: 182.61,148.81 182.26,149.16 182.26,150.67 181.94,150.99 181.94,156.91 185.07,160.04 186.72,160.04 189.83,163.15 192.37,163.15 196.29,167.06 199.08,167.06 200.88,168.86 200.88,175.72 200.5,176.1 200.5,178.9 200.76,179.15 207.74,179.15 208.12,178.77 208.12,170.77 207.87,170.51 207.87,168.99 203.04,164.16 200.37,164.16 197.39,161.18 196.25,161.18 192.25,157.18 191.61,157.18 190.85,157.94 189.2,157.94 188.69,157.43 188.69,156.29 188.47,156.07 186.75,156.07 185.06,154.38 185.06,150.07 185.01,150.07 185.01,149.18 184.64,148.81 ; 1 cut-out
+VCCSA on BOTTOM: 200.88,175.97 207.36,175.97 207.97,175.37 207.97,171.59 207.9,171.53 207.74,171.53 207.11,170.89 207.11,167.97 205.84,166.7 201.52,166.7 201.14,167.08 201.14,171.4 200.5,172.04 200.5,175.59
+VCCSA on IN03: 184.63,152.86 184.63,156.16 186.91,158.45 188.69,158.45 190.34,160.1 203.8,160.1 207.36,163.66 207.36,175.47 207.11,175.72 201.9,175.72 201.52,175.34 201.52,167.72 200.12,166.32 185.64,166.32 182.59,163.27 182.59,159.85 182.21,159.46 182.21,153.11 182.85,152.48 184.25,152.48
+VCCSA on IN05: 182.72,152.99 184.75,152.99 185.13,153.37 185.13,154.13 186.66,155.65 189.45,155.65 194.6,160.8 200.82,160.8 201.9,161.88 201.9,164.8 207.13,170.03 207.13,175.85 206.88,176.1 197.96,176.1 197.58,175.72 197.58,166.83 197.01,166.26 185.58,166.26 181.71,162.39 181.71,159.34 182.59,158.45 182.59,153.11
+VCCSA on VCC07: 181.96,150.45 181.96,151.36 182.7,152.1 182.7,157.76 181.96,158.5 181.96,160.76 192.35,171.15 196.16,171.15 197.71,172.69 197.71,177.88 206.75,177.88 207.61,177.01 207.61,166.05 206.11,164.54 197.09,164.54 183,150.45
+VCCSFR_OC on TOP: 186.79,132.67 186.79,132.03 187.17,131.65 187.67,131.65 188.06,131.27 188.06,131.14 190.21,131.14 190.34,131.27 190.34,131.78 190.09,132.03 190.09,132.29 190.47,132.67 194.41,132.67 194.53,132.54 199.23,132.54 199.49,132.79 199.49,134.06 199.17,134.38 190.02,134.38 189.96,134.45 188.94,134.45 188.69,134.19 188.69,133.94 188.18,133.43 188.18,133.05 187.8,132.67
+VCCSFR_OC on IN03: 154.27,138.26 154.27,139.27 155.54,140.54 170.02,140.54 170.28,140.29 172.13,140.29 172.59,140.74 173.6,140.74 174.7,139.65 181.45,139.65 181.96,140.16 184.69,140.16 184.88,139.97 186.53,139.97 186.79,139.72 186.79,136.99 186.4,136.6 184.63,136.6 183.23,138 163.93,138 162.99,138.94 161.18,138.94 160.24,138 154.53,138
+VCCSFR_OC on IN10: 185.9,136.48 187.17,135.21 196.82,135.21 197.2,134.83 197.2,133.18 197.58,132.79 199.1,132.79 199.49,133.18 199.49,137.11 199.23,137.37 199.23,139.4 198.22,140.41 186.53,140.41 185.9,139.78
+VCCSFR_OC_S on TOP: 187.42,130.25 187.42,129.62 187.67,129.37 188.82,129.37 188.94,129.49 188.94,130 189.07,130.13 189.96,130.13 190.21,130.38 190.21,131.02 188.06,131.02 188.06,130.64 187.67,130.25
+VDD33_LAN on BOTTOM: 48.23,69.42 47.97,69.17 47.09,69.17 46.96,69.04 46.96,67.9 47.21,67.64 48.48,67.64 48.99,67.14 48.99,66.5 48.86,66.37 47.85,66.37 47.47,65.99 47.47,65.48 47.59,65.36 49.5,65.36 50.26,66.12 50.26,67.9 50.9,68.53 52.67,68.53 53.05,68.91 53.05,69.93 52.8,70.18 52.04,70.18 51.4,69.55 50.51,69.55 49.88,70.18 48.36,70.18 48.23,70.06
AGND on BOTTOM: 297.31,13.08 294.89,15.49 294.89,24.49 293.39,25.99 289.78,25.99 289.53,26.24 289.53,28.15 289.66,28.27 290.93,28.27 291.05,28.4 291.05,30.05 290.93,30.18 290.04,30.18 289.91,30.05 289.91,29.42 289.78,29.29 289.27,29.29 289.15,29.42 289.15,30.81 290.8,30.81 291.18,31.19 291.18,32.46 291.85,33.13 291.85,37.21 291.81,37.24 291.81,38.15 291.95,38.28 291.95,39.12 292.79,39.96 293.19,39.96 293.37,39.78 293.42,39.78 293.42,39.42 293.32,39.32 292.83,39.32 292.7,39.2 292.7,38.31 293.08,37.93 293.08,37.37 293.75,36.7 297.31,36.7 297.69,36.32 297.69,35.81 299.34,34.16 299.34,30.23 299.08,29.97 299.08,19.94 299.97,19.05 299.97,18.92 299.85,18.8 299.34,18.8 299.21,18.67 299.21,17.14 299.34,17.02 299.85,17.02 299.97,16.89 299.97,16.64 299.85,16.51 298.2,16.51 297.31,15.62 296.93,15.62 296.8,15.49 296.8,14.35 297.69,13.46 299.34,13.46 299.97,14.1 300.99,14.1 301.12,13.97 301.12,13.84 300.99,13.72 300.23,13.72 299.59,13.08
AGND on GND02, GND04, VCC06, VCC07, GND09, GND11: 297.28,13.08 294.89,15.47 294.89,24.49 293.4,25.99 288.74,25.99 287.24,27.49 287.24,28.93 287.62,29.31 287.62,30.71 287.73,30.81 290.78,30.81 291.18,31.22 291.18,36.25 290.42,37.01 290.42,39.42 291.34,40.34 293.06,40.34 293.49,39.9 293.49,37.54 294.25,36.78 297.12,36.78 297.56,36.34 297.56,35.66 299.26,33.96 299.26,30.13 299.08,29.95 299.08,19.96 299.94,19.1 300.96,19.1 301.24,18.82 301.24,13.95 301.01,13.72 300.25,13.72 299.61,13.08
AGND on IN05: 294.23,36.78 297.13,36.78 297.56,36.35 297.56,35.66 299.08,34.14 299.08,26.06 298.17,25.15 294.23,25.15 293.39,25.99 288.77,25.99 287.24,27.51 287.24,28.91 287.62,29.29 287.62,30.69 287.75,30.81 290.8,30.81 291.18,31.19 291.18,36.27 290.42,37.04 290.42,39.42 291.33,40.34 293.06,40.34 293.49,39.91 293.49,37.52
AGND on IN10: 293.49,37.52 294.23,36.78 297.18,36.78 297.69,36.27 297.69,35.84 299.17,34.35 299.17,28.27 293.85,28.27 291.56,25.99 288.77,25.99 287.24,27.51 287.24,28.91 287.62,29.29 287.62,30.69 287.75,30.81 290.8,30.81 291.18,31.19 291.18,36.27 290.42,37.04 290.42,39.42 291.33,40.34 293.06,40.34 293.49,39.91
GND on TOP (solid shape): 205.33,96.73 204.31,96.73 204.31,101.43 205.33,101.43
GND on TOP (solid shape): 110.97,29.54 110.97,27.64 110.71,27.38 100.55,27.38 100.43,27.51 100.43,29.54 100.55,29.67 110.84,29.67
GND on TOP (solid shape): 264,182.07 264,178.64 263.87,178.51 260.57,178.51 260.45,178.64 260.45,181.69 261.59,182.83 263.24,182.83
GND on TOP (solid shape): 213.49,166.92 213.49,164.51 213.21,164.23 213.21,164.16 212.83,163.78 210.66,163.78 210.28,164.16 210.28,167.08 210.53,167.34 213.07,167.34
GND on TOP (solid shape): 237.97,181.94 237.97,178.01 237.71,177.75 234.28,177.75 234.16,177.88 234.16,181.69 235.17,182.71 237.2,182.71
GND on TOP (solid shape): 279.75,55.71 279.75,55.32 279.11,54.69 278.73,54.69 278.35,55.07 277.34,55.07 277.08,55.32 277.08,56.21 277.21,56.34 279.11,56.34
GND on TOP (solid shape): 213.71,181.44 213.71,179.78 214.34,179.15 214.34,176.48 214.09,176.23 212.31,176.23 212.06,176.48 212.06,181.56 212.19,181.69 213.46,181.69
GND on TOP (solid shape): 283.31,65.61 283.31,63.83 283.18,63.71 281.4,63.71 281.27,63.83 281.27,64.6 280,64.6 280,64.85 281.27,64.85 281.27,65.61 281.4,65.74 283.18,65.74
GND on TOP (solid shape): 21.18,66.5 21.18,63.58 21.56,63.2 21.56,61.93 21.43,61.8 21.43,61.17 21.3,61.04 19.65,61.04 19.02,61.67 19.02,66.63 21.05,66.63
GND on TOP (solid shape): 276.83,186.01 276.83,184.48 277.84,183.47 277.84,178.64 277.59,178.39 273.53,178.39 273.27,178.64 273.27,181.69 274.35,182.77 274.35,186.2 274.54,186.39 276.45,186.39
GND on TOP (solid shape): 216.76,120.86 216.76,120.22 216.63,120.09 213.96,120.09 213.84,119.97 213.84,118.44 213.71,118.32 212.82,118.32 211.93,119.21 211.17,119.21 211.04,119.33 211.04,120.6 211.42,120.98 216.63,120.98
GND on TOP (solid shape): 221.33,160.48 221.33,153.37 220.57,152.61 220.57,150.7 220.44,150.57 218.92,150.57 218.54,150.96 218.54,153.5 219.3,154.26 219.3,157.94 218.92,158.32 218.28,158.32 218.15,158.45 218.15,160.35 218.68,160.35 218.92,160.6 218.92,160.73 219.17,160.99 220.82,160.99
GND on TOP (solid shape): 250.54,181.94 250.54,178.77 250.16,178.39 248.13,178.39 247.75,178.77 247.36,178.39 247.11,178.39 246.86,178.64 246.86,181.82 247.75,182.71 249.78,182.71
GND on BOTTOM (solid shape): 26.29,2.41 26.29,0.76 26.03,0.51 24.64,0.51 24.38,0.76 24.38,2.41 24.64,2.67 26.03,2.67
GND on BOTTOM (solid shape): 126.97,119.33 126.97,116.28 126.71,116.02 118.21,116.02 117.82,116.41 117.82,119.07 118.21,119.45 126.85,119.45
GND on BOTTOM (solid shape): 213.58,181.44 213.58,179.78 213.96,179.4 213.96,176.36 213.71,176.1 212.06,176.1 211.8,176.36 211.8,181.56 212.06,181.82 213.2,181.82
GND on BOTTOM (solid shape): 54.74,24.38 54.74,20.83 54.31,20.4 45.31,20.4 44.93,20.78 44.93,23.96 45.43,24.46 48.36,24.46 48.74,24.84 54.28,24.84
GND on BOTTOM (solid shape): 120.18,134.06 122.47,134.06 122.47,133.55 120.82,133.55 120.82,132.15 120.49,132.15 120.05,131.72 120.05,130.38 119.93,130.25 118.28,130.25 118.02,130.5 118.02,134.31 118.28,134.57 119.67,134.57
GND on BOTTOM (solid shape): 60.55,10.62 60.42,10.49 59.53,10.49 59.4,10.62 59.4,11.13 59.28,11.26 58.39,11.26 58.13,11 58.13,10.49 58.01,10.37 57.75,10.37 57.12,11 57.12,11.38 57.25,11.51 57.75,11.51 57.88,11.64 59.28,11.64 59.4,11.76 59.4,12.27 59.53,12.4 60.55,12.4
GND on BOTTOM (solid shape): 213.42,167.22 215.91,167.22 215.96,167.17 215.96,165.27 215.93,165.24 215.73,165.24 215.7,165.27 215.7,166.49 215.6,166.59 214.08,166.59 214.03,166.54 214.03,165.37 213.46,164.8 213.46,164.29 212.95,163.78 210.92,163.78 210.41,164.29 210.41,167.21 210.53,167.34 211.93,167.34 212.06,167.47 213.18,167.47
GND on GND02 (solid shape): 101.85,112.39 100.46,111 98.17,111 96.77,112.39 96.77,112.59 98.62,114.43 98.62,114.87 98.68,114.87 100.01,116.2 101.85,116.2
GND on TOP: 301.59,136.73 302.61,136.73 302.74,136.6 302.74,135.46 302.61,135.33 301.72,135.33 301.34,135.72 301.34,136.48
GND on TOP: 236.57,126.57 237.08,126.57 237.08,126.06 237.2,125.94 237.71,125.94 237.84,125.81 237.84,125.43 237.71,125.3 236.7,125.3 236.44,125.56 236.44,126.44
GND on TOP: 146.02,201.98 146.02,199.8 139.5,193.28 132.98,199.8 132.98,201.98 130.4,201.98 130.4,202.99 133.5,202.99 133.85,202.85 133.99,202.5 133.99,199.8 139.5,194.29 145.01,199.8 145.01,202.5 145.15,202.85 145.5,202.99 149.13,202.99 149.3,202.82 149.3,202.21 149.06,201.98
GND on TOP: 291.84,46.84 291.84,44.3 291.56,44.02 289.91,44.02 289.53,44.4 289.53,46.43 290.04,46.94 291.74,46.94
GND on TOP: 272,178.01 274.03,178.01 274.16,178.13 275.81,178.13 276.19,177.75 276.19,176.1 276.07,175.97 275.05,175.97 274.03,176.99 271.88,176.99 271.75,177.12 271.75,177.75
GND on TOP: 300.83,107.52 300.83,104.6 301.09,104.35 302.48,104.35 302.74,104.6 302.74,107.27 302.36,107.65 300.96,107.65
GND on TOP: 231.74,166.2 233.78,166.2 233.9,166.07 233.9,165.81 233.78,165.69 232.76,165.69 232.63,165.56 231.74,165.56 231.62,165.69 231.62,166.07
GND on TOP: 264.64,171.4 265.53,171.4 265.65,171.28 265.65,170.13 265.53,170.01 264,170.01 263.87,170.13 263.87,170.64
GND on TOP: 280,175.85 281.4,175.85 282.16,175.09 282.16,174.83 281.78,174.45 278.99,174.45 278.86,174.58 278.86,174.96 278.99,175.09 279.62,175.09 279.88,175.34 279.88,175.72
GND on TOP: 234.82,88.65 235.08,88.9 236.5,88.9 236.54,88.94 236.57,88.99 237.11,89.53 237.11,90.93 236.9,91.14 231.11,91.14 230.73,90.76 219.93,90.76 219.62,91.08 219.62,95.27 218.64,96.24 218.64,98.53 218.79,98.68 240.33,98.68 240.63,98.38 240.63,94.61 240.1,94.08 240.1,87.57 238.89,86.36 235.08,86.36 234.82,86.61
GND on TOP: 17.11,69.42 17.37,69.68 19.15,69.68 19.27,69.55 19.27,68.66 19.15,68.53 16.35,68.53 15.72,67.9 14.7,67.9 14.57,68.02 14.57,69.29 14.7,69.42
GND on TOP: 71.98,46.31 74.26,46.31 74.52,46.05 74.52,45.04 74.39,44.91 72.1,44.91 71.85,45.16 71.85,46.18
GND on TOP: 270.86,27.38 269.72,27.38 269.46,27.64 269.46,33.23 269.74,33.51 270.35,33.51 270.55,33.71 270.55,36.02 270.28,36.3 269.59,36.3 269.46,36.43 269.46,36.91 270.35,37.8 274.42,37.8 275.18,37.04 275.18,36.15 275.03,36 274.21,36 274.14,35.92 274.14,33.3 274.21,33.23 275.05,33.23 275.18,33.1 275.18,27.89 274.42,27.13 271.11,27.13
GND on TOP: 117.7,91.52 117.57,91.65 117.57,93.93 116.81,94.69 111.47,94.69 110.2,95.96 110.2,100.41 113.25,103.46 118.97,103.46 119.98,102.44 119.98,91.9 119.6,91.52
GND on TOP: 262.6,47.83 262.6,49.74 262.48,49.74 262.48,48.47 262.35,48.34 260.83,48.34 260.7,48.47 260.7,49.71 260.68,49.73 260.68,50.24 260.01,50.91 258.52,50.91 258.14,50.53 258.14,47.96 258.27,47.83 258.63,47.83 258.64,47.83
GND on TOP: 256.28,138.31 256.28,132.74 256.36,132.67 256.36,130.94 256.46,130.84 256.69,130.84 257.22,131.37 258.67,131.37 258.72,131.42 258.72,132.06 258.64,132.13 258.41,132.13 258.29,132.26 258.29,133.12 258.11,133.3 257.85,133.3 257.75,133.2 257.75,132.29 257.55,132.08 257.04,132.08 256.84,132.29 256.84,141.08 256.76,141.15 256.48,141.15 256.41,141.08 256.41,139.68 256.33,139.6 256.33,138.64 256.36,138.61 256.36,138.38
GND on TOP: 216.88,126.44 220.31,126.44 220.57,126.19 220.57,124.79 220.44,124.67 216.88,124.67 216.76,124.79 216.76,126.32
GND on TOP: 35.4,82.76 37.69,82.76 37.94,82.5 37.94,81.36 37.69,81.11 35.4,81.11 35.15,81.36 35.15,82.5
GND on TOP: 265.91,172.55 267.68,172.55 267.94,172.29 267.94,171.91 267.81,171.78 267.56,171.78 267.3,172.04 265.91,172.04 265.78,172.16 265.78,172.42
GND on TOP: 257.8,124.95 258.13,124.95 258.21,124.87 258.21,122.58 258.52,122.28 258.95,122.28 259.12,122.46 259.12,124.97 259.2,125.05 259.61,125.05 259.66,125 259.66,122.43 259.84,122.25 260.47,122.25 260.57,122.36 260.57,124.9 260.7,125.02 260.98,125.02 261.18,124.82 261.18,122.03 260.93,121.77 258.64,121.77 258.52,121.64 258.52,120.86 258.41,120.76 258.11,120.76 258.01,120.86 258.01,121.97 257.68,122.3 257.68,123.52 257.63,123.57 257.63,124.77
GND on TOP: 261.97,178.26 264.13,178.26 264.26,178.39 264.26,178.77 264.38,178.9 264.64,178.9 265.27,178.26 268.07,178.26 268.19,178.13 268.19,177.75 268.07,177.63 265.91,177.63 265.78,177.5 265.4,177.5 264.89,176.99 264,176.99 263.75,177.24 263.75,177.5 262.1,177.5 261.84,177.75 261.84,178.13
GND on TOP: 292.86,106.81 294.77,106.81 295.02,106.55 295.02,100.58 294.39,99.95 294.39,98.81 294.89,98.3 294.89,96.27 295.15,96.01 295.15,91.82 294.89,91.57 292.35,91.57 292.1,91.82 292.1,93.34 291.59,93.85 288.29,93.85 287.91,94.23 287.91,102.23 288.92,103.25 291.08,103.25 292.73,104.9 292.73,106.68
GND on TOP: 213.07,124.41 211.55,124.41 211.42,124.29 211.17,124.29 211.04,124.41 211.04,124.67 210.79,124.92 210.41,124.92 210.03,125.3 209.26,125.3 209.14,125.43 209.14,126.06 209.39,126.32 212.95,126.32 213.33,125.94 213.33,124.67
GND on TOP: 212.19,99.77 212.19,97.87 212.57,97.49 214.85,97.49 215.11,97.74 215.11,99.65 214.73,100.03 212.44,100.03
GND on TOP: 267.3,57.1 266.03,55.83 265.4,55.83 265.27,55.96 265.27,56.98 265.65,57.36 265.65,64.54 265.96,64.85 267.05,64.85 267.3,64.6
GND on TOP: 296.77,12.14 299.94,12.14 301.47,13.67 306.29,13.67 306.67,13.29 306.67,10.39 306.47,10.19 306.47,6.35 305.53,5.41 293.97,5.41 293.47,5.92 293.47,9.22 294.35,10.11 296.13,10.11 296.51,10.49 296.51,11.89
GND on TOP: 298.42,169.5 298.42,167.21 298.55,167.08 300.45,167.08 300.58,167.21 300.58,169.24 300.2,169.62 298.55,169.62
GND on TOP: 289.05,17.02 289.05,13.59 289.31,13.34 290.58,13.34 290.83,13.59 290.83,16.89 290.58,17.14 289.18,17.14
GND on TOP: 271.49,61.8 270.73,61.04 270.73,59.13 270.45,58.86 270.45,58.47 270.3,58.32 269.54,58.32 269.34,58.53 269.34,64.09 269.46,64.21 270.61,64.21 270.86,64.47 272.38,64.47 272.38,63.45 272.51,63.33 275.51,63.33 276.75,62.08 278.63,62.08 278.76,61.95 278.76,61.29 278.61,61.14 275.46,61.14 275.36,61.24 274.64,61.24 274.09,61.8
GND on TOP: 246.09,118.95 247.75,118.95 248.13,119.33 249.02,119.33 249.14,119.21 249.9,119.21 250.03,119.08 250.03,117.43 249.78,117.17 249.14,117.17 248,118.32 247.11,118.32 246.98,118.19 246.98,116.92 246.73,116.67 246.09,116.67 245.84,116.92 245.84,117.81 245.71,117.94 245.08,117.94 244.95,118.06 244.95,118.44 245.08,118.57 245.71,118.57
GND on TOP: 145,151.97 145.51,151.46 145.51,147.91 144.11,146.51 139.92,146.51 138.53,147.91 138.53,151.72 138.78,151.97
GND on TOP: 32.23,103.2 32.99,103.2 33.37,102.82 33.37,93.04 32.99,92.66 32.23,92.66 31.97,92.92 31.97,102.95
GND on TOP: 301.59,155.4 303.12,155.4 303.37,155.15 303.37,154.89 302.74,154.26 300.83,154.26 300.7,154.38 300.7,154.64 300.83,154.77 301.21,154.77 301.47,155.02 301.47,155.27
GND on TOP: 261.72,84.92 262.22,84.92 262.48,84.66 262.86,84.66 263.11,84.92 263.62,84.92 263.75,84.79 263.75,83.26 263.62,83.14 261.59,83.14 261.46,83.26 261.46,84.66
GND on TOP: 264,121.36 263.37,120.73 263.11,120.73 262.99,120.86 262.35,120.86 262.22,120.98 262.22,122.25 261.97,122.51 261.97,123.52 262.22,123.78 262.22,124.29 261.97,124.54 261.97,124.79 262.22,125.05 263.11,125.05 263.24,124.92 263.24,122.13
GND on TOP: 283.21,22.61 281.43,22.61 280.42,21.59 280.42,20.95 280.54,20.83 280.92,20.83 281.05,20.7 281.05,19.68 281.18,19.56 282.45,19.56 283.46,20.57 283.46,22.35
GND on TOP: 134.28,154.13 134.28,152.35 132.73,150.8 127.25,150.8 126.21,151.84 126.21,153.75 126.46,154 130.91,154 131.54,154.64 133.78,154.64
GND on TOP: 63.85,45.04 67.53,45.04 68.04,45.55 70.33,45.55 70.58,45.29 70.58,44.53 69.69,43.64 63.47,43.64 63.21,43.89 63.21,44.4
GND on TOP: 258.97,59.01 258.77,59.21 258.77,62.21 259,62.44 260.32,62.44 260.5,62.26 260.5,59.24 260.27,59.01
GND on TOP: 15.21,33.61 15.21,31.45 20.42,31.45 20.67,31.7 22.19,31.7 22.57,32.08 22.57,35.26 22.45,35.39 20.54,35.39 20.42,35.26 20.42,34.37 20.03,33.99 15.59,33.99
GND on TOP: 89.03,20.53 90.52,20.53 92.68,18.37 92.68,13.92 92.3,13.54 91.06,13.54 90.93,13.67 90.93,14.48 90.8,14.61 90.42,14.61 88.65,16.38 88.65,20.15
GND on TOP: 154.15,170.51 153.89,170.77 153.64,170.77 153,171.4 153,172.8 153.38,173.18 153.38,175.21 152.88,175.72 151.73,175.72 148.94,172.93 136.49,172.93 129.51,165.94 129.51,159.97 130.14,159.34 133.7,159.34 134.08,159.72 134.08,166.45 134.59,166.96 150.59,166.96 151.61,165.94 159.1,165.94 159.23,166.07 159.23,167.21 158.72,167.72 154.4,167.72 154.15,167.97
GND on TOP: 300.7,145.88 300.7,145.49 301.09,145.11 301.09,144.22 301.47,143.84 302.74,143.84 302.99,144.1 302.99,144.99 302.86,145.11 302.1,145.11 301.21,146 300.83,146
GND on TOP: 263.24,42.75 263.62,43.13 263.62,45.29 263.01,45.9 261.92,45.9 261.85,45.84 261.85,45.21 261.76,45.12 261.29,45.12 261.21,45.04 261.21,44.78 261.59,44.4 261.59,43.06 261.89,42.75
GND on TOP: 209.9,109.3 210.15,109.05 210.15,108.16 209.9,107.9 206.34,107.9 206.22,108.03 206.22,109.05 206.47,109.3
GND on TOP: 211.55,102.06 212.95,102.06 213.2,101.81 213.2,100.54 212.95,100.28 211.93,100.28 211.55,100.66
GND on TOP: 56.4,25.27 56.4,23.88 54.36,21.84 54.36,21.42 54.15,21.21 46.48,21.21 46.23,21.46 46.23,23.37 46.48,23.62 54.86,23.62 55.21,23.97 55.21,25.24 55.5,25.53 56.14,25.53
GND on TOP: 281.27,53.8 281.53,54.05 284.19,54.05 284.7,53.55 284.7,45.04 284.69,45.03 284.69,44.61 285.68,43.62 286.43,43.62 286.58,43.46 286.58,42.83 286.33,42.57 281.96,42.57 281.27,43.26
GND on TOP: 128.62,97.87 128.62,92.28 129,91.9 131.92,91.9 132.43,92.41 132.43,97.74 132.05,98.12 128.87,98.12
GND on TOP: 74.52,50.27 74.21,50.57 74.21,52.07 74.11,52.18 74.01,52.18 74.01,52.15 72.99,52.15 72.87,52.02 72.87,51.21 72.36,50.7 70.07,50.7 69.95,50.83 69.95,52.28 73.2,55.53 74.85,55.53 75.58,54.79 77.97,54.79 78.2,54.56 78.2,52.91 78.35,52.76 80.87,52.76 80.99,52.63 80.99,51.46 81.07,51.39 82.39,51.39 82.65,51.64 86.96,51.64 87.47,51.13 87.47,49.48 87.22,49.23 84.55,49.23 83.66,48.34 80.39,48.34 80.33,48.39 80.33,48.7 80.44,48.8 80.44,50.04 80.21,50.27
GND on TOP: 27.53,37.8 29.18,37.8 29.43,38.05 29.43,40.34 28.92,40.85 27.15,40.85 26.96,40.66 26.96,38.62 26.38,38.05 26.38,37.54 26.51,37.42 27.15,37.42
GND on TOP: 252.27,130.79 251.66,131.4 251.56,131.4 251.48,131.47 251.48,131.96 251.94,132.41 251.94,137.29 251.86,137.37 251.86,138.76 251.94,138.84 251.94,140.14 252.06,140.26 255.21,140.26 255.42,140.06 255.42,132.31 255.16,132.06 255.16,131.52 255.01,131.37 254.1,131.37 253.99,131.47 253.99,132.57 253.11,133.46 252.67,133.46 252.52,133.3 252.52,130.92 252.39,130.79 ; 1 cut-out
GND on TOP: 265.65,174.96 268.07,174.96 268.19,174.83 268.19,174.45 267.94,174.2 265.78,174.2 265.53,174.45 265.53,174.83
GND on TOP: 301.85,153.24 302.99,153.24 303.24,152.99 303.24,151.72 302.99,151.46 301.59,151.46 301.47,151.59 301.47,152.86
GND on TOP: 273.02,85.17 274.92,85.17 275.56,84.53 275.81,84.53 275.94,84.41 275.94,83.39 275.56,83.01 274.42,83.01 274.29,83.14 274.29,84.28 274.16,84.41 273.02,84.41 272.76,84.66 272.76,84.92
GND on TOP: 244.32,148.29 244.95,148.92 244.95,149.25 244.65,149.56 244.65,149.57 244.23,149.57 242.84,150.96 240.63,150.96 240,150.32 240,148.8 240.51,148.29
GND on TOP: outline of 96 points within 258.69,130.76 261.21,140.24
GND on TOP: 290.32,22.73 290.19,22.61 290.19,20.19 290.07,20.07 289.05,20.07 288.92,19.94 288.92,18.03 289.05,17.91 291.21,17.91 291.34,18.03 291.34,22.61 291.21,22.73
GND on TOP: 67.02,93.3 69.18,93.3 69.31,93.17 69.31,88.47 69.56,88.22 69.56,86.95 69.44,86.82 67.02,86.82 66.77,87.07 66.77,93.04
GND on TOP: 246.6,129.85 246.86,129.85 246.96,129.75 246.96,128.73 247.19,128.5 247.19,127.92 246.98,127.71 246.98,127.28 247.19,127.08 247.19,126.6 247.01,126.42 247.01,124.64 246.83,124.46 246.53,124.46 246.4,124.59 246.4,124.87 246.55,125.02 246.55,125.91 246.45,126.01 246.45,126.29 246.55,126.39 246.55,127.23 246.42,127.36 246.42,127.64 246.65,127.87 246.65,128.63 246.45,128.83 246.45,129.7
GND on TOP: 301.85,130.38 303.24,130.38 303.37,130.25 303.37,129.37 303.24,129.24 301.85,129.24 301.59,129.49 301.59,130.13
GND on TOP: 300.96,120.73 303.24,120.73 303.37,120.6 303.37,120.09 303.12,119.84 301.47,119.84 301.34,119.71 301.34,119.33 301.21,119.21 300.83,119.21 300.7,119.33 300.7,120.48
GND on TOP: 300.45,159.34 301.34,159.34 301.59,159.08 301.59,158.7 300.83,157.94 300.83,156.92 300.45,156.54 299.94,156.54 299.82,156.67 299.82,158.7
GND on TOP: 83.03,82.63 82.9,82.5 80.74,82.5 80.49,82.76 80.49,88.98 80.74,89.23 82.65,89.23 83.03,88.85
GND on TOP: 269.84,85.04 271.49,85.04 271.62,84.92 271.62,84.41 271.11,83.9 271.11,83.14 270.99,83.01 269.97,83.01 269.59,83.39 269.59,84.79
GND on TOP: 230.09,178.39 233.01,178.39 233.14,178.26 233.14,178.01 232.51,177.37 232.51,177.12 233.01,176.61 233.01,176.36 232.89,176.23 232.63,176.23 231.87,176.99 231.49,176.99 231.36,177.12 230.09,177.12 229.97,177.24 229.97,178.26
GND on TOP: 62.71,63.71 62.71,61.04 62.83,60.91 63.34,60.91 64.36,59.9 65.37,59.9 65.75,60.28 67.28,60.28 67.53,60.53 67.53,62.06 67.79,62.31 67.79,62.94 67.53,63.2 67.53,64.21 67.41,64.34 67.15,64.34 66.64,63.83 66.14,63.83 66.01,63.96 66.01,64.21 65.88,64.34 63.85,64.34 63.34,63.83 62.83,63.83
GND on TOP: 235.3,143.46 237.97,143.46 238.35,143.08 238.35,142.7 238.6,142.45 240,142.45 240.63,141.81 240.63,140.41 240.38,140.16 239.74,140.16 238.35,141.56 236.19,141.56 235.3,142.45
GND on TOP: 188.11,128.81 189,128.81 189,128.32 189.27,128.04 189.27,127.33 189.2,127.26 187.12,127.26 186.05,128.32 185.57,128.32 185.39,128.5 185.39,128.81 185.82,129.24 186.15,129.24 186.25,129.34 186.25,130.18 186.35,130.28 186.89,130.28 187.09,130.08 187.09,128.68 187.22,128.55 187.9,128.55 188.11,128.76
GND on TOP: 300.2,123.52 300.83,123.52 300.83,122.13 300.45,121.75 300.45,120.98 300.32,120.86 300.07,120.86 299.82,121.11 299.82,122.13 300.2,122.51
GND on TOP: 23.97,3.38 23.97,0.84 24.23,0.59 33.12,0.59 33.37,0.84 33.37,3.38
GND on TOP: 45.18,67.9 45.18,69.93 45.31,70.06 45.94,70.06 46.2,70.31 46.2,70.82 46.32,70.95 47.34,70.95 47.64,70.64 47.64,68.71 47.39,68.46 47.39,67.54 47.21,67.36 47.21,66.93 47.26,66.88 47.64,66.88 47.87,67.11 47.87,67.77 47.97,67.87 47.97,68.41 48.05,68.48 48.05,71 47.59,71.45 45.31,71.45 44.67,70.82 44.67,67.9 44.8,67.77 45.05,67.77
GND on TOP: 233.9,67.26 233.9,65.48 233.65,65.23 232.51,65.23 232.25,65.48 232.25,67.64 232.38,67.77 232.76,67.77 233.27,67.26
GND on TOP: 14.32,20.27 18.13,20.27 18.38,20.02 18.38,18.11 18.26,17.99 17.49,17.99 16.86,18.62 14.19,18.62 14.07,18.75 14.07,20.02
GND on TOP: 223.11,182.96 224.89,182.96 225.9,181.94 225.9,178.51 224.76,177.37 224.76,176.36 224.5,176.1 222.22,176.1 221.96,176.36 221.96,178.26 222.22,178.51 222.22,182.07
GND on TOP: 284.1,14.73 286.51,14.73 286.64,14.61 286.64,13.97 286.51,13.84 285.5,13.84 285.37,13.72 285.37,12.32 285.11,12.06 285.11,11.05 284.99,10.92 283.59,10.92 283.46,11.05 283.46,11.68 283.97,12.19 283.97,14.61
GND on TOP: 276.57,74.12 276.57,75.26 276.83,75.52 276.83,75.77 276.7,75.9 275.94,75.9 275.81,75.77 275.3,75.77 275.18,75.64 275.18,74.12 275.43,73.87 276.32,73.87
GND on TOP: 275.97,22.35 274.19,22.35 274.07,22.23 274.07,20.57 274.19,20.45 274.57,20.45 274.95,20.07 275.21,20.07 275.59,20.45 275.97,20.45 276.1,20.57 276.1,22.23
GND on TOP: 296.77,37.93 296.51,37.67 294.1,37.67 293.97,37.8 293.97,38.81 294,38.84 294,39.35 294.1,39.45 294.86,39.45 294.99,39.32 296.64,39.32 296.77,39.2
GND on TOP: 300.58,142.7 302.48,142.7 302.74,142.45 302.74,141.3 302.48,141.05 301.47,141.05 301.34,140.92 301.34,139.91 301.09,139.65 300.7,139.65 300.58,139.78 300.58,140.67 300.32,140.92 300.32,142.45
GND on TOP: 117.82,27.77 117.44,28.15 117.44,38.18 122.65,43.39 125.44,43.39 127.48,41.35 127.48,39.45 128.62,38.31 158.34,38.31 158.72,38.69 158.72,40.72 158.08,41.35 149.83,41.35 149.32,41.86 149.32,47.07 149.7,47.45 164.69,47.45 172.56,39.58 181.45,39.58 182.15,40.28 182.15,45.99 182.47,46.31 191.74,46.31 192.75,45.29 211.3,45.29 211.3,37.54 123.41,37.54 122.65,36.78 122.65,28.02 122.4,27.77
GND on TOP: 255.49,85.55 257.52,85.55 258.67,84.41 258.67,83.39 258.54,83.26 254.6,83.26 254.48,83.39 254.48,84.92 254.73,85.17 255.11,85.17
GND on TOP: 207.61,157.81 207.3,158.12 207.16,158.12 207.04,158.25 206.62,158.25 206.37,158.5 206.37,159.36 206.47,159.46 207.99,159.46 208.25,159.21 208.25,157.94 208.12,157.81
GND on TOP: 211.93,114.89 213.58,114.89 213.71,114.76 213.71,113.49 213.84,113.36 215.36,113.36 215.61,113.62 215.61,115.9 215.36,116.16 214.85,116.16 214.22,115.52 211.93,115.52 211.8,115.4 211.8,115.01
GND on TOP: 117.95,118.06 117.95,115.65 118.08,115.52 145.38,115.52 145.64,115.78 145.64,122.76 143.61,124.79 135.1,124.79 134.46,124.16 123.41,124.16 123.29,124.03 123.29,121.36 123.03,121.11 120.36,121.11 120.11,120.86 120.11,120.22
GND on TOP: 261.84,137.04 261.79,136.99 261.79,133.43 261.97,133.25 261.97,132.41 261.72,132.16 261.72,131.02 261.97,130.76 262.99,130.76 263.24,131.02 263.24,131.52 263.11,131.65 263.11,132.29 262.86,132.54 262.86,136.22 263.37,136.73 263.37,137.62 262.99,138 262.99,140.03 262.73,140.29 262.3,140.29 262.27,140.26 262.27,139.98 261.84,139.55
GND on TOP: 308.32,105.87 309.59,105.87 309.85,105.62 309.85,103.33 309.59,103.08 308.71,103.08 308.58,103.2 308.58,103.84 308.2,104.22 308.2,105.74
GND on TOP: 300.07,136.1 300.45,136.1 300.83,135.72 300.83,134.57 300.7,134.45 299.82,134.45 299.69,134.57 299.69,135.46 300.07,135.84
GND on TOP: 262.1,129.87 263.11,129.87 263.24,129.75 263.24,128.6 263.11,128.48 262.1,128.48 261.97,128.6 261.97,129.75
GND on TOP: 248.25,121.69 248.18,121.77 248.18,122.25 247.82,122.61 247.82,123.24 247.69,123.37 247.69,124.67 247.97,124.95 248.23,124.95 248.33,124.84 248.33,122.51 248.56,122.28 249.12,122.28 249.19,122.36 249.19,123.42 249.32,123.55 249.32,124.39 249.19,124.51 249.19,124.84 249.09,124.95 249.09,125.81 249.22,125.94 249.22,126.44 249.12,126.55 249.12,127.16 249.19,127.23 249.19,127.79 249.12,127.87 249.12,128.68 249.19,128.76 249.19,129.72 249.32,129.85 249.6,129.85 249.7,129.75 249.7,128.65 249.63,128.58 249.63,127.79 249.73,127.69 249.73,127.21 249.65,127.13 249.65,126.37 249.78,126.24 249.78,125.89 249.65,125.76 249.65,125.07 249.75,124.97 249.75,122.41 249.9,122.25 250.51,122.25 250.57,122.3 250.57,122.96 250.67,123.07 250.67,123.5 250.92,123.75 250.92,124.41 250.64,124.69 250.64,128.5 250.57,128.58 250.57,129.72 250.26,130.03 250.26,130.58 250.62,130.94 250.62,131.04 250.79,131.22 251.02,131.22 251.12,131.12 251.12,124.74 251.33,124.54 251.33,123.73 251.23,123.63 251.23,122.74 251.25,122.71 251.25,121.85 251.1,121.69
GND on TOP: 33.91,18.29 33.65,18.03 33.65,15.88 33.91,15.62 36.7,15.62 36.96,15.88 36.96,16.26 37.21,16.51 40.87,16.51 41.63,17.27 43.18,17.27 43.43,17.53 43.43,18.16 43.31,18.29
GND on TOP: 83.03,59.9 84.55,59.9 84.68,59.77 84.68,57.48 84.55,57.36 83.03,57.36 82.65,57.74 82.65,59.52
GND on TOP: 118.33,134.57 120.11,134.57 120.62,134.06 120.62,131.65 120.36,131.4 118.46,131.4 118.08,131.78 118.08,134.32
GND on TOP: 237.2,160.23 237.46,159.97 237.46,158.45 237.2,158.19 235.05,158.19 234.41,158.83 233.78,158.83 233.65,158.96 233.65,162.89 233.9,163.15 235.81,163.15 237.2,161.75
GND on TOP: 250.62,139.42 250.62,138.48 250.84,138.26 250.84,137.7 250.62,137.47 250.62,137.16 250.9,136.88 250.9,136.35 250.67,136.12 250.67,135.79 250.77,135.69 251.05,135.69 251.25,135.89 251.25,139.32 250.84,139.73 250.84,140.9 250.69,141.05 249.55,141.05 249.47,140.97 249.47,139.78 249.3,139.6 249.3,138.56 249.37,138.48 249.63,138.48 249.8,138.66 249.8,139.58 249.9,139.68 250.36,139.68
GND on TOP: 272.54,10.67 272.54,9.4 272.8,9.14 277.11,9.14 277.37,9.4 277.37,10.67 277.11,10.92 272.8,10.92
GND on TOP: 213.1,190.68 212.44,191.34 212.44,196.55 212.33,196.66 212.33,197.54 211.68,198.2 211.68,203.15 210.92,203.91 210.92,205.69 211.17,205.95 267.3,205.95 267.43,205.82 267.43,204.3 267.3,204.17 265.27,204.17 265.02,204.42 265.02,205.06 264.89,205.18 263.24,205.18 263.11,205.06 263.11,201.63 263.87,200.87 270.86,200.87 271.11,200.61 271.11,197.21 271.77,196.55 271.77,191.24 271.22,190.68 ; 4 cut-outs
GND on TOP: 226.84,74.63 229.03,74.63 229.28,74.37 230.04,74.37 230.3,74.12 230.3,73.36 230.07,73.13 227.91,73.13 227.78,73.26 227.45,73.26 226.71,73.99 226.71,74.5
GND on TOP: 229.2,175.21 231.87,175.21 232.12,174.96 233.01,174.96 233.14,174.83 233.14,174.45 233.01,174.32 232.25,174.32 231.87,173.94 229.08,173.94 228.95,174.07 228.95,174.96
