# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
B+_1.0VG:
  vias: v1(213.25,169.68) v2(213.71,168.74) v2(213.84,169.37)
B+_1.05VP:
  vias: v1(259.4,42.8)
B+_1.8VP:
  vias: v1(121.18,136.55) v2(118.84,136.73) v2(119.6,136.73)
B+_2.5VP:
  vias: v1(217.01,115.78) v2(214.6,117.86) v2(215.23,117.86)
B+_GPU_ALL: length 7.3
  IN08 w2.54: 308.07,126.32 308.07,119.84
  BOTTOM w0.381: PC3426.1 v2(297.94,98.93)
  vias: v1(299.18,103.2) v2(172.69,204.04) v2(172.69,203.28) v2(172.69,202.52) v2(172.69,201.5) v2(173.32,204.04) v2(173.32,203.28) v2(173.32,202.52) v2(173.32,201.5) v2(173.96,204.04) v2(173.96,203.28) v2(173.96,202.52) v2(173.96,201.5) v2(174.59,204.04) v2(174.59,203.28) v2(174.59,202.52) v2(174.59,201.5) v2(197.58,205.18) v2(197.83,204.55) v2(198.34,205.18) v2(198.47,204.55) v2(199.1,205.18) v2(199.1,204.42) v2(199.1,203.66) v2(199.87,205.18) v2(199.87,204.42) v2(199.87,203.66) v2(200.63,205.18) v2(200.63,204.42) v2(200.63,203.66) v2(201.39,205.18) v2(201.39,204.42) v2(201.39,203.66) v2(230.32,81.49) v2(230.96,81.49) v2(231.62,81.46) v2(232.25,81.46) v2(232.89,81.46) v2(233.52,81.46) v2(254.1,80.09) v2(254.73,80.09) v2(255.37,80.09) v2(256,80.09) v2(256.64,80.09) v2(257.27,80.09) v2(296.42,99.69) v2(296.42,98.93) v2(297.18,102.11) v2(297.18,101.35) v2(297.18,99.69) v2(297.18,98.93) v2(297.18,95.25) v2(297.18,94.49) v2(297.18,93.73) v2(297.18,92.96) v2(297.94,99.69) v2(297.94,95.25) v2(297.94,94.49) v2(297.94,93.73) v2(297.94,92.96) v2(305.53,168.35) v2(305.53,167.47) v2(305.53,166.58) v2(305.53,165.69)
B+_GPU_ALLN: length 151.7
  TOP w0.254: v2(171.16,199.34) 171.69,199.86 PR701.4
  IN05 w0.254: v2(296.13,198.8) 295.84,199.09 292.32,199.09 286.73,193.5 274.67,193.5 271.37,196.8 271.37,204.93 271.75,205.31 272.38,205.31 v2(272.51,205.44)
  IN08 w0.254: v2(171.16,199.34) 170.91,199.09 170.91,197.47 171.32,197.06 177.39,197.06 177.77,196.68 184.3,196.68 187.04,199.41 187.04,201.5 188.31,202.77 196.82,202.77 197.45,202.14 201.9,202.14 203.04,203.28 210.12,203.28 211.14,204.3 213.2,204.3 213.84,204.93 220.69,204.93 221.33,204.3 225.9,204.3 226.66,205.06 233.9,205.06 234.66,204.3 237.84,204.3 238.6,205.06 246.35,205.06 247.11,204.3 249.65,204.3 250.41,205.06 258.54,205.06 259.3,204.3 262.6,204.3 263.37,205.06 269.34,205.06 269.72,205.44 v2(272.51,205.44)
  BOTTOM w0.254: PR26.1 v2(296.13,198.8)
B+_GPU_ALLP: length 151.2
  TOP w0.254: PR701.3 169.88,199.61 v2(170.15,199.34)
  IN05 w0.254: v2(296.13,199.69) 295.9,199.47 292.16,199.47 286.58,193.88 274.83,193.88 271.75,196.96 271.75,204.76 271.92,204.93 272.26,204.93 v2(272.51,204.68)
  IN08 w0.254: v2(272.51,204.68) 272.13,205.06 269.97,205.06 269.59,204.68 263.52,204.68 262.76,203.91 259.14,203.91 258.38,204.68 250.67,204.68 249.9,203.91 246.86,203.91 246.09,204.68 238.76,204.68 238,203.91 234.41,203.91 233.65,204.68 226.92,204.68 226.16,203.91 221.17,203.91 220.54,204.55 213.99,204.55 213.36,203.91 211.3,203.91 210.28,202.9 203.3,202.9 202.15,201.76 197.2,201.76 196.56,202.39 188.56,202.39 187.55,201.37 187.55,199.38 184.46,196.29 177.51,196.29 177.13,196.68 171.16,196.68 170.53,197.31 170.53,198.96 v2(170.15,199.34)
  BOTTOM w0.254: PR29.1 v2(296.13,199.69)
B+_GPU_COREN: length 110.7
  TOP w0.254: PR901.4 203.6,201.46 203.6,200.94 v2(203.8,200.74)
  IN05 w0.254: v2(273.02,202.64) 273.4,202.26 273.4,200.61 273.52,199.4 273.74,198.81 274.21,197.53 274.29,197.36 274.86,196.61 276.83,194.64 285.59,194.64 293.97,203.03 298.54,203.03 v2(298.8,202.77)
  IN08 w0.254: v2(273.02,202.64) 273.02,202.68 272.8,202.9 270.19,202.9 269.56,203.53 264.41,203.53 263.78,202.9 258.51,202.9 257.87,203.53 251.33,203.53 250.7,202.9 245.59,202.9 244.95,203.53 239.14,203.53 238.51,202.9 233.39,202.9 232.76,203.53 227.46,203.53 226.82,202.9 220.28,202.9 219.77,203.41 214.73,203.41 214.22,202.9 211.93,202.9 210.66,201.63 203.93,201.63 203.68,201.37 203.68,200.87 v2(203.8,200.74)
  BOTTOM w0.254: PR36.1 v2(298.8,202.77)
B+_GPU_COREP: length 111.6
  TOP w0.254: v2(203.04,200.74) 203.22,200.92 203.22,201.49 PR901.3
  IN05 w0.254: v2(298.8,203.65) 298.55,203.41 293.82,203.41 285.43,195.02 276.99,195.02 275.45,196.56 274.63,197.7 274.04,199.14 273.87,199.77 273.78,200.74 273.78,202.64 v2(273.02,203.41)
  IN08 w0.254: v2(203.04,200.74) 203.3,200.99 203.3,201.53 203.77,202.01 210.5,202.01 211.77,203.28 213.96,203.28 214.47,203.79 219.93,203.79 220.44,203.28 226.66,203.28 227.3,203.91 233.01,203.91 233.65,203.28 238.35,203.28 238.98,203.91 245.21,203.91 245.84,203.28 250.54,203.28 251.17,203.91 258.03,203.91 258.67,203.28 263.62,203.28 264.26,203.91 269.72,203.91 270.35,203.28 272.89,203.28 v2(273.02,203.41)
  BOTTOM w0.254: PR24.1 v2(298.8,203.65)
B+_NVVDDSN: length 218.1
  IN05 w0.254: v2(309.72,200.58) 309.49,200.36 308.8,200.36 308.32,199.88 308.32,185.28 304.39,181.34 304.39,175.31 308.2,171.5 308.2,121.24 307.31,120.35 307.31,112.73 308.58,111.46 308.58,103.71 308.96,103.33 308.96,95.71 309.47,95.2 309.47,81.74 308.07,80.34 305.53,80.34 304.9,79.71 304.9,78.82 305.28,78.44 306.04,78.44 v2(306.17,78.31)
  IN10 w0.254: v2(306.17,78.31) 306.04,78.44 296.51,78.44 295.88,77.8 286.61,77.8 285.34,79.07 282.42,79.07 281.65,78.31 262.35,78.31 261.97,77.93 250.29,77.93 248.63,79.58 239.36,79.58 236.25,82.7 228.65,82.7 227.68,83.67 227.68,84.48 v2(227.55,84.61)
  BOTTOM w0.254: v2(227.55,84.61) 227.55,84.78 227.94,85.17 228.76,85.17 PR3552.4 ; PR3569.1 v2(309.72,200.58)
B+_NVVDDSP: length 216.1
  IN05 w0.254: v2(306.17,78.95) 306.04,78.82 305.53,78.82 305.28,79.07 305.28,79.45 305.78,79.96 308.23,79.96 309.85,81.58 309.85,95.58 309.34,96.09 309.34,103.49 308.96,103.87 308.96,111.71 307.69,112.98 307.69,119.97 308.58,120.86 308.58,171.66 304.77,175.47 304.77,181.18 308.78,185.2 308.78,199.8 308.96,199.98 309.43,199.98 v2(309.72,199.69)
  IN10 w0.254: v2(228.22,84.61) 228.06,84.45 228.06,83.82 228.75,83.14 236.44,83.14 239.62,79.96 248.79,79.96 250.44,78.31 261.72,78.31 262.1,78.69 281.5,78.69 282.26,79.45 285.59,79.45 286.86,78.18 295.62,78.18 296.26,78.82 306.04,78.82 v2(306.17,78.95)
  BOTTOM w0.254: v2(228.22,84.61) 228.22,83.91 PR3552.3 ; PR3568.1 v2(309.72,199.69)
BAT_R:
  vias: v1(94.58,17.68) v1(95.22,23.07) v1(97.12,22.94)
BATT_SMB_CLK: length 3
  BOTTOM w0.097: PR101.2 95.93,15.62 v1(95.98,15.57) 96.49,15.57 96.97,16.05 JBAT1.5
BATT_SMB_DAT: length 3.1
  BOTTOM w0.097: PR102.2 95.47,13.85 v1(95.93,14.3) 96.43,14.8 JBAT1.6
BGATE: length 19.5
  TOP w0.254: v2(87.22,11.89) 86.84,11.89 86.59,11.64 PU201.25
  TOP w0.356: v2(99.77,20.76) 99.87,20.65 PR231.1
  IN03 w0.508: v2(87.22,11.89) 88.39,11.89 89.2,12.7 90.69,12.7 91.99,14 95.35,14 99.77,18.41 v2(99.77,20.76)
BIOS_ONEKEY_N: length 66.3
  IN05 w0.091: v3(69.6,20.19) 68.88,20.91 64.61,20.91 63.85,20.15 55.98,20.15 54.71,21.41 54.71,25.73 46.45,33.99 42.89,33.99 v2(41.5,35.39)
  IN08 w0.089: 35.72,46.69 v1(35.72,50.88)
  IN08 w0.091: v2(41.5,35.39) 38.7,35.39 37.56,36.53 37.56,38.18 36.29,39.45 36.29,41.99 35.4,42.88 35.4,44.46 35.72,44.78 35.72,46.69
  BOTTOM w0.089: U5.D8 35.77,50.93 v1(35.72,50.88)
  BOTTOM w0.097: R268.2 68.96,19.55 v3(69.6,20.19) 69.98,20.19 70.94,19.23 70.94,18.36 69.6,17.02 68.58,17.02 68.09,16.53 JKB1.48
BMON: length 101.7
  TOP w0.097: v3(78.63,5.29) 78.2,5.72 78.2,7.18 78.37,7.34 79.06,7.34 PC219.2 PR215.1
  IN03 w0.089: 41.5,52.4 40.23,52.4 39.97,52.15 v1(37.43,52.15)
  IN03 w0.091: 41.5,52.4 41.75,52.4 42.13,52.78 49.12,52.78 51.41,50.5 52.16,50.5 52.85,51.18 55.26,51.18 55.72,51.64 58.26,51.64 63.72,57.1 71.34,57.1 v2(71.47,57.23)
  IN08 w0.091: v3(78.63,5.29) 79.09,5.74 79.09,6.43 80.61,7.95 80.61,15.83 78.2,18.24 78.2,20.4 78.49,20.68 78.49,30.01 79.39,30.91 79.39,33.01 71.37,41.02 71.37,44.05 71.63,44.3 71.63,45.95 72.36,46.69 72.36,56.34 v2(71.47,57.23)
  BOTTOM w0.089: U5.F10 36.79,52.41 37.05,52.15 v1(37.43,52.15)
BOARD_ID0: length 7.3
  BOTTOM w0.097: U2.AG42 227.47,60.1 227.27,60.1 227.22,60.05 226.82,60.05 226.69,59.92 226.69,59.74 225.98,59.03 225.34,59.03 224.86,58.55 v1(224.43,58.55) 224.17,58.8 224.17,59.41 R188.2 R186.1
BOARD_ID1: length 5.7
  TOP w0.097: v3(224,60.4) 224.17,60.23 R187.2 R185.1
  BOTTOM w0.097: v3(224,60.4) 224.5,59.9 v1(224.58,59.9) 225.01,59.9 225.47,60.35 226.44,60.35 226.64,60.56 227.11,60.56 U2.AG43
BOARD_ID2: length 2.6
  TOP w0.097: R856.1 R855.2 v3(225.98,60.73)
  BOTTOM w0.097: U2.AE45 226.2,60.96 v3(225.98,60.73)
BST_3V: length 2.1
  TOP w0.203: 47.09,14.56 46.98,14.45 PU301.9
  TOP w0.508: 47.09,14.56 47.59,15.07 PR309.2
BST_5V: length 1.8
  TOP w0.203: 41.99,14.45 PU301.17
  TOP w0.508: PR308.1 41.57,14.45 41.99,14.45
CAM_PWR_EN: length 283.5
  TOP w0.097: v3(231.11,66.75) 230.6,67.26 230.12,67.26 228.92,68.46 R103.1
  IN03 w0.091: v2(148.56,196.29) 149.45,195.41 157.7,195.41 158.59,194.52 164.05,194.52 v2(164.56,195.02)
  IN08 w0.091: v2(164.56,195.02) 164.94,195.41 169.26,195.41 170.4,194.26 176.88,194.26 178.94,192.21 195.7,192.21 198.34,189.56 198.34,184.64 196.95,183.25 196.95,163.27 198.72,161.5 198.72,156.29 197.58,155.15 197.58,150.19 195.93,148.54 195.93,132.03 195.42,131.52 195.42,128.48 172.05,105.11 172.05,73.61 172.56,73.1 172.56,62.44 174.34,60.66 174.34,59.52 175.23,58.63 176.24,58.63 v2(176.75,59.13)
  IN10 w0.091: v2(176.75,59.13) 176.75,62.69 177.08,63.02 177.08,65.18 178.78,66.88 199.61,66.88 203.4,70.67 203.4,72.83 204.31,73.74 209.52,73.74 210.28,72.98 210.28,65.99 213.07,63.2 216.38,63.2 222.6,69.42 227.93,69.42 230.09,67.26 230.6,67.26 v3(231.11,66.75)
  BOTTOM w0.097: PR1305.2 148.5,196.36 v2(148.56,196.29) ; v3(231.11,66.75) 231.11,66.71 U2.R36
CFG0: length 18.8
  TOP w0.097: v2(151.59,148.68) 151.53,148.75 R10.2
  IN05 w0.091: v2(142.97,141.68) 141.83,142.83 141.83,146.26 142.82,147.25 148.57,147.25 148.81,147.5 151.09,147.5 151.59,148.01 v2(151.59,148.68)
  BOTTOM w0.097: v2(151.59,148.68) 151.27,148.36 U1.BN25 ; v2(142.97,141.68) TP24.1
CFG1: length 2.6
  TOP w0.097: v1(149.32,150.45) 149.9,149.86 150.55,149.86 v3(150.94,149.47)
  BOTTOM w0.097: U1.BN27 151.27,149.8 v3(150.94,149.47)
CFG2: length 2.8
  TOP w0.097: R12.2 150.88,148.75 v3(150.94,148.68) 150.96,148.68 v1(151.61,148.03) 151.86,147.78 TP28.1
  BOTTOM w0.097: v3(150.94,148.68) 151.27,149.01 U1.BN26
CFG3: length 7.5
  TOP w0.097: v2(151.59,150.26) 152.16,150.83 TP29.1
  BOTTOM w0.076: U1.BN28 151.27,150.58 v2(151.59,150.26)
  BOTTOM w0.097: U1.BN28 151.02,150.65 150.55,151.13 148.89,151.13 148.43,151.59 147.42,151.59 146.91,151.08 146.53,151.08 146.02,150.57 R269.1
CFG4: length 7.7
  TOP w0.097: v3(149.63,143.97) 149.98,144.32 R23.2
  BOTTOM w0.097: TP30.1 146.15,145.49 147.29,144.35 148.56,144.35 148.94,144.73 149.45,144.73 149.83,144.35 U1.BR20 149.97,144.31 v3(149.63,143.97)
CFG5: length 13.2
  TOP w0.097: v2(151.59,143.96) 152.22,143.34 R28.2
  IN05 w0.091: v2(151.59,143.96) 151.22,143.59 148.18,143.59 147.54,142.95 146.15,142.95 v2(142.97,139.78)
  BOTTOM w0.097: v2(151.59,143.96) 151.92,144.28 U1.BM20 ; v2(142.97,139.78) TP31.1
CFG6: length 7.7
  TOP w0.097: v3(148.98,143.97) 148.81,143.97 v1(148.3,143.46) 148.3,142.9 R26.2
  BOTTOM w0.097: U1.BT20 149.32,144.31 v3(148.98,143.97) 148.94,143.97 146.65,141.68 TP33.1
CFG7: length 7.4
  TOP w0.097: R32.2 150.28,143.85 v3(150.28,143.97)
  IN05 w0.091: v3(150.28,143.97) 149.9,144.35 146.91,144.35 v2(146.15,143.59)
  BOTTOM w0.097: TP32.1 v2(146.15,143.59) ; v3(150.28,143.97) 150.62,144.31 U1.BP20
CFG8: length 1.5
  TOP w0.097: v1(149.07,146.38) 149.07,146.53 v3(149.65,147.11)
  BOTTOM w0.097: U1.BR23 149.97,146.78 v3(149.65,147.11)
CFG9: length 3.1
  BOTTOM w0.097: TP36.1 147.09,146.2 149.69,146.2 U1.BR22
CFG10: length 2.5
  BOTTOM w0.097: U1.BT23 148.76,147.27 TP39.1
CFG11: length 2.4
  BOTTOM w0.097: U1.BT22 149.29,145.95 147.24,145.95 TP38.1
CFG12: length 10.5
  IN05 w0.091: v3(151.58,143.18) 150.97,142.57 150.97,141.56 150.46,141.05 149.32,141.05 148.05,139.78 148.05,139.53 145.89,137.37 v2(145.64,137.37)
  BOTTOM w0.097: U1.BM19 151.92,143.52 v3(151.58,143.18) ; TP40.1 v2(145.64,137.37)
CFG13: length 11
  IN05 w0.091: v2(142.97,137.87) 144.75,139.65 144.75,140.29 146.78,142.32 148.61,142.32 149.48,143.18 v3(149.63,143.18)
  BOTTOM w0.097: v2(142.97,137.87) TP41.1 ; v3(149.63,143.18) 149.97,143.52 U1.BR19
CFG14: length 10.1
  IN05 w0.091: v3(150.28,143.18) 149.93,142.83 149.45,142.83 146.53,139.91 146.53,139.53 v2(146.15,139.14)
  BOTTOM w0.097: TP43.1 v2(146.15,139.14) ; U1.BP19 150.62,143.52 v3(150.28,143.18)
CFG15: length 6
  BOTTOM w0.097: U1.BT19 145.53,139.78 TP42.1
CFG16: length 12.8
  IN05 w0.091: v3(150.3,147.11) 149.7,146.51 142.97,146.51 142.34,145.88 142.34,144.22 v2(142.97,143.59)
  BOTTOM w0.097: v2(142.97,143.59) TP44.1 ; v3(150.3,147.11) 150.62,146.78 U1.BP23
CFG17: length 1.6
  TOP w0.097: v1(151.48,146.26) 151.48,146.57 v3(150.95,147.11)
  BOTTOM w0.097: v3(150.95,147.11) 151.27,146.78 U1.BN23
CFG18: length 10.2
  IN05 w0.091: v3(150.93,145.55) 150.47,146 143.48,146 v2(142.97,145.49)
  BOTTOM w0.097: v3(150.93,145.55) 151.27,145.88 U1.BN22 ; v2(142.97,145.49) TP47.1
CFG19: length 3.9
  BOTTOM w0.097: TP46.1 147.42,146.38 150.16,146.38 U1.BP22
CFG_RCOMP: length 3.5
  BOTTOM w0.254: U1.BT25 149.07,148.29 148.68,147.91 R22.2
CHASSIS1_GND: length 1.9
  TOP w0.457: C279.2 13.81,114
  TOP w0.508: C278.2 4.67,113.87
  vias: v1(10.26,113.74) v2(1.62,113.49) v2(1.62,112.73) v2(2.38,112.86) v2(7.08,113.36) v2(9.24,113.62) v2(13.18,113.49) v2(20.11,101.63) v2(20.14,100.26) v2(20.14,98.76) v2(20.14,97.21) v2(20.06,95.66) v2(20.09,94.26) v2(20.06,92.64) v2(20.06,91.37)
CHG_DH: length 2.2
  TOP w0.254: 88.23,11 87.84,10.6 PU201.23
  TOP w0.356: PR209.2 88.55,11 88.23,11
CHG_DH_R: length 9.2
  TOP w0.508: v2(96.62,14.3) 96.41,14.09 PQ204.1 ; PR209.1 v2(91.06,11.38)
  IN03 w0.508: v2(96.62,14.3) 96.62,13.31 95.12,11.81 92.63,11.81 91.87,11.05 91.39,11.05 v2(91.06,11.38)
CHG_DL: length 16.5
  TOP w0.254: 88.92,9.99 88.74,9.8 PU201.21
  TOP w0.508: v2(100.3,14.3) 101.04,13.56 PQ204.8 ; v2(92.33,10.49) v1(91.57,10.49) 91.15,10.49 90.77,10.11 89.05,10.11 88.92,9.99
  IN03 w0.508: v2(100.3,14.3) 98.63,14.3 95.5,11.18 92.96,11.18 92.33,10.54 v2(92.33,10.49)
CHG_PAHSE: length 1.7
  TOP w0.097: 105.12,5.92 105.12,4.4 v1(105,4.27)
CHG_PROCHOT_N: length 4
  TOP w0.097: PU201.5 82.14,9.4 81.96,9.22 80.05,9.22 PR229.2
CHG_PROCHOT_N_R: length 88.3
  TOP w0.097: v3(78.33,10.87) 78.63,10.57 PR229.1
  IN05 w0.089: 41.5,47.96 v3(40.35,47.96)
  IN05 w0.091: 41.5,47.96 43.4,47.96 44.29,47.07 46.7,47.07 47.18,46.59 48.07,46.59 53.51,41.15 53.51,37.16 58.24,32.43 66.17,32.43 68.8,29.8 70.34,29.8 73.13,32.59 75.91,32.59 76.42,33.1 78.33,33.1 v2(78.96,32.46)
  IN08 w0.091: v2(78.96,32.46) 78.84,32.59 77.18,32.59 76.69,32.09 76.69,19.37 77.06,19 77.06,16.46 77.95,15.57 79.09,15.57 79.51,15.16 79.51,13.83 78.33,12.65 v3(78.33,10.87)
  BOTTOM w0.089: v3(40.35,47.96) 41.5,47.96
  BOTTOM w0.097: v3(40.35,47.96) 39.72,48.59 39.72,49.67 38.48,50.91 U5.C13 ; R435.1 46.62,47.61 D2016.1 45.28,47.32 43.4,47.32 43.28,47.45 42.01,47.45 41.8,47.65 R247.2 41.5,47.96
CHG_SMB_CLK: length 2
  TOP w0.097: PU201.4 v1(82.29,9.8) 81.99,9.8 81.91,9.73 PR228.2
CHG_SMB_DAT: length 2.1
  TOP w0.097: PU201.3 81.74,10.2 PR227.2
CHG_TGR: length 12.2
  TOP w0.254: PU201.22 88.2,10.2 v2(88.36,10.37)
  TOP w0.508: PQ204.2 95.71,13 v2(95.71,13.34) ; PC212.2 v2(92.25,13.34)
  IN03 w0.508: v2(88.36,10.37) 88.36,10.89 89.53,12.06 90.98,12.06 v2(92.25,13.34) v2(95.71,13.34)
CK_CPU_24M_N: length 139.5
  IN03 w0.114: v3(188.34,152.86) 188.21,152.86 188.09,152.75 188.09,152.44 188.42,152.11 192.87,152.11 193.34,151.65 193.34,147.2 205.07,135.46 205.07,129.84 206.62,128.3 207.28,128.3 208.77,126.81 208.77,125.87 209.84,124.81 210.77,124.81 211.42,124.15 211.42,117.12 209.9,115.6 209.9,114.76 210.17,114.49 210.17,107.41 209.77,107.01 209.77,101.55 209.15,100.93 209.15,94.81 209.77,94.19 209.77,92.66 212.31,90.12 212.31,86.06 214.71,83.66 239.22,83.66 242.92,79.96 248.88,79.96 253.12,75.73 253.12,73.14 253.26,73 253.49,73 253.6,73.12 253.6,73.32 253.71,73.43 253.89,73.43 v3(254.1,73.23)
  BOTTOM w0.104: U1.D31 188,153.2 v3(188.34,152.86) ; U2.F1 248.17,70.49 248.56,70.49 250.11,72.04 252.16,72.04 253.15,73.03 253.89,73.03 253.96,73.1 v3(254.1,73.23)
CK_CPU_24M_P: length 139.5
  IN03 w0.114: v3(254.1,72.6) 253.97,72.72 253.16,72.72 252.85,73.03 252.85,75.62 248.77,79.7 242.81,79.7 239.11,83.39 214.6,83.39 212.05,85.95 212.05,90.01 209.51,92.55 209.51,94.08 208.88,94.7 208.88,101.04 209.51,101.66 209.51,107.12 209.9,107.52 209.9,114.38 209.63,114.65 209.63,115.71 211.16,117.23 211.16,124.04 210.66,124.54 209.73,124.54 208.5,125.76 208.5,126.7 207.17,128.03 206.51,128.03 204.81,129.73 204.81,135.35 193.07,147.09 193.07,151.53 192.76,151.84 188.31,151.84 187.83,152.33 187.83,152.68 v3(187.67,152.84)
  BOTTOM w0.104: U1.E31 187.35,153.16 v3(187.67,152.84) ; v3(254.1,72.6) 253.92,72.77 253.26,72.77 v2(252.95,72.47) 252.26,71.78 250.21,71.78 248.66,70.23 248.17,70.23 U2.G1
CK_CPU_BCLK_N: length 144
  IN03 w0.114: v3(255.62,72.6) 255.67,72.65 256.13,72.65 256.46,72.98 256.46,74.17 255.81,74.82 255.55,74.82 249.51,80.86 243.4,80.86 237.7,86.57 216.25,86.57 213.58,89.23 213.58,94.82 210.79,97.62 210.79,101.81 213.7,104.72 214.46,104.72 216.38,106.63 216.38,111.59 215.79,112.18 215.79,115.6 213.58,117.8 213.58,123.27 213.72,123.41 213.72,125.34 212.24,126.83 210.15,126.83 207.87,129.11 207.87,129.62 207.64,129.85 207.64,135.06 194.23,148.47 194.23,152.02 193.19,153.06 191.56,153.06 191.21,153.42 v2(191.21,153.52)
  BOTTOM w0.076: U2.H2 247.7,69.68 248.45,69.68 248.5,69.62 248.51,69.62
  BOTTOM w0.104: v3(255.62,72.6) 255.62,72.65 255.29,72.98 255.17,72.98 255.06,72.87 255.06,71.91 v2(254.54,71.39) 254.2,71.05 250.75,71.05 249.33,69.62 248.51,69.62 ; U1.A32 190.19,153.93 190.8,153.93 v2(191.21,153.52)
CK_CPU_BCLK_P: length 143.9
  IN03 w0.114: v2(190.57,153.52) 191.01,153.08 191.17,153.08 191.45,152.8 193.08,152.8 193.96,151.91 193.96,148.35 207.37,134.95 207.37,129.74 207.6,129.51 207.6,129 210.04,126.56 212.13,126.56 213.46,125.23 213.46,123.52 213.32,123.38 213.32,117.69 215.52,115.49 215.52,112.07 216.11,111.48 216.11,106.74 214.35,104.98 213.59,104.98 210.52,101.92 210.52,97.51 213.32,94.71 213.32,89.12 216.14,86.3 237.59,86.3 243.29,80.6 249.4,80.6 255.44,74.55 255.7,74.55 256.19,74.06 256.19,73.09 256.02,72.91 255.89,72.91 255.62,73.18 v3(255.62,73.23)
  BOTTOM w0.076: 248.51,69.88 248.49,69.88 248.44,69.83 247.81,69.83 U2.G2
  BOTTOM w0.104: 248.51,69.88 249.22,69.88 v2(250.16,70.82) 250.64,71.3 254.09,71.3 254.81,72.02 254.81,72.98 255.06,73.23 v3(255.62,73.23) ; U1.B31 189.3,153.31 189.38,153.39 190.09,153.39 190.32,153.62 190.47,153.62 v2(190.57,153.52)
CK_CPU_PCIBCLK_N: length 151.2
  IN03 w0.114: v3(257.27,72.6) 257.64,72.97 257.79,72.97 258.05,73.22 258.05,74.1 255.91,76.24 255.4,76.24 249.19,82.45 243.1,82.45 238.09,87.46 218.05,87.46 216.27,89.23 216.27,94.29 215.23,95.33 214.34,95.33 211.93,97.74 211.93,101.07 212.87,102.01 215.65,102.01 218.17,104.53 218.17,111.32 216.68,112.8 216.68,117.76 214.85,119.59 214.85,125.5 212.64,127.71 210.66,127.71 209.01,129.37 209.01,136.09 195.39,149.72 195.39,152.16 192.8,154.75 188.87,154.75 188.7,154.92 188.7,155.38 188.83,155.51 v2(188.83,155.51)
  BOTTOM w0.104: v2(188.83,155.51) 188.56,155.78 U1.C36 ; U2.J1 248.04,69.04 248.44,69.04 248.59,68.89 249.01,68.89 249.16,69.04 250.17,69.04 251.41,70.29 251.71,70.29 251.85,70.15 252.26,70.15 252.4,70.29 253.62,70.29 253.74,70.16 254.16,70.16 254.29,70.29 255.2,70.29 255.36,70.45 255.45,70.45 255.53,70.45 255.83,70.75 255.83,70.83 255.83,70.83 255.83,70.92 256.12,71.21 256.21,71.21 256.21,71.21 256.29,71.21 256.59,71.51 256.59,71.59 256.59,71.68 v2(256.59,72.22) 256.59,72.64 256.83,72.89 257.05,72.89 257.27,72.67 v3(257.27,72.6)
CK_CPU_PCIBCLK_P: length 151.2
  IN03 w0.114: v3(257.27,73.23) 257.68,73.23 257.78,73.33 257.78,73.99 255.8,75.97 255.29,75.97 249.08,82.18 242.99,82.18 237.98,87.19 217.94,87.19 216,89.12 216,94.18 215.12,95.06 214.23,95.06 211.67,97.63 211.67,101.18 212.76,102.27 215.54,102.27 217.9,104.64 217.9,111.21 216.41,112.69 216.41,117.65 214.59,119.48 214.59,125.39 212.53,127.45 210.55,127.45 208.74,129.26 208.74,135.98 195.12,149.61 195.12,152.05 192.69,154.49 188.76,154.49 188.44,154.81 188.44,155.31 187.83,155.92 v2(187.83,155.92)
  BOTTOM w0.104: U2.J2 247.64,69.29 250.06,69.29 250.47,69.69 251.32,70.54 v2(251.81,70.54) 255.09,70.54 256.33,71.78 256.33,72.75 256.72,73.14 257.18,73.14 v3(257.27,73.23) ; U1.D35 188.09,155.62 187.83,155.88 v2(187.83,155.92)
CK_CR_N: length 92.7
  IN10 w0.114: v2(301.85,33.3) 302.03,33.48 302.47,33.48 302.9,33.91 302.9,35.69 303.15,35.94 303.15,36.58 302.51,37.21 301.5,37.21 300.88,37.83 300.88,46.49 301.68,47.29 301.68,50.32 299.54,52.45 298.5,52.45 289.02,61.93 287.88,61.93 286.86,62.94 286.86,66.5 287.38,67.03 287.38,70.42 286.99,70.81 286.99,71.58 286.23,72.34 284.97,72.34 284.22,71.59 275.42,71.59 274.92,72.09 265.4,72.09 263.51,70.2 258.27,70.2 257.89,70.58 248.43,70.58 248.15,70.86 246.94,70.86 v3(246.85,70.95)
  BOTTOM w0.104: U2.E5 v3(246.85,70.95) ; v2(301.85,33.3) 301.5,33.65 301.09,33.65 301.02,33.58 JIO1.27
CK_CR_P: length 92.7
  IN10 w0.114: v2(301.85,34.19) 301.85,33.9 302.01,33.74 302.36,33.74 302.64,34.02 302.64,34.26 302.51,34.38 302.51,34.62 302.64,34.74 302.64,34.99 302.51,35.11 302.51,35.35 302.64,35.47 302.64,35.81 302.88,36.05 302.88,36.47 302.4,36.94 301.39,36.94 300.61,37.72 300.61,38.02 300.48,38.15 300.48,38.39 300.61,38.52 300.61,38.76 300.48,38.88 300.48,39.13 300.61,39.25 300.61,39.49 300.48,39.62 300.48,39.86 300.61,39.99 300.61,46.61 301.41,47.41 301.41,50.21 299.43,52.18 298.39,52.18 288.91,61.66 287.77,61.66 286.6,62.83 286.6,66.62 287.12,67.14 287.12,70.31 286.72,70.7 286.72,71.47 286.12,72.08 285.08,72.08 284.33,71.33 275.3,71.33 274.81,71.82 265.51,71.82 263.62,69.93 258.16,69.93 257.78,70.31 248.32,70.31 248.04,70.59 247.02,70.59 246.86,70.43 v3(246.86,70.31)
  BOTTOM w0.104: U2.G4 246.54,70 v3(246.86,70.31) ; v2(301.85,34.19) 301.57,33.91 301.09,33.91 301.02,33.98 JIO1.26
CK_LAN_N: length 240.9
  TOP w0.104: R278.1 52.99,60.52 53.75,60.52 54.68,61.45 57.35,61.45 58.39,60.4 58.39,55.32 61.06,52.66 70.2,52.66 73.37,55.83 75.53,55.83 76.52,56.82 76.52,57.3 v2(76.7,57.48)
  IN05 w0.114: v2(76.7,57.48) 76.47,57.48 76.27,57.69 76.27,57.97 76.75,58.45 83.59,58.45 85.32,56.72 88.36,56.72 89.89,58.25 92.53,58.25 95.45,61.17 95.45,61.9 96.03,62.49 96.03,63.5 96.41,63.88 97.58,63.88 98.8,65.1 98.8,65.89 99.71,66.81 99.71,68.08 104.36,72.72 105.4,72.72 106.04,73.36 109.32,73.36 110.2,74.25 113.76,74.25 114.14,74.63 124.35,74.63 129.73,80.01 133.49,80.01 135.1,81.61 135.1,85.17 136.17,86.24 141.76,86.24 143.48,87.96 144.88,87.96 145.51,88.6 145.51,89.87 146.02,90.38 173.45,90.38 174.07,91 177.4,91 178.03,90.38 193.52,90.38 196.23,93.09 198.17,93.09 199.11,92.15 204.57,92.15 205.2,91.52 210.79,91.52 212.68,89.63 212.68,88.23 213.98,86.94 237.9,86.94 245.32,79.51 245.32,77.55 245.07,77.3 245.07,75.02 245.97,74.12 245.97,72.98 245.36,72.37 244.95,72.37 244.82,72.24 244.82,72.09 244.95,71.96 v3(245.08,71.96)
  BOTTOM w0.104: v3(245.08,71.96) 244.53,71.41 U2.D8
CK_LAN_P: length 240.9
  TOP w0.104: R279.1 52.75,60.9 52.88,60.77 53.65,60.77 54.57,61.7 57.45,61.7 58.65,60.51 v2(58.65,58.5) 58.65,55.43 61.16,52.91 70.09,52.91 73.27,56.09 75.43,56.09 76.27,56.93 76.27,57.31 76.09,57.48 v2(75.87,57.48)
  IN05 w0.114: v3(245.84,71.96) 245.7,72.1 245.7,72.33 246.23,72.87 246.23,74.23 245.33,75.13 245.33,77.19 245.59,77.44 245.59,79.62 238.01,87.2 214.09,87.2 212.95,88.34 212.95,89.74 210.9,91.79 205.31,91.79 204.68,92.42 199.22,92.42 198.28,93.36 196.12,93.36 193.41,90.64 178.14,90.64 177.51,91.27 173.96,91.27 173.34,90.64 145.91,90.64 145.24,89.98 145.24,88.71 144.77,88.23 143.37,88.23 141.65,86.51 136.06,86.51 134.83,85.28 134.83,81.72 133.38,80.28 129.62,80.28 124.24,74.9 114.03,74.9 113.65,74.51 110.09,74.51 109.21,73.63 105.93,73.63 105.29,72.99 104.25,72.99 99.45,68.19 99.45,66.92 98.53,66 98.53,65.21 97.47,64.15 96.3,64.15 95.76,63.61 95.76,62.6 95.18,62.01 95.18,61.28 92.42,58.51 89.77,58.51 88.25,56.99 85.43,56.99 83.7,58.72 76.64,58.72 76,58.08 76,57.61 75.97,57.58 75.97,57.57 v2(75.87,57.48)
  BOTTOM w0.104: U2.D7 245.47,71.56 245.7,71.56 245.84,71.69 v3(245.84,71.96)
CK_LPC1: length 1.4
  TOP w0.097: v3(239.62,54.82) 239.36,55.07 v1(238.98,55.07)
  BOTTOM w0.091: U2.AV19 239.57,54.77 v3(239.62,54.82)
CK_LPC/ESPI_CLK: length 249.5
  IN03 w0.091: v2(239.24,46.69) 239.36,46.56 239.36,44.53 236.85,42.02 216.32,42.02 210.41,47.93 202.18,47.93 201.23,48.88 175.77,48.88 175.17,49.48 160.7,49.48 154.98,55.2 126.99,55.2 125.47,56.72 106.3,56.72 104.77,55.2 98.77,55.2 97.5,53.93 95.85,53.93 95.47,54.31 89.12,54.31 87.47,52.66 81.63,52.66 80.99,52.02 80.11,52.02 79.6,52.53 77.06,52.53 76.42,51.9 74.64,51.9 71.61,48.86 63.99,48.86 61.19,46.06 53.66,46.06 52.25,44.66 49.37,44.66 49.16,44.87 46.79,44.87 46.24,44.32 33.47,44.32 32.73,43.59 32.73,40.59 32.05,39.91 30.5,39.91 29.69,40.72 v2(29.69,42.24)
  IN05 w0.089: 30.45,46.69 30.45,53.17 29.81,53.8
  IN05 w0.091: 30.45,46.69 30.45,46.05 30.07,45.67 29.56,45.67 29.18,45.29 29.18,42.75 v2(29.69,42.24) ; 29.81,53.8 v2(29.31,54.31)
  BOTTOM w0.076: 31.97,54.67 32.51,54.67 32.77,54.41 U5.K2
  BOTTOM w0.089: 29.81,54.82 30.06,55.06 31.34,55.06 31.74,54.67
  BOTTOM w0.097: 31.97,54.67 31.74,54.67 ; R264.2 v2(29.31,54.31) 29.81,54.82 ; v2(239.24,46.69) R183.1
CK_LPC/ESPI_CLK_R: length 4.6
  BOTTOM w0.097: U2.BC17 240.09,52.19 240.38,51.9 240.38,51.26 240.25,51.13 240.25,49.74 v1(240.05,49.53) 239.62,49.1 239.62,48.67 R183.2
CK_PCIE_SSD1_N: length 202.3
  IN03 w0.114: v3(250.28,67.52) 250.28,67 250.14,66.86 249.94,66.86 249.8,67 249.8,67.92 250.16,68.28 252.44,68.28 252.7,68.02 257.02,68.02 257.39,67.66 257.39,62.81 255.75,61.17 255.75,56.96 254.97,56.18 254.97,46.82 248.66,40.52 215.69,40.52 209.9,46.31 161.13,46.31 153.74,53.7 117.18,53.7 116.42,52.93 116.42,51.88 116.15,51.62 115.85,51.62 v2(115.67,51.8)
  BOTTOM w0.076: U2.N3 247.16,67.34 247.42,67.08 248.26,67.08 248.31,67.03 248.33,67.03
  BOTTOM w0.104: v2(115.67,51.8) 115.5,51.63 113.76,51.63 109.17,56.21 104.28,56.21 103.7,55.64 103.7,54.7 104.23,54.17 JSSD1.53 ; v3(250.28,67.52) 250.14,67.38 250.14,67.12 249.8,66.78 248.76,66.78 248.5,67.03 248.33,67.03
CK_PCIE_SSD1_P: length 202.3
  IN03 w0.114: v3(249.4,67.52) 249.54,67.66 249.54,68.03 250.05,68.55 252.56,68.55 252.81,68.29 257.13,68.29 257.65,67.77 257.65,62.69 256.01,61.06 256.01,56.85 255.24,56.07 255.24,46.71 248.77,40.25 215.58,40.25 209.79,46.04 161.02,46.04 153.63,53.43 117.3,53.43 116.68,52.82 116.68,51.77 116.26,51.35 115.78,51.35 115.67,51.24 v2(115.67,50.98)
  BOTTOM w0.076: 248.33,67.29 248.31,67.29 248.26,67.24 247.7,67.24 U2.N2
  BOTTOM w0.104: v2(115.67,50.98) 115.67,50.75 115.56,50.65 115.31,50.65 115.21,50.75 115.21,51.26 115.1,51.37 113.65,51.37 109.06,55.96 v2(108.55,55.96) 104.38,55.96 103.96,55.53 103.96,54.8 104.33,54.43 105.02,54.43 105.27,54.67 JSSD1.55 ; v3(249.4,67.52) 249.4,67.75 249.52,67.87 249.76,67.87 249.88,67.75 249.88,67.22 249.7,67.04 248.86,67.04 248.61,67.29 248.33,67.29
CK_PCIE_SSD2_N: length 181.9
  IN05 w0.114: v2(124.28,55.07) 124.44,54.91 124.44,54.33 125.03,53.74 149.85,53.74 153.4,57.29 186.6,57.29 187.93,58.61 194.9,58.61 195.21,58.3 212.26,58.3 220.59,66.63 220.59,72.93 224.05,76.38 230.63,76.38 232.24,74.77 232.24,74.01 233.9,72.34 234.66,72.34 235.35,71.66 235.35,67.47 235.8,67.02 238.59,67.02 239.15,66.46 239.88,66.46 240.57,67.15 241.3,67.15 241.39,67.05 242.15,67.05 242.62,67.53 242.62,68.91 243.5,69.79 245.6,69.79 246.09,70.29 v3(246.09,71.38)
  BOTTOM w0.104: U2.D5 246.37,71.74 246.37,71.47 246.28,71.38 v3(246.09,71.38) ; JSSD2.53 106.75,78.54 106.87,78.66 107.06,78.66 107.67,78.06 109.83,78.06 110.84,77.04 110.84,75.01 115.54,70.31 v2(115.54,70.06) 115.54,63.98 117.34,62.18 118.84,62.18 124.68,56.34 124.68,55.66 124.58,55.55 124.25,55.55 124.12,55.43 124.12,55.22 v2(124.27,55.07)
CK_PCIE_SSD2_P: length 181.9
  IN05 w0.114: v2(125.09,55.07) 124.81,55.07 124.71,54.97 124.71,54.44 125.14,54.01 149.74,54.01 153.29,57.55 186.49,57.55 187.82,58.88 195.01,58.88 195.32,58.57 212.15,58.57 220.33,66.74 220.33,73.04 223.94,76.65 230.74,76.65 232.51,74.88 232.51,74.12 234.01,72.61 234.78,72.61 235.62,71.77 235.62,67.58 235.91,67.29 238.7,67.29 239.26,66.73 239.77,66.73 240.46,67.42 241.41,67.42 241.5,67.32 242.03,67.32 242.35,67.64 242.35,69.02 243.39,70.06 245.49,70.06 245.83,70.4 245.83,71.09 245.59,71.33 245.33,71.33 245.21,71.2 v3(245.21,71.07)
  BOTTOM w0.104: JSSD2.55 106.75,79.04 106.87,78.92 107.17,78.92 107.77,78.31 109.93,78.31 111.1,77.15 111.1,75.12 115.8,70.42 v2(115.8,68.79) 115.8,64.09 117.44,62.44 118.95,62.44 124.94,56.45 124.94,55.22 v2(125.09,55.07) ; U2.E6 245.66,71.07 v3(245.21,71.07)
CK_PEG1_N: length 89.8
  IN05 w0.114: v3(235.4,130.99) 235.53,130.86 235.83,130.86 235.93,130.97 235.93,131.3 235.83,131.4 235.11,131.4 235.02,131.49 235.02,131.65 235.15,131.78 236.29,131.78 236.94,131.13 238.36,131.13 238.62,130.88 243.57,130.88 243.75,130.7 243.75,121.04 242.53,119.82 242.53,118.59 243.03,118.08 243.03,116.89 243.62,116.3 243.62,112.49 243.92,112.19 243.92,109.28 243.17,108.53 243.17,105.49 242.87,105.18 241.98,105.18 240.62,103.83 240.62,87.52 241.4,86.75 241.4,84.77 245.83,80.33 248.14,80.33 249.02,79.45 249.51,78.96 249.51,71.23 246.35,68.07 246.35,67.39 246.86,66.88 246.86,66.5 246.45,66.09 245.53,66.09 245.26,66.37 245.26,66.68 245.41,66.83 245.56,66.83 v3(245.64,66.75)
  BOTTOM w0.104: G2.BM27 236.04,131.37 236.21,131.19 236.21,131.07 236.14,130.99 v3(235.4,130.99) ; U2.N7 245.2,67.19 v3(245.64,66.75)
CK_PEG1_P: length 89.9
  IN05 w0.114: v3(234.64,130.97) 234.75,131.08 234.75,131.76 235.04,132.05 236.4,132.05 237.05,131.4 238.47,131.4 238.73,131.14 243.68,131.14 244.01,130.81 244.01,120.93 242.79,119.71 242.79,118.7 243.3,118.19 243.3,117 243.88,116.41 243.88,112.6 244.19,112.3 244.19,109.17 243.44,108.42 243.44,105.38 242.98,104.92 242.09,104.92 240.89,103.72 240.89,87.63 241.66,86.86 241.66,84.88 245.94,80.6 248.25,80.6 249.2,79.64 249.78,79.07 249.78,71.12 246.62,67.96 246.62,67.5 247.12,66.99 247.12,66.39 246.56,65.83 245.42,65.83 244.99,66.26 244.99,66.64 v3(244.88,66.75)
  BOTTOM w0.104: G2.BM26 235.8,130.58 235.02,130.58 v3(234.64,130.97) ; v3(244.88,66.75) 244.88,66.81 244.44,67.24 U2.N8
CK_REQ_CR_N: length 105.4
  IN03 w0.091: v2(302.39,36.2) 300.99,37.59 299.54,37.59 297.51,39.62 297.51,40.39 296.67,41.22 294.77,41.22 294.13,41.86 294.13,46.66 v2(293.97,46.82)
  IN05 w0.091: v2(257.4,49.36) 257.99,49.95 257.99,55.38 261.94,59.34 264.76,59.34 265.65,58.45 266.11,58.45 266.34,58.22 266.34,55.81 265.4,54.87 265.4,50.12 266.99,48.52 272.71,48.52 274.92,46.31 277.08,46.31 279.62,43.77 282.42,43.77 283.43,44.78 285.34,44.78 285.72,44.4 288.39,44.4 291.31,47.32 293.47,47.32 v2(293.97,46.82)
  IN08 w0.091: v3(235.05,49.1) 235.17,49.1 235.55,48.72 239.74,48.72 240.13,48.34 243.3,48.34 243.68,48.72 243.68,49.1 243.94,49.36 244.44,49.36 244.53,49.27 248,49.27 248.04,49.23 252.7,49.23 252.88,49.05 257.09,49.05 v2(257.4,49.36)
  BOTTOM w0.076: 235.81,51.39 236.16,51.74 U2.BD25
  BOTTOM w0.097: RP2.5 233.91,48.35 234.66,49.1 v3(235.05,49.1) 235.05,49.61 235.66,50.22 235.66,51.24 235.81,51.39 ; v2(302.39,36.2) 302.39,36.32 301.53,37.18 JIO1.18
CK_REQ_LAN_N: length 239.1
  TOP w0.097: R277.1 49.37,69.93 v2(48.1,71.2) 48.38,71.48 50.03,71.48 50.27,71.72 Q35.6
  IN03 w0.091: v2(45.56,51.01) 46.86,49.71 55.31,49.71 56.36,50.75 58.52,50.75 63.98,56.21 73.12,56.21 73.25,56.09 76.8,56.09 77.31,55.58 86.33,55.58 88.82,58.07 103.68,58.07 106.39,60.79 124.43,60.79 125.7,59.52 130.65,59.52 132.3,57.86 156.43,57.86 157.19,57.1 189.2,57.1 191.23,55.07 214.88,55.07 219.46,50.5 220.69,50.5 224,47.2 234.66,47.2 236.32,48.85 236.32,49.36 v3(235.93,49.74)
  IN10 w0.091: v2(45.56,51.01) 44.8,51.77 44.8,52.28 45.31,52.78 45.31,60.91 44.55,61.67 44.55,66.75 44.29,67.01 44.29,70.18 45.82,71.71 47.59,71.71 v2(48.1,71.2)
  BOTTOM w0.097: U2.BE25 236.16,49.96 v3(235.93,49.74) 235.52,49.32 235.52,49.01 235.17,48.67 234.61,48.67 234.41,48.47 RP2.6
CK_REQ_PEG1_N: length 180.9
  IN08 w0.091: v2(206.6,133.68) 205.58,132.67 205.58,124.92 205.07,124.41 205.07,121.11 207.87,118.32 208.95,118.32 214.41,112.86 215.11,112.86 216.12,111.84 216.12,107.01 215.26,106.15 213.21,106.15 209.98,102.91 209.98,100.23 209.11,99.37 209.11,95.3 206.65,92.85 206.65,78 207.87,76.79 210.28,76.79 211.3,75.77 218.54,75.77 220.57,73.74 220.57,70.44 222.22,68.79 224.76,68.79 228.44,65.1 233.52,65.1 233.9,65.48 240.89,65.48 241.27,65.1 245.97,65.1 246.98,66.12 247.87,66.12 248.76,67.01 251.68,67.01 252.19,67.52 252.19,69.04 253.97,70.82 257.14,70.82 258.54,69.42 258.54,61.55 259.18,60.91 259.18,52.02 256.51,49.36 255.11,49.36 255.06,49.3 253.26,49.3 253.09,49.47 247.73,49.47 247.72,49.46 245.71,49.46 245.56,49.61 243.81,49.61 243.63,49.43 240.56,49.43 240.25,49.74 239.11,49.74 238.6,50.24 237.97,50.24 237.59,49.86 v3(236.85,49.86)
  BOTTOM w0.076: U2.BC24 236.85,52.25 237.08,52.02 237.08,51.77 237.2,51.64 237.33,51.64 237.46,51.51 237.46,50.5 236.85,49.89 v3(236.85,49.86)
  BOTTOM w0.097: Q13.6 206.21,133.29 v2(206.6,133.68) 206.98,133.68 207.28,133.38 R601.2 ; v3(236.85,49.86) 236.85,49.38 235.86,48.39 235.73,48.39 235.41,48.07 RP2.8
CK_REQ_SSD1_N: length 189.5
  TOP w0.097: v3(232.63,52.91) 232.63,52.1 230.98,50.45 R304.2
  IN03 w0.091: v2(96.87,32.46) 96.87,32.08 97,31.96 98.77,31.96 98.9,32.08 108.46,32.08 114.51,38.13 117.35,38.13 119.7,40.49 119.7,42.72 121.92,44.94 134.31,44.94 v2(139.16,40.08)
  IN10 w0.091: v2(96.87,32.46) 97.29,32.88 97.29,39.8 96.36,40.72 96.36,54.99 v2(96.49,55.12) ; v2(139.16,40.08) 139.16,41.68 148.87,51.39 168.88,51.39 170.15,52.66 174.59,52.66 175.23,53.29 175.23,53.61 176.18,54.56 186.43,54.56 187.88,56.01 194.99,56.01 195.7,56.72 203.8,56.72 204.44,57.36 217.39,57.36 218.28,58.25 220.91,58.25 223.83,55.32 226.92,55.32 227.3,54.94 230.09,54.94 230.98,54.05 231.49,54.05 v3(232.63,52.91)
  BOTTOM w0.097: U2.BC32 232.75,52.79 v3(232.63,52.91) ; v2(96.49,55.12) 96.46,55.15 R512.2 95.35,55.15 95.27,55.07 R479.2 94.79,54.51 94.71,54.44 94.22,54.44 Q9.6
CK_REQ_SSD2_N: length 165.6
  IN03 w0.091: v2(97.25,61.67) 97.5,61.93 111.86,61.93 112.62,61.17 124.56,61.17 125.83,59.9 131.92,59.9 133.7,58.12 156.56,58.12 156.94,57.74 190.21,57.74 192.25,55.71 214.6,55.71 219.55,50.75 220.82,50.75 224.12,47.45 234.54,47.45 235.93,48.85 v3(235.93,49.1)
  IN10 w0.091: v2(97.25,61.67) 96.82,61.67 95.73,60.58 v2(95.73,50.88)
  BOTTOM w0.097: v2(95.73,50.88) R508.2 R485.2 95.04,52.58 Q9.3 ; RP2.7 234.91,48.03 235.93,49.05 v3(235.93,49.1) 236.44,49.61 236.44,52.53 236.67,52.76 U2.BB24
CK_REQ_TBT_N: length 267.3
  IN05 w0.091: v2(114.22,35.51) 112.18,35.51 111.25,34.59 100.33,34.59 96.14,38.78 96.14,39.54 95.09,40.59 87.22,40.59 85.57,38.94 71.09,38.94 67.79,42.24 60.93,42.24 v2(58.9,40.21)
  IN08 w0.091: v2(114.22,35.51) 113.63,36.1 113.63,42.42 119.96,48.75 168.85,48.75 171.55,46.05 190.82,46.05 193.67,43.21 199.54,43.21 202.53,46.21 213.51,46.21 216.78,42.93 222.53,42.93 223.62,44.02 227.71,44.02 230.73,47.04 230.73,47.45 v3(231.36,48.09)
  IN10 w0.091: v2(61.56,90.03) 61.56,90 61.18,89.61 61.18,84.03 59.91,82.76 59.91,74.5 60.29,74.12 60.29,65.01 61.18,64.12 61.18,54.94 62.71,53.42 67.79,53.42 69.44,51.77 69.44,49.25 65.79,45.59 61.34,45.59 59.56,43.81 59.56,40.88 v2(58.9,40.21)
  BOTTOM w0.097: R2067.1 61.09,90.5 v2(61.56,90.03) ; U2.BD32 232.75,51.86 232.25,51.36 232.25,50.66 231.36,49.77 v3(231.36,48.09) 231.36,47.91 R309.2
CK_REQ_TBT_N_R: length 5.8
  BOTTOM w0.076: U2005.AC5 56.76,89.28
  BOTTOM w0.097: R2066.1 R2067.2 58.75,90.5 v1(58.53,90.72) 58.29,90.49 58.29,89.52 58.12,89.35 56.84,89.35 56.76,89.28
CK_REQ_WLAN_N: length 78.6
  TOP w0.097: R457.1 266.58,77.29 Q8.6 267.82,77.54 268.21,77.93 269.59,77.93 269.97,77.55 269.97,73.8 272.19,71.58 274.55,71.58 275.81,70.31 275.81,65.48 v2(276.19,65.1) ; v3(235.93,55.83) 236.98,56.87 R787.2
  IN05 w0.091: v2(276.19,65.1) 275.3,64.21 260.59,64.21 258.08,61.7 258.08,59.92 257.43,59.26 257.27,59.26 v2(256.64,58.63)
  IN08 w0.091: v2(256.64,58.63) 257.4,57.86 257.4,53.55 256.89,53.04 256.13,53.04 254.48,54.69 253.59,54.69 252.84,53.94 249.89,53.94 249.27,53.32 249.27,53.29 248.56,52.58 248.18,52.58 247.55,51.95 237.4,51.95 236.44,52.91 236.44,55.32 v3(235.93,55.83)
  BOTTOM w0.097: U2.AT24 236.36,55.53 236.06,55.83 v3(235.93,55.83)
CK_TBT_N: length 263.2
  IN03 w0.114: v3(244.24,64.34) 244.02,64.34 243.79,64.57 243.79,64.73 243.89,64.84 245.11,64.84 245.71,64.23 245.71,62.82 247.23,61.31 247.23,59.66 247.73,59.15 247.73,52.51 247.04,51.82 236.57,51.82 235.22,50.47 231.46,50.47 230.85,49.86 230.85,48.97 230.47,48.59 229.59,48.59 229.06,49.11 224.11,49.11 219.79,53.43 218.27,53.43 214.96,56.73 196.81,56.73 194.91,58.63 157.58,58.63 157.07,59.13 134.59,59.13 132.56,61.17 127.22,61.17 126.07,62.32 113.24,62.32 112.73,62.83 96.02,62.83 92.2,59.01 76.17,59.01 75.66,58.5 70.07,58.5 69.58,58 63.35,58 57.88,52.53 52.75,52.53 52.47,52.25 51.39,52.25 51.25,52.39 51.25,52.57 51.38,52.7 v2(51.67,52.7)
  IN10 w0.114: v2(51.67,52.7) 51.46,52.49 51.46,52.34 51.57,52.24 52.26,52.24 52.41,52.39 52.41,54.18 51.78,54.8 51.78,56.97 52.92,58.1 52.92,61.53 53.96,62.58 56.12,62.58 56.73,63.18 56.73,65.34 56.98,65.6 56.98,66.26 56.6,66.64 56.6,69.69 56.09,70.2 56.09,73.75 52.53,77.31 52.53,82.47 v1(52.52,82.48)
  BOTTOM w0.104: U2005.T19 52.85,82.81 v1(52.52,82.48) ; U2.W10 v3(244.24,64.34)
CK_TBT_P: length 263.2
  IN03 w0.114: v2(51.66,51.77) 51.81,51.92 52.52,51.92 52.86,52.26 57.99,52.26 63.46,57.74 69.69,57.74 70.18,58.23 75.77,58.23 76.28,58.74 92.31,58.74 96.13,62.56 112.62,62.56 113.13,62.06 125.96,62.06 127.11,60.9 132.45,60.9 134.48,58.87 156.96,58.87 157.47,58.36 194.8,58.36 196.7,56.47 214.85,56.47 218.15,53.17 219.68,53.17 224,48.85 228.95,48.85 229.48,48.32 230.58,48.32 231.12,48.86 231.12,49.75 231.57,50.21 235.33,50.21 236.68,51.55 247.15,51.55 248,52.4 248,59.26 247.49,59.77 247.49,61.42 246.18,62.73 245.98,62.93 245.98,64.34 245.22,65.1 243.78,65.1 243.52,64.84 243.52,64.38 v3(243.48,64.34)
  IN10 w0.114: v2(51.66,51.77) 51.86,51.97 52.37,51.97 52.67,52.28 52.67,54.29 52.05,54.91 52.05,56.86 53.18,57.99 53.18,61.42 54.07,62.31 56.23,62.31 56.99,63.07 56.99,65.23 57.25,65.48 57.25,66.37 56.86,66.75 56.86,69.8 56.36,70.31 56.36,73.86 52.8,77.42 52.8,82.11 v1(53.18,82.49)
  BOTTOM w0.104: U2005.V19 v1(53.18,82.49) ; U2.W11 v3(243.48,64.34)
CK_WLAN_N: length 28.9
  IN10 w0.114: v2(268.1,74.12) 268.31,73.91 268.31,73.68 267.63,72.99 264.78,72.99 263,71.21 258.52,71.21 258.27,71.47 251.03,71.47 250.54,71.96 247.59,71.96 247.41,71.79 247.16,71.79 v3(246.98,71.96)
  BOTTOM w0.104: v3(246.98,71.96) 247.06,71.88 U2.D3 ; JWLAN1.49 268.75,77.96 268.87,77.84 268.87,77.45 268.32,76.89 268.32,74.33 v2(268.1,74.12)
CK_WLAN_P: length 28.9
  IN10 w0.114: v2(268.79,74.12) 268.58,73.91 268.58,73.57 267.74,72.72 264.89,72.72 263.11,70.95 258.41,70.95 258.16,71.2 250.92,71.2 250.43,71.7 247.7,71.7 247.54,71.54 v3(247.54,71.35)
  BOTTOM w0.104: JWLAN1.47 269.25,77.96 269.13,77.84 269.13,77.34 268.57,76.79 268.57,74.33 v2(268.79,74.12) ; v3(247.54,71.35) 247.49,71.3 247.49,70.95 U2.F2
CK_XDP_N: length 6.9
  BOTTOM w0.104: U2.L1 248.71,67.95 249.21,68.46 v2(249.47,68.46) 252.13,68.46 252.87,69.2 253.87,69.2 253.97,69.29 253.97,69.42 TP55.1
CK_XDP_P: length 6.9
  BOTTOM w0.104: U2.L2 247.69,67.77 247.69,67.77 247.76,67.7 248.82,67.7 249.32,68.2 v2(252.01,68.2) 252.24,68.2 252.98,68.94 253.71,68.94 TP54.1
CLK_REQ_PEG_N_R: length 34.8
  BOTTOM w0.097: G2.BL26 236.45,130.67 236.04,130.25 224.18,130.25 220.57,133.86 209.13,133.86 208.68,133.41 208.68,132.77 R601.1 208.38,132.11 v1(208.38,131.27) 207.94,130.84 R600.2 206.66,131.53 Q13.1
CLKA0: length 35.4
  TOP w0.127: R774.2 248.88,168.14 249.1,168.37 249.76,168.37 v3(250.06,168.07)
  IN10 w0.127: v3(252.51,170.75) 252.29,170.75 251.89,171.15 251.52,171.15 250.51,170.14 250.51,168.4 250.18,168.07 v3(250.06,168.07) 250.06,168.21 249.84,168.43 249.7,168.43 249.57,168.3 249.57,167.75 250.2,167.13 250.2,161.72 253.34,158.58 253.34,150.06 253.15,149.87 253.15,148.46 253.87,147.75 253.87,144.17 253.58,143.88 253.3,143.88 v3(253.09,143.67)
  BOTTOM w0.127: v3(252.51,170.75) 252.67,170.75 252.91,170.99 U48.J12 ; G2.AG45 253.39,143.83 253.23,143.67 v3(253.09,143.67)
CLKA0_N: length 35.4
  TOP w0.127: v3(250.06,168.94) 249.78,168.67 249.1,168.67 248.88,168.89 R2219.2
  IN10 w0.127: v3(253.09,144.37) 253.3,144.16 253.46,144.16 253.59,144.28 253.59,147.63 252.87,148.35 252.87,149.99 253.06,150.17 253.06,158.47 249.92,161.61 249.92,167.01 249.3,167.63 249.3,168.42 249.58,168.71 249.82,168.71 v3(250.06,168.94) 250.23,169.12 250.23,170.26 251.4,171.43 252.01,171.43 252.29,171.14 252.91,171.14 v3(253.31,170.75)
  BOTTOM w0.122: U48.J11 v3(253.31,170.75)
  BOTTOM w0.127: G2.AG46 v3(253.09,144.37)
CLKA1: length 36.3
  TOP w0.127: R2218.2 246.05,168.14 245.84,168.36 245.45,168.36 v3(245.17,168.08)
  IN03 w0.127: v3(242.47,170.75) 242.66,170.75 243.06,171.15 243.88,171.15 244.72,170.32 244.72,168.44 245.07,168.08 v3(245.17,168.08) 245.22,168.13 245.22,168.38 245.37,168.53 245.6,168.53 245.79,168.34 245.79,162.65 251.16,157.28 251.16,147.78 251.4,147.54 251.4,144.58 251.19,144.37 v3(250.99,144.37)
  BOTTOM w0.122: U2022.J12 242.07,170.84
  BOTTOM w0.127: 242.07,170.84 242.17,170.75 v3(242.47,170.75) ; G2.AK46 251.35,144.73 251.56,144.73 251.66,144.62 251.66,144.36 251.59,144.29 251.07,144.29 v3(250.99,144.37)
CLKA1_N: length 36.3
  TOP w0.127: v3(245.17,168.95) 245.46,168.67 245.83,168.67 246.05,168.89 R2215.2
  IN03 w0.127: v3(241.67,170.75) 242.07,171.15 242.67,171.15 242.95,171.43 244,171.43 244.99,170.43 244.99,169.13 v3(245.17,168.95) 245.31,168.81 245.72,168.81 246.07,168.46 246.07,162.77 251.44,157.39 251.44,147.89 251.68,147.66 251.68,144.36 v3(250.99,143.67)
  BOTTOM w0.122: U2022.J11 v3(241.67,170.75)
  BOTTOM w0.127: G2.AK45 v3(250.99,143.67)
CLKB0: length 42.3
  TOP w0.127: R2223.2 291.18,159.01 291.41,158.78 291.41,158.58 v3(291.13,158.29)
  IN10 w0.127: v3(266.39,142.17) 266.6,141.96 266.6,141.54 266.92,141.21 267.43,141.21 267.7,141.49 270.48,141.49 271.06,142.07 271.06,142.65 274.58,146.17 275.56,146.17 277.26,147.86 277.26,148.85 287.34,158.93 291.42,158.93 291.54,158.81 291.54,158.42 291.41,158.29 v3(291.13,158.29) 291.85,157.57 293.16,157.57 294.18,156.56 294.18,156.01 293.7,155.53 v3(293.7,155.34)
  BOTTOM w0.122: U2023.J12 294.1,155.13 293.9,155.34 v3(293.7,155.34) ; v3(266.39,142.17) G2.H42
CLKB0_N: length 42.3
  TOP w0.127: R2221.2 291.94,159.01 291.71,158.78 291.71,158.58 v3(292,158.29)
  IN10 w0.127: v3(293.7,154.54) 294.1,154.94 294.1,155.54 294.46,155.89 294.46,156.67 293.28,157.85 292.44,157.85 v3(292,158.29) 291.82,158.47 291.82,158.93 291.54,159.21 287.22,159.21 276.98,148.96 276.98,147.98 275.45,146.45 274.46,146.45 270.78,142.77 270.78,142.18 270.36,141.77 267.59,141.77 267.31,141.49 267.04,141.49 266.87,141.66 266.87,141.96 v3(267.09,142.17)
  BOTTOM w0.122: U2023.J11 v3(293.7,154.54) ; G2.G42 v3(267.09,142.17)
CLKB1: length 38.9
  TOP w0.127: v3(280.63,168.36) 280.93,168.66 281.26,168.66 281.49,168.44 R2220.2
  IN03 w0.127: v3(277.53,170.75) 277.64,170.64 277.78,170.64 277.91,170.76 277.91,170.89 278.19,171.17 279.01,171.17 280.01,170.18 280.01,168.99 v3(280.63,168.36) 280.63,168.62 280.82,168.81 281.1,168.81 281.21,168.7 281.21,164.89 278.84,162.51 278.84,156.94 272.45,150.56 272.45,147.01 271.4,145.96 269.94,145.96 269.34,145.37 268.68,145.37 v3(268.38,145.07)
  BOTTOM w0.122: v3(268.38,145.07) 268.38,145.26 268.28,145.37 G2.F47 ; U55.J12 277.13,170.91 277.29,170.75 v3(277.53,170.75)
CLKB1_N: length 38.9
  TOP w0.127: R871.2 281.49,169.19 281.26,168.96 280.9,168.96 v3(280.63,169.23)
  IN03 w0.127: v3(269.05,144.94) 269.32,144.94 270.05,145.68 271.52,145.68 272.73,146.9 272.73,150.45 279.11,156.83 279.11,162.4 281.49,164.77 281.49,168.82 281.08,169.23 v3(280.63,169.23) 280.29,169.58 280.29,170.3 279.13,171.45 278.08,171.45 277.77,171.15 277.13,171.15 v3(276.73,170.75)
  BOTTOM w0.122: v3(269.05,144.94) 269.05,145.1 G2.E47 ; U55.J11 v3(276.73,170.75)
CLKC0: length 33.3
  TOP w0.127: v3(291.25,123.05) 291.54,123.33 291.54,123.71 291.31,123.93 R2226.2
  IN10 w0.127: v3(267.09,123.27) 267.5,122.85 272.41,122.85 272.68,122.58 286.71,122.58 286.97,122.84 290.33,122.84 290.98,123.49 291.53,123.49 291.62,123.39 291.62,123.19 291.48,123.05 v3(291.25,123.05) 291.25,122.95 291.81,122.39 293.25,122.39 294.28,121.36 294.28,120.93 293.83,120.47 v3(293.83,120.28)
  BOTTOM w0.127: v3(267.09,123.27) 267.09,123.13 267.24,122.97 G2.G15 ; v3(293.83,120.28) 293.83,120.07 294.01,119.88 U2025.J12
CLKC0_N: length 33.3
  TOP w0.127: v3(292.12,123.05) 291.84,123.33 291.84,123.71 292.06,123.93 R2227.2
  IN10 w0.127: v3(267.63,123.42) 267.92,123.13 272.52,123.13 272.79,122.86 286.59,122.86 286.85,123.12 290.22,123.12 290.86,123.77 291.65,123.77 291.9,123.51 291.9,123.27 v3(292.12,123.05) 292.5,122.67 293.37,122.67 294.56,121.48 294.56,120.81 294.23,120.47 294.23,119.88 v3(293.83,119.48)
  BOTTOM w0.122: G2.F15 v3(267.63,123.42)
  BOTTOM w0.127: U2025.J11 v3(293.83,119.48)
CLKC1: length 35.5
  TOP w0.127: R903.2 291.31,126.67 291.54,126.9 291.54,127.18 v3(291.25,127.46)
  IN03 w0.127: v3(266.39,127.47) 266.21,127.47 266.07,127.33 266.07,126.99 266.19,126.87 267.15,126.87 267.34,127.05 281.46,127.05 281.52,127 291.47,127 291.64,127.17 291.64,127.29 291.46,127.46 v3(291.25,127.46) 291.88,128.1 293.24,128.1 294.25,129.11 294.25,129.69 293.83,130.12 v3(293.83,130.32)
  BOTTOM w0.122: v3(266.39,127.47) 266.34,127.42 266.34,126.87 266.42,126.79 266.71,126.79 266.8,126.88 266.8,127.06 G2.H21 ; v3(293.83,130.32) 294.03,130.32 294.23,130.52 U2024.J12
CLKC1_N: length 35.2
  TOP w0.127: v3(292.12,127.46) 291.84,127.18 291.84,126.9 292.06,126.67 R901.2
  IN03 w0.127: v3(293.83,131.12) 294.23,130.72 294.23,130.11 294.53,129.81 294.53,129 293.36,127.82 292.47,127.82 v3(292.12,127.46) 291.92,127.26 291.92,127.05 291.59,126.72 281.4,126.72 281.35,126.77 267.46,126.77 267.27,126.59 266.07,126.59 265.79,126.87 265.79,127.36 v3(265.69,127.47)
  BOTTOM w0.122: G2.J21 v3(265.69,127.47) ; U2024.J11 v3(293.83,131.12)
CLKD0: length 35.2
  TOP w0.127: v3(256.15,94.49) 256.43,94.21 256.72,94.21 256.94,94.44 R785.2
  IN03 w0.127: v3(253.27,91.92) 253.47,91.92 253.92,91.47 254.76,91.47 255.58,92.29 255.58,93.92 v3(256.15,94.49) 256.15,94.16 256.22,94.09 256.51,94.09 256.73,94.31 256.73,94.68 255.99,95.42 255.99,100.91 258.77,103.69 258.77,110.88 258.52,111.13 258.52,112.78 257.6,113.7 257.6,116.64 257.69,116.72 257.69,117.82 258,118.13 258.35,118.13 v3(258.58,118.37)
  BOTTOM w0.122: v3(258.58,118.37) 258.47,118.37 258.28,118.18 G2.Y8 ; U2026.J12 253.08,91.52 253.27,91.71 v3(253.27,91.92)
CLKD0_N: length 35.2
  TOP w0.127: R906.2 256.94,93.68 256.72,93.91 256.43,93.91 v3(256.15,93.62)
  IN03 w0.127: v3(258.63,117.69) 258.47,117.85 258.11,117.85 257.97,117.71 257.97,116.61 257.88,116.52 257.88,113.81 258.8,112.9 258.8,111.25 259.05,111 259.05,103.57 256.27,100.8 256.27,95.53 257.01,94.79 257.01,94.19 256.62,93.81 256.33,93.81 v3(256.15,93.62) 255.86,93.33 255.86,92.18 254.87,91.19 253.81,91.19 253.47,91.53 252.86,91.53 v3(252.47,91.92)
  BOTTOM w0.122: v3(258.63,117.69) 258.61,117.69 G2.Y7 ; U2026.J11 v3(252.47,91.92)
CLKD1: length 32.8
  TOP w0.127: v3(260.5,94.49) 260.5,94.44 260.27,94.21 259.98,94.21 259.76,94.44 R916.2
  IN10 w0.127: v3(261.36,118.49) 262.07,117.78 262.07,115.47 261.64,115.04 261.64,113.35 261.33,113.05 261.33,103.47 260.64,102.77 260.64,95.65 260.45,95.46 260.45,94.55 v3(260.5,94.49) 260.62,94.49 261.21,93.91 261.21,92.31 262,91.52 262.84,91.52 263.24,91.92 v3(263.43,91.92)
  BOTTOM w0.122: G2.R8 261.79,118.25 261.55,118.49 v3(261.36,118.49) ; v3(263.43,91.92) 263.43,91.7 263.61,91.52 U60.J12
CLKD1_N: length 32.8
  TOP w0.127: R914.2 259.76,93.68 259.98,93.91 260.27,93.91 260.5,93.67 v3(260.5,93.62)
  IN10 w0.127: v3(264.23,91.92) 263.83,91.51 263.23,91.51 262.96,91.24 261.88,91.24 260.93,92.19 260.93,93.2 v3(260.5,93.62) 260.06,94.06 260.06,95.47 260.36,95.77 260.36,102.88 261.06,103.58 261.06,113.16 261.36,113.47 261.36,115.16 261.79,115.59 261.79,117.36 v3(261.49,117.67)
  BOTTOM w0.122: U60.J11 v3(264.23,91.92) ; G2.R7 v3(261.48,117.67)
CMDA0: length 32.1
  BOTTOM w0.102: G2.Y51 258.28,148.42 258.59,148.72 258.59,149.04 258.42,149.21 258.42,150.92 258.55,151.05
  BOTTOM w0.122: U48.G3 260.51,172.35 261.96,172.35 262.11,172.5 262.79,172.5 264.18,171.11 264.18,156.22 262.57,154.6 259.66,154.6 258.55,153.48 258.55,151.05
CMDA1: length 33
  TOP w0.122: R2195.1 261.52,172.61 v1(261.21,172.29) 260.51,171.59 v3(260.51,171.55)
  BOTTOM w0.102: G2.Y52 258.17,148.98 258.17,151.14 258.26,151.24
  BOTTOM w0.122: U48.J3 v3(260.51,171.55) 260.51,171.55 262.26,171.55 262.33,171.62 262.79,171.62 263.68,170.73 263.68,156.43 262.34,155.09 259.75,155.09 258.26,153.59 258.26,151.24
CMDA2: length 30.4
  TOP w0.122: R2200.1 261.45,170.61 v3(261.31,170.75)
  BOTTOM w0.122: U48.J2 v3(261.31,170.75) 261.31,170.75 262.26,170.75 263.18,169.83 263.18,156.67 262.09,155.58 259.86,155.58 257.9,153.62 257.9,147.15 G2.Y49
CMDA3: length 26.5
  BOTTOM w0.122: U48.L3 260.51,169.95 261.95,169.95 262.67,169.22 262.67,156.98 261.77,156.07 259.97,156.07 257.58,153.68 G2.AA52
CMDA4: length 28.2
  BOTTOM w0.102: 257.28,153.76 257.28,148.7 257.58,148.4 G2.AA51
  BOTTOM w0.122: 257.28,153.76 260.08,156.56 261.48,156.56 262,157.08 262,163.07 261.12,163.96 258.8,163.96 258.12,164.64 258.12,169.96 U48.K5
CMDA5: length 29.7
  BOTTOM w0.102: G2.AA50 257.58,147.63 257.27,147.94 257.27,148.3 257.02,148.55 257.02,153.88
  BOTTOM w0.122: 257.02,153.88 260.19,157.05 260.7,157.05 261.5,157.85 261.5,162.86 260.91,163.45 258.92,163.45 257.85,164.52 257.85,170.24 258.36,170.75 258.91,170.75 U48.K4
CMDA6: length 28.8
  BOTTOM w0.102: 256.77,154.01 256.77,148.55 256.5,148.28 256.5,147.78 G2.AC50
  BOTTOM w0.122: 256.77,154.01 259.74,156.98 259.74,156.98 260.99,158.24 260.99,162.62 260.67,162.95 258.68,162.95 258.38,163.24 258.38,163.64 257.58,164.44 257.58,170.57 258.16,171.15 U48.J5
