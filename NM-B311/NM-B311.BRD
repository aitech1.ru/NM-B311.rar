# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
H_SKTOCC_N: length 3.8
  BOTTOM w0.097: U1.BR33 149.97,153.5 149.61,153.14 149.61,152.89 149.4,152.68 148.1,152.68 TP115.1
H_THRMTRIP_N: length 261.1
  TOP w0.097: C2683.1 v2(300.58,55.32) ; C2683.1 301.43,56.01 Q98.6 ; C2683.1 300.15,56.01 299.56,56.59 v1(299.56,57.1) 299.56,57.74 300.12,58.3 C1329.1 301.09,58.3 301.13,58.25 Q87.3 ; v2(253.71,59.13) 253.71,59.26 253.33,59.64 252.52,59.64 R287.2
  IN03 w0.091: v2(208.63,160.61) 203.8,160.61 201.52,158.32 197.86,158.32 197.73,158.19 196.56,158.19 v2(196.18,158.58) 193.77,156.16 189.96,156.16 189.58,156.54 187.67,156.54 187.42,156.29 187.42,153.5 187.17,153.24 186.79,153.24 186.15,152.61 184.83,152.61 v2(184.68,152.45)
  IN05 w0.091: v2(253.71,59.13) 253.84,59.13 258.16,63.45 258.16,64.6 259.05,65.48 267.05,65.48 267.81,64.72 274.03,64.72 277.21,67.9 278.86,67.9 279.62,67.14 279.62,61.83 280.54,60.91 288.51,60.91 v2(290.29,59.13)
  IN08 w0.091: v2(208.63,160.61) 208.88,160.61 209.65,159.85 209.65,149.43 203.22,143.01 203.22,117.12 204.22,116.13 208.79,116.13 210.97,113.94 210.97,105.27 209.08,103.38 209.08,100.7 208.12,99.74 208.12,95.63 205.71,93.22 205.71,74.37 207.11,72.98 207.11,68.41 213.2,62.31 221.94,62.31 222.19,62.56 226.28,62.56 227.43,61.42 240.38,61.42 240.4,61.44 241.54,61.44 242.16,62.06 246.35,62.06 249.65,65.36 253.33,65.36 254.1,64.6 254.1,59.52 v2(253.71,59.13)
  BOTTOM w0.097: v2(290.29,59.13) 294.1,55.32 v2(300.58,55.32) ; v2(196.18,158.58) 196.11,158.5 R15.1 ; U1.J31 184.94,152.72 v2(184.68,152.45)
H_VCCST_PWRGD: length 302.8
  TOP w0.097: v2(196.69,150.93) 196.69,150.96 195.29,152.35 190.52,152.35 189.96,152.91 R14.1 ; R17.1 185.69,141.13 186.37,141.81 v2(186.37,141.83)
  IN05 w0.091: v2(107.92,32.52) 107.89,32.49 99.56,32.49 97.52,30.45 94.69,30.45 94.55,30.31 85.19,30.31 84.55,29.67 80.87,29.67 80.68,29.85 74.31,29.85 71.42,26.97 65.03,26.97 63.22,28.78 58.01,28.78 57.03,29.76 56.59,29.76 51.08,35.27 51.08,39.14 50.26,39.96 48.48,39.96 v2(47.85,40.59)
  IN08 w0.091: v2(47.34,47.07) 47.34,46.25 46.32,45.24 46.32,41.35 46.96,40.72 47.72,40.72 v2(47.85,40.59) ; v2(114.65,59.77) 115.03,59.77 116.02,58.78 124.76,58.78 125.83,57.71 155.06,57.71 155.59,58.25 166.97,58.25 167.99,59.26 167.99,63.58 166.85,64.72 166.85,65.36 164.07,68.13 164.07,102.46 190.98,129.37 192.12,129.37 192.5,129.75 192.5,130.51 191.99,131.02 190.09,131.02 189.83,131.27 189.83,140.54 188.94,141.43 186.66,141.43 186.37,141.72 v2(186.37,141.83)
  IN10 w0.091: v2(114.65,59.77) 115.03,59.77 118.97,55.83 118.97,55.07 119.86,54.18 119.86,52.28 115.27,47.69 115.27,40.83 107.92,33.48 v2(107.92,32.52) ; v2(186.37,141.83) 186.79,142.24 187.98,142.24 189.33,143.59 189.33,146.26 189.96,146.89 191.36,146.89 195.4,150.93 v2(196.69,150.93)
  BOTTOM w0.097: U58.4 47.03,39.77 v2(47.85,40.59) ; v2(47.34,47.07) 47.64,47.37 R64.2 48.15,48.85 49.12,48.85 49.75,48.21 52.24,48.21 R842.1
H_VCCST_PWRGD_R: length 2.2
  TOP w0.097: R17.2 v2(186.38,139.47)
  BOTTOM w0.097: v2(186.38,139.47) 185.74,139.47 185.34,139.08 U1.H13
HDA_BCLK: length 54
  TOP w0.097: U7.13 284.65,31.41 283.54,31.41 v2(283.43,31.3) ; R131.2 v2(252.83,50.75)
  IN05 w0.091: v2(256.2,42.04) 257.45,42.04 258.93,43.51 263.48,43.51 266.66,40.34 280.77,40.34 281.02,40.59 281.78,40.59 282.16,40.21 282.16,32.08 282.42,31.83 282.9,31.83 v2(283.43,31.3)
  IN10 w0.091: v2(257.02,47.83) 257.02,45.8 257.68,45.14 257.68,44.38 256.76,43.46 256.76,42.6 v2(256.2,42.04)
  BOTTOM w0.097: v2(252.83,50.75) 252.95,50.75 253.38,51.18 254.6,51.18 257.02,48.77 v2(257.02,47.83) ; C339.1 283.56,30.69 283.43,30.81 v2(283.43,31.3)
HDA_BCLK_R: length 8.5
  TOP w0.097: v3(244.75,53.32) 245.15,52.91 246.98,52.91 247.36,52.53 248.76,52.53 249.27,52.02 249.27,51.26 249.78,50.75 v1(250.23,50.75) R131.1
  BOTTOM w0.097: U2.BA9 244.58,53.15 v3(244.75,53.32)
HDA_I2S_SEL: length 2.9
  TOP w0.097: R289.1 TP94.1 282.8,34.67 283.16,34.32 283.74,34.32 283.85,34.21 284.07,34.21 284.07,34.21 U7.6
HDA_JD1: length 1.6
  TOP w0.097: v1(283.1,33.35) 283.16,33.41 U7.8
HDA_JD2: length 47.6
  TOP w0.097: v2(302.89,21.59) 303.45,21.04 R311.2 R312.1 ; U7.9 283.78,33.01 283.69,33.1 283.41,33.1 283.28,32.97 C332.2 R310.1 v2(282.8,33.86)
  IN03 w0.091: v2(282.8,33.86) 282.8,35.13 284.96,37.29 284.96,39.07 285.59,39.7 287.24,39.7 288.51,40.97 293.97,40.97 294.35,40.59 294.35,38.05 294.86,37.54 298.16,37.54 300.2,35.51 300.2,25.3 302.89,22.61 v2(302.89,21.59)
HDA_RST_N: length 58.1
  TOP w0.097: v2(284.45,28.91) 285.1,29.56 285.31,29.56 285.53,29.79 U7.15 ; v2(245.84,47.58) 245.97,47.45 245.97,44.28 246.86,43.39 v1(247.36,43.39) 250.79,43.39 252.75,41.43 254.71,41.43 v2(255.24,40.9)
  IN05 w0.091: v2(255.24,40.9) 255.7,40.44 257,40.44 259.19,42.63 263.11,42.63 266.29,39.45 275.43,39.45 276.19,38.69 279.5,38.69 279.88,39.07 280.64,39.07 281.02,38.69 281.02,30.18 282.29,28.91 v2(284.45,28.91)
  BOTTOM w0.097: R135.2 246.48,48.21 v2(245.84,47.58)
HDA_RST_N_R: length 5.7
  BOTTOM w0.097: R135.1 247.39,49.1 v1(247.24,49.25) 245.36,49.25 244.6,50.02 U2.BD8
HDA_SDIN: length 65.1
  TOP w0.097: R307.2 283.69,26.75 v2(283.31,26.37)
  IN05 w0.091: v2(283.31,26.37) 280.63,29.04 280.63,31.46 280.04,32.04 280.04,37.03 278.61,38.47 275.81,38.47 275.17,39.11 266.16,39.11 262.85,42.41 259.6,42.41 257.37,40.19 254.91,40.19 v2(254.2,40.9)
  IN08 w0.091: v3(245.21,50.75) 251.82,50.75 252.28,51.21 255.92,51.21 v2(256.38,50.75)
  IN10 w0.091: v2(254.2,40.9) 254.2,41.41 254.63,41.84 254.63,45.58 255.87,46.82 255.87,50.24 v2(256.38,50.75)
  BOTTOM w0.097: U2.BE7 245.1,50.86 v3(245.21,50.75)
HDA_SDIN_R: length 4.6
  TOP w0.097: v1(283.69,28.91) R307.1 284.12,28.4 284.7,28.4 284.96,28.65 284.96,29.01 285.29,29.34 285.64,29.34 285.93,29.63 U7.16
HDA_SDOUT: length 58.3
  TOP w0.097: v2(254.2,42.02) 253.8,42.42 253.8,46.35 252.37,47.78 R167.1 252.11,48.85 251.3,48.85 251.17,48.97 v1(250.79,48.97) 250.16,48.97 249.27,48.09 248.2,48.09 247.95,48.34 R134.2 ; v2(285.46,28.91) 285.64,28.91 286.33,29.6 U7.17
  IN05 w0.091: v2(285.46,28.91) 285.46,29.67 284.45,30.69 282.16,30.69 281.78,31.07 281.78,38.94 280.89,39.83 279.62,39.83 279.07,39.28 276.44,39.28 275.68,40.04 266.53,40.04 263.31,43.26 258.98,43.26 257.28,41.56 254.65,41.56 v2(254.2,42.02)
HDA_SDOUT_R: length 6.5
  TOP w0.097: R134.1 246.22,48.97 245.84,49.36 v3(245.84,49.86) 245.84,50.45 R2286.2
  BOTTOM w0.097: U2.BB7 245.02,52.35 244.82,52.15 244.82,50.57 245.15,50.24 245.46,50.24 v3(245.84,49.86)
HDA_SPKR: length 88.7
  TOP w0.097: v2(283.31,25.48) 283.43,25.61 R313.2 ; v3(233.78,48.97) 233.27,48.47 232.38,48.47 231.87,47.96 R164.1
  IN08 w0.091: v2(278.35,46.05) 274.42,46.05 272.89,47.58 267.91,47.58 267.56,47.93 263.78,47.93 263.37,48.34 256.51,48.34 256.1,47.93 248,47.93 247.59,48.34 244.21,48.34 243.7,47.83 239.87,47.83 239.49,48.21 234.16,48.21 233.78,48.59 v3(233.78,48.97)
  IN10 w0.091: v2(278.35,46.05) 277.72,46.05 273.79,42.12 273.79,39.95 274.5,39.24 275.26,39.24 275.81,38.69 279.11,38.69 279.62,39.2 282.92,39.2 283.31,38.81 283.31,37.93 284.7,36.53 284.7,30.05 282.42,27.77 282.42,26.37 v2(283.31,25.48)
  BOTTOM w0.097: v3(233.78,48.97) 234.03,48.97 235.43,50.37 235.43,51.67 U2.BD26
HDA_SYNC: length 60.2
  TOP w0.097: v2(283.43,30.18) 283.43,30.56 283.88,31.01 284.32,31.01 284.32,31.01 U7.14 ; v2(254.22,47.45) 254.22,43.01 254.71,42.52 254.71,41.86 255.06,41.51 255.65,41.51 v2(256.25,40.9)
  IN05 w0.091: v2(256.25,40.9) 257.04,40.9 259.06,42.92 263.23,42.92 266.41,39.74 275.55,39.74 276.32,38.98 279.28,38.98 279.73,39.43 280.79,39.43 281.38,38.84 281.38,30.33 282.29,29.41 283.06,29.41 283.43,29.79 v2(283.43,30.18)
  IN08 w0.091: v2(244.82,47.58) 245.33,48.09 247.49,48.09 248.76,46.82 253.46,46.82 254.1,47.45 v2(254.22,47.45)
  BOTTOM w0.097: R132.2 244.7,47.7 v2(244.82,47.58)
HDA_SYNC_R: length 4.3
  BOTTOM w0.097: R132.1 v1(244.67,49.23) 244.32,49.58 244.32,51.51 244.12,51.71 U2.BD9
HDMI_CEC: length 4.2
  TOP w0.097: JDP1.14 11.82,159.3 v2(11.65,159.46)
  BOTTOM w0.097: v2(11.65,159.46) 11.98,159.13 R807.1 v1(13.89,159.13)
HDMI_CLK_DN: length 101.3
  TOP w0.081: CM6.3 19.19,133.03 19.46,132.76 19.71,132.76 v3(19.95,133)
  IN10 w0.081: v2(76.55,82.63) 76.37,82.81 69.63,82.81 68.53,83.9 66.19,83.9 63.6,86.49 63.6,90.19 62.5,91.29 59.25,91.29 58.13,92.41 55.34,92.41 54.96,92.79 51.69,92.79 50.27,94.21 50.27,96.24 46.86,99.66 40.73,99.66 20.79,119.59 16.81,119.59 14.84,121.57 14.84,130.52 17.17,132.85 19.8,132.85 v3(19.95,133)
  BOTTOM w0.081: U2019.25 79.69,82.8 79.6,82.89 78.58,82.89 78.48,82.79 76.71,82.79 v2(76.55,82.63)
HDMI_CLK_DP: length 101.3
  TOP w0.081: v3(19.95,132.21) 19.71,132.45 19.46,132.45 19.19,132.18 CM6.2
  IN10 w0.081: v3(19.95,132.21) 20.15,132.21 20.25,132.3 20.25,132.5 20.15,132.6 17.27,132.6 15.08,130.41 15.08,121.67 16.91,119.84 20.89,119.84 40.83,99.9 46.96,99.9 50.51,96.35 50.51,94.31 51.79,93.04 55.06,93.04 55.44,92.66 58.24,92.66 59.35,91.54 62.61,91.54 63.85,90.29 63.85,86.59 66.3,84.15 68.63,84.15 69.73,83.05 76.35,83.05 v2(76.56,83.26)
  BOTTOM w0.081: v2(76.56,83.26) 76.72,83.1 78.36,83.1 78.45,83.2 79.6,83.2 79.69,83.3 U2019.26
HDMI_CLK_R_DN: length 4
  TOP w0.081: CM6.4 17.03,133.03 16.72,132.72 15.97,132.72 15.91,132.78 D26.10 D26.1 14.82,132.78 14.78,132.75 13.91,132.75 R2279.1
HDMI_CLK_R_DP: length 4
  TOP w0.081: CM6.1 17.03,132.18 16.79,132.41 16.1,132.41 15.96,132.28 D26.9 D26.2 14.81,132.28 14.65,132.44 13.78,132.44 R2278.1
HDMI_CLK_RS_DN: length 3.6
  TOP w0.081: JHDMI1.12 10.71,132.75 11.06,132.4 11.4,132.4 11.79,132.79 12.34,132.79 R2279.2
HDMI_CLK_RS_DP: length 3.6
  TOP w0.081: R2278.2 12.37,132.48 11.92,132.48 11.53,132.09 11.06,132.09 10.71,131.75 JHDMI1.10
HDMI_DATA0_DN: length 99.6
  TOP w0.081: v3(19.95,131.23) 19.71,130.98 19.46,130.98 19.19,131.25 CM3.3
  IN10 w0.081: v2(76.55,84.41) 76.36,84.6 72.34,84.6 70.97,85.97 70.97,93.2 70.61,93.56 65.33,93.56 64.87,93.09 63.54,93.09 63.21,93.42 61.06,93.42 60.48,92.85 59.34,92.85 58.51,93.68 55.63,93.68 55.22,94.08 55.22,95.35 54.74,95.84 52.45,95.84 49.76,98.53 49.76,99.26 49.37,99.66 48.35,99.66 47.09,100.92 40.74,100.92 21.04,120.61 17.14,120.61 15.72,122.02 15.72,128.71 18.09,131.07 19.8,131.07 v3(19.95,131.23)
  BOTTOM w0.081: U2019.28 79.69,84.3 79.6,84.39 78.5,84.39 78.33,84.57 76.71,84.57 v2(76.55,84.41)
HDMI_DATA0_DP: length 99.6
  TOP w0.081: v3(19.95,130.43) 19.71,130.67 19.46,130.67 19.19,130.4 CM3.2
  IN10 w0.081: v3(19.95,130.43) 20.15,130.43 20.24,130.52 20.24,130.72 20.14,130.82 18.19,130.82 15.97,128.6 15.97,122.13 17.24,120.86 21.15,120.86 40.84,101.16 47.19,101.16 48.45,99.9 49.47,99.9 50.01,99.37 50.01,98.63 52.55,96.08 54.84,96.08 55.47,95.46 55.47,94.19 55.73,93.93 58.61,93.93 59.44,93.09 60.37,93.09 60.95,93.67 63.32,93.67 63.65,93.34 64.76,93.34 65.23,93.81 70.71,93.81 71.22,93.3 71.22,86.08 72.44,84.85 76.36,84.85 76.55,85.04 v2(76.56,85.04)
  BOTTOM w0.081: v2(76.56,85.04) 76.72,84.88 78.45,84.88 78.63,84.7 79.6,84.7 79.69,84.8 U2019.29
HDMI_DATA0_R_DN: length 4.2
  TOP w0.081: R2273.1 13.86,131.02 14.08,131.02 14.26,131.2 14.61,131.2 14.69,131.28 D26.4 D26.7 16.09,131.28 16.15,131.22 16.46,131.22 16.73,130.95 16.97,130.95 CM3.4
HDMI_DATA0_R_DP: length 4.2
  TOP w0.081: CM3.1 17.03,130.4 16.79,130.64 16.61,130.64 16.33,130.91 16.06,130.91 15.93,130.78 D26.6 D26.5 14.68,130.78 14.57,130.89 14.39,130.89 14.21,130.71 13.83,130.71 R2272.1
HDMI_DATA0_RS_DN: length 3.5
  TOP w0.081: JHDMI1.9 10.71,131.25 11.09,130.88 11.58,130.88 11.78,131.07 12.39,131.07 R2273.2
HDMI_DATA0_RS_DP: length 3.5
  TOP w0.081: JHDMI1.7 10.71,130.25 11.03,130.57 11.71,130.57 11.91,130.76 12.31,130.76 R2272.2
HDMI_DATA1_DN: length 94.6
  TOP w0.081: CM4.3 19.19,129.35 19.46,129.07 19.71,129.07 v3(19.95,129.32)
  IN10 w0.081: 76.41,86.33 76.36,86.38 74.37,86.38 73.79,85.8 72.54,85.8 71.86,86.49 71.86,93.59 70.5,94.95 63.97,94.95 63.72,94.7 60.79,94.7 60.55,94.95 56.86,94.95 55.09,96.73 52.96,96.73 51.03,98.66 51.03,99.93 50.23,100.73 48.58,100.73 47.5,101.81 41.09,101.81 21.14,121.75 17.29,121.75 16.61,122.43 16.61,127.18 18.6,129.17 19.8,129.17 v3(19.95,129.32)
  IN10 w0.091: v2(76.55,86.19) 76.41,86.33
  BOTTOM w0.081: U2019.31 79.69,85.8 79.6,85.89 78.49,85.89 78.04,86.35 76.71,86.35 v2(76.55,86.19)
HDMI_DATA1_DP: length 94.6
  TOP w0.081: v3(19.95,128.52) 19.71,128.76 19.46,128.76 19.19,128.5 CM4.2
  IN10 w0.081: v3(19.95,128.52) 20.15,128.52 20.26,128.63 20.26,128.8 20.14,128.92 18.7,128.92 16.86,127.08 16.86,122.53 17.39,122 21.24,122 41.19,102.05 47.6,102.05 48.68,100.97 50.33,100.97 51.28,100.03 51.28,98.76 53.06,96.97 55.19,96.97 56.97,95.2 60.65,95.2 60.9,94.95 63.62,94.95 63.87,95.2 70.61,95.2 72.1,93.7 72.1,86.59 72.65,86.05 73.69,86.05 74.27,86.63 76.36,86.63 76.55,86.82 v2(76.56,86.82)
  BOTTOM w0.081: v2(76.56,86.82) 76.72,86.66 78.17,86.66 78.62,86.2 79.6,86.2 79.69,86.3 U2019.32
HDMI_DATA1_R_DN: length 4.1
  TOP w0.081: R2275.1 13.83,129.27 14.27,129.27 14.42,129.13 14.61,129.13 14.7,129.22 D30.1 D30.10 16.27,129.22 16.39,129.11 16.79,129.11 17.03,129.35 CM4.4
HDMI_DATA1_R_DP: length 4.1
  TOP w0.081: R2274.1 13.87,128.96 14.14,128.96 14.29,128.82 14.61,128.82 14.7,128.72 D30.2 D30.9 16.27,128.72 16.35,128.8 16.72,128.8 17.03,128.5 CM4.1
HDMI_DATA1_RS_DN: length 3.4
  TOP w0.081: R2275.2 12.39,129.29 11.75,129.29 11.3,129.75 JHDMI1.6
HDMI_DATA1_RS_DP: length 3.4
  TOP w0.081: R2274.2 12.31,128.98 11.53,128.98 11.3,128.75 JHDMI1.4
HDMI_DATA2_DN: length 85.5
  TOP w0.081: v3(19.95,127.54) 19.7,127.29 19.47,127.29 19.19,127.57 CM5.3
  IN10 w0.081: v3(19.95,127.54) 19.8,127.39 19.23,127.39 18.24,126.39 18.24,123.97 19.06,123.15 20.92,123.15 41.12,102.95 47.63,102.95 48.89,101.68 50.89,101.68 51.4,101.18 52.67,101.18 57.5,96.35 70.87,96.35 73.92,93.3 73.92,91.23 74.2,90.95 74.2,88.78 74.82,88.16 76.36,88.16 v2(76.55,87.96)
  BOTTOM w0.081: v2(76.55,87.96) 76.71,88.13 77.91,88.13 78.65,87.39 79.6,87.39 79.69,87.3 U2019.34
HDMI_DATA2_DP: length 85.5
  TOP w0.081: v3(19.95,126.74) 19.71,126.98 19.46,126.98 19.19,126.72 CM5.2
  IN10 w0.081: v3(19.95,126.74) 20.15,126.74 20.26,126.85 20.26,127.04 20.15,127.14 19.33,127.14 18.49,126.29 18.49,124.08 19.16,123.4 21.03,123.4 41.23,103.2 47.73,103.2 49,101.93 51,101.93 51.5,101.43 52.77,101.43 57.6,96.59 70.97,96.59 74.16,93.4 74.16,91.33 74.44,91.06 74.44,88.88 74.92,88.4 76.36,88.4 v2(76.55,88.6)
  BOTTOM w0.081: U2019.35 79.69,87.8 79.6,87.7 78.77,87.7 78.04,88.44 76.71,88.44 v2(76.55,88.6)
HDMI_DATA2_R_DN: length 4.2
  TOP w0.081: R2277.1 13.77,127.55 14.66,127.55 14.83,127.72 D30.4 D30.7 15.98,127.72 16.06,127.65 16.35,127.65 16.73,127.26 16.85,127.26 17.15,127.57 CM5.4
HDMI_DATA2_R_DP: length 4.2
  TOP w0.081: CM5.1 17.15,126.72 16.92,126.95 16.61,126.95 16.22,127.34 16.1,127.34 15.98,127.22 D30.6 D30.5 14.83,127.22 14.81,127.24 13.92,127.24 R2276.1
HDMI_DATA2_RS_DN: length 3.6
  TOP w0.081: R2277.2 12.34,127.46 11.91,127.46 11.47,127.9 11.1,127.9 10.76,128.25 JHDMI1.3
HDMI_DATA2_RS_DP: length 3.6
  TOP w0.081: R2276.2 12.37,127.15 11.78,127.15 11.34,127.59 11.1,127.59 10.76,127.25 JHDMI1.1
HDMI_DDC_CLK: length 32.5
  TOP w0.081: R443.2 15.91,134.82 16.53,134.82 17.67,135.96 17.67,136.15 v2(17.88,136.35) 17.8,136.42 17.8,136.84 R862.1
  IN10 w0.081: v2(17.88,136.35) 17.77,136.45 17.77,137.31 15.44,139.65 12.95,139.65 9.63,136.33 9.63,128.71 6.33,125.4 6.33,122.58 6.62,122.29 6.62,122.18 v2(6.45,122)
  BOTTOM w0.081: Q41.3 6.45,121.64 v2(6.45,122)
HDMI_DDC_CLK_R: length 6.1
  TOP w0.081: 12.15,134.43 D27.2 ; 12.15,134.43 12.58,134.86 14.46,134.86 R443.1 ; 12.15,134.43 12.15,134.46 11.74,134.86 11.51,134.86 10.89,134.25 JHDMI1.15
HDMI_DDC_DATA: length 32.5
  TOP w0.081: R565.1 17.24,136.78 v2(17.24,136.35) 17.34,136.25 17.34,136.07 v2(16.91,135.64) 16.4,135.13 15.54,135.13 15.46,135.21 15.46,135.39 R444.2
  IN10 w0.081: v2(7.9,122.86) 7.74,122.7 7.74,122.42 7.62,122.3 6.95,122.3 6.57,122.69 6.57,125.3 9.87,128.6 9.87,136.22 13.05,139.4 15.34,139.4 17.53,137.21 17.53,136.63 17.38,136.48 17.37,136.48 v2(17.24,136.35)
  BOTTOM w0.081: v2(7.9,122.86) 8.07,122.86 8.28,122.66 8.28,122.43 Q41.6
HDMI_DDC_DATA_R: length 6.2
  TOP w0.081: D28.2 12.15,135.6 ; 12.15,135.6 12.58,135.17 14.56,135.17 14.75,135.36 R444.1 ; 12.15,135.6 12.15,135.58 11.74,135.17 11.38,135.17 10.96,134.75 JHDMI1.16
HDMI_DONGLE_DETECT: length 114.5
  TOP w0.097: JDP1.13 11.75,158.8 v2(11.65,158.7)
  IN08 w0.091: v2(11.65,158.7) 11.91,158.45 16.86,158.45 17.62,157.69 17.62,145.49 18.76,144.35 18.76,125.17 43.02,100.92 53.56,100.92 57.96,96.52 61.77,96.52 62.07,96.22 68.8,96.22 70.71,98.12 73.34,98.12 74.14,97.33 v2(74.14,96.73)
  BOTTOM w0.097: v2(11.65,158.7) 11.07,158.7 R408.1 ; Q6.5 76.17,95.71 75.91,95.96 75.91,96.25 75.63,96.54 74.33,96.54 v2(74.14,96.73)
HDMI_REP_A1_VTH1: length 1.4
  BOTTOM w0.097: U2019.16 84.29,81.8 R2236.2
HDMI_REP_A4_VTH0: length 1.5
  BOTTOM w0.097: U2019.17 83.9,81.3 R2237.2
HDMI_REP_ENI2C: length 2.9
  BOTTOM w0.097: R2143.1 79.67,79.28 79.8,79.4 R2122.2 80.23,79.4 81.01,80.18 U2019.21
HDMI_REP_EQ0: length 1.1
  BOTTOM w0.097: U2019.39 81.01,90.03 R2141.2
HDMI_REP_EQ1: length 1
  BOTTOM w0.097: R2142.2 81.51,90.42 U2019.40
HDMI_REP_EQ2: length 1
  BOTTOM w0.097: R2125.2 82.01,90.3 U2019.41
HDMI_REP_EQ3: length 1.2
  BOTTOM w0.097: U2019.42 82.51,89.91 R2126.2
HDMI_REP_FG0: length 2.4
  BOTTOM w0.097: U2019.37 79.78,88.8 79.6,88.98 78.78,88.98 R2140.2
HDMI_REP_FG1: length 1.5
  BOTTOM w0.097: R2139.2 79.79,90.36 79.79,89.67 U2019.38
HDMI_REP_I2C_DONE_A0: length 3.1
  BOTTOM w0.097: R2239.2 78.28,80.22 v1(78.96,80.22) 79.22,80.22 79.6,80.6 79.6,80.98 79.92,81.3 U2019.22
HDMI_REP_PEN: length 1.8
  BOTTOM w0.254: U2019.20 81.51,79.96 81.57,79.89 Q106.2
HDMI_REP_SCL: length 3.5
  TOP w0.097: v2(82.26,80.09) 81.88,79.71 81.43,79.71 R2240.2 80.54,79.28 80.49,79.33 R2131.1
  BOTTOM w0.097: U2019.19 82.01,80.35 v2(82.26,80.09)
HDMI_REP_SDA: length 4.9
  TOP w0.097: R2130.1 81.55,80.27 81.81,80.52 82.64,80.52 v2(83.07,80.09) 82.26,79.28 R2241.2
  BOTTOM w0.097: U2019.18 82.51,80.66 v2(83.07,80.09)
HDMI_REP_SW0: length 1.5
  BOTTOM w0.097: R2123.2 84.55,88.8 U2019.2
HDMI_REP_SW1: length 1.6
  BOTTOM w0.097: U2019.1 84.16,89.3 R2138.2
HDMI_REP_VOD1: length 2.4
  BOTTOM w0.097: U2019.23 79.78,81.8 79.47,81.49 v1(78.96,81.49) R2238.2
HP_JD: length 2.1
  TOP w0.097: v2(301.5,20.32) 301.52,20.35 R311.1
  BOTTOM w0.097: v2(301.5,20.32) 301.5,20.19 301.28,19.98 JIO1.61
HP_OUTL: length 25.3
  TOP w0.254: U7.32 292.33,32.21 292.66,31.87 292.66,31.01 293.42,30.25 293.62,30.25
  TOP w0.356: v2(297.18,15.24) 296.67,15.24 295.88,16.03 v1(295.88,26.88) 295.88,29.84 295.47,30.25 293.62,30.25
  BOTTOM w0.254: JIO1.71 299.96,15.98 299.74,16.2 299.27,16.2
  BOTTOM w0.381: 299.27,16.2 298.69,16.2 297.6,15.11 297.31,15.11 v2(297.18,15.24)
HP_OUTR: length 27.1
  TOP w0.254: 294.03,30.81 293.47,30.81 293.04,31.24 293.04,32.1 292.54,32.61 U7.33
  TOP w0.356: 294.03,30.81 295.62,30.81 v1(296.13,30.31) 296.39,30.05 296.39,16.21 296.8,15.8 297.41,15.8 297.74,15.47 297.74,15.01 297.21,14.48 v2(297.18,14.48)
  BOTTOM w0.254: 299.08,15.69 299.56,15.69 299.67,15.58 JIO1.72
  BOTTOM w0.381: 299.08,15.69 298.9,15.69 297.81,14.61 297.31,14.61 v2(297.18,14.48)
I2CB_SCL: length 2.1
  TOP w0.097: R2298.1 240.25,117.2 v3(239.69,117.77)
  BOTTOM w0.1: G2.BG8 v3(239.69,117.77)
I2CB_SDA: length 3.3
  TOP w0.097: v3(240.39,117.77) 240.59,117.77 241.01,118.19 241.9,118.19 242.41,117.68 R2299.1
  BOTTOM w0.1: G2.BF8 v3(240.39,117.77)
I2CC_SCL: length 323.8
  TOP w0.097: v3(302.1,184.48) 301.34,183.72 PR1469.1 ; v3(225.14,120.15) 225.22,120.07 R2169.2
  IN05 w0.091: v3(308.07,72.22) 306.67,73.61 306.67,76.91 305.66,77.93 304.64,77.93 304.39,78.18 304.39,79.84 306.8,82.25 306.8,91.01 308.58,92.79 308.58,102.93 307.94,103.56 307.94,111.46 306.8,112.6 306.8,120.98 307.69,121.87 307.69,171.44 302.74,176.4 302.74,183.59 302.1,184.22 v3(302.1,184.48) 302.36,184.48 303.63,185.75 303.63,195.88 v3(303.62,195.88)
  IN08 w0.091: v3(289.02,74.88) 288,73.87 283.96,73.87 282.44,72.34 280.03,72.34 278.86,71.18 278.86,69.02 278.63,68.79 277.08,68.79 276.77,69.1 276.77,70.65 277.59,71.47 277.59,75.24 276.68,76.15 274.31,76.15 273.17,75.01 270.84,75.01 269.44,76.41 253.1,76.41 252.21,75.52 242.67,75.52 238.99,79.2 223.12,79.2 222.86,79.45 220.19,79.45 215.23,84.41 215.23,86.7 213.84,88.09 213.84,94.62 212.67,95.79 212.67,99.57 213.46,100.35 213.46,101.81 213.87,102.22 217.23,102.22 219.01,104 219.01,107.99 218.82,108.18 218.82,111.59 217.27,113.14 217.27,114.89 217.5,115.12 217.5,117.01 218.2,117.7 223.13,117.7 225.14,119.71 v3(225.14,120.15)
  IN10 w0.091: v3(308.07,72.22) 307.64,71.78 307.64,57.74 304.64,54.74 302.86,54.74 301.09,56.52 299.44,56.52 295.62,60.33 295.62,70.24 293.59,72.27 292.22,72.27 291.43,73.06 291.43,73.99 290.54,74.88 v3(289.02,74.88)
  BOTTOM w0.097: PU5.6 303.44,196.06 v3(303.62,195.88) ; v3(225.14,120.15) 225.01,120.02 R2296.1
I2CC_SCL_R: length 13.8
  TOP w0.097: R2169.1 228.98,120.07 230.5,118.54 v1(232.76,118.54) 232.81,118.49 238.31,118.49 v3(238.99,119.17)
  BOTTOM w0.1: G2.BG9 v3(238.99,119.17)
I2CC_SDA: length 326.5
  TOP w0.097: PR1470.1 300.96,182.83 301.72,183.59 v3(302.1,183.59) ; v3(225.14,120.73) 225.57,120.73 R2170.2
  IN05 w0.091: v3(308.07,71.45) 306.42,73.1 306.42,76.81 305.55,77.68 304.54,77.68 304.13,78.08 304.13,79.94 306.55,82.35 306.55,91.36 308.32,93.14 308.32,102.82 307.69,103.46 307.69,111.2 306.55,112.35 306.55,121.11 307.44,122.01 307.44,171.34 302.49,176.29 302.49,183.21 v3(302.1,183.59) 301.7,184 301.7,189.97 303.24,191.51 303.24,195.42 v3(302.79,195.88)
  IN08 w0.091: v3(225.14,120.73) 224.89,120.73 224.69,120.53 224.69,119.9 222.71,117.92 218.11,117.92 217.28,117.1 217.28,115.29 217.01,115.01 217.01,113.07 218.6,111.48 218.6,108.09 218.79,107.9 218.79,104.09 217.14,102.44 213.78,102.44 213.24,101.9 213.24,100.45 212.45,99.66 212.45,95.7 213.53,94.62 213.53,87.97 214.92,86.57 214.92,84.34 220.06,79.2 222.68,79.2 222.99,78.89 238.78,78.89 242.41,75.26 252.32,75.26 253.21,76.15 269.34,76.15 270.73,74.76 273.27,74.76 274.42,75.9 276.57,75.9 277.34,75.14 277.34,71.53 276.55,70.74 276.55,69.01 277.03,68.53 278.73,68.53 279.11,68.91 279.11,71.07 280.13,72.09 282.54,72.09 284.07,73.61 289.63,73.61 v3(290.29,74.27)
  IN10 w0.091: v3(308.07,71.45) 307.94,71.33 307.94,57.61 304.77,54.44 302.74,54.44 300.96,56.21 299.31,56.21 295.37,60.15 295.37,70.06 293.47,71.96 292.2,71.96 290.29,73.87 v3(290.29,74.27)
  BOTTOM w0.097: PR23.2 303.11,195.56 v3(302.79,195.88) PU5.7 ; v3(225.14,120.73) 225.27,120.73 225.9,120.09 R2297.1
I2CC_SDA_R: length 13.4
  TOP w0.097: R2170.1 229.74,120.96 230.85,119.84 233.01,119.84 233.34,119.51 233.34,119.23 233.89,118.69 237.32,118.69 v1(237.71,119.08) 237.78,119.14 v3(238.39,119.14)
  BOTTOM w0.1: G2.BH9 v3(238.39,119.14)
IFPAB_RSET: length 5
  TOP w0.097: R1015.1 237.79,128.15 238.12,127.81 238.9,127.81 238.93,127.85 240,127.85 240.05,127.89 v2(241.14,127.89) 241.41,127.89 v3(241.79,128.27)
  BOTTOM w0.097: G2.BD23 v3(241.79,128.27)
IFPCD_RSET: length 4.7
  TOP w0.1: v3(241.79,126.17) 241.64,126.17 241.23,126.57 v2(239.74,126.57) 238.04,126.57 R922.1
  BOTTOM w0.097: G2.BD20 v3(241.79,126.17)
IFPEF_RSET: length 6.7
  TOP w0.1: v3(241.79,124.07) 241.62,124.07 241.22,124.47 238.02,124.47 v1(237.84,124.29) 237.71,124.41 236.49,124.41 R923.1
  BOTTOM w0.097: G2.BD17 v3(241.79,124.07)
ILIM_1PH_A: length 2.6
  TOP w0.203: v2(126.59,186.92) 126.59,186.95 126.33,187.2 PU1101.20
  BOTTOM w0.254: v2(126.59,186.92) 126.71,186.8 PR1211.1
ILIM_3PH_A: length 6
  TOP w0.203: PU1101.46 126.33,195.38
  TOP w0.254: PR1208.1 123.64,197.96 123.91,197.69 125.83,197.69 v1(126.19,197.33) 126.33,197.18 126.33,195.38
IMON_3PH_A: length 4.1
  TOP w0.203: PU1101.1 122.92,194 122.59,194.33
  TOP w0.254: PR1152.2 PC1160.2 121.51,195.41 122.59,194.33
KBRST_N: length 280
  TOP w0.089: 29.81,53.55 31.24,53.55 31.36,53.42 D2.2
  TOP w0.097: v3(240.76,56.09) 241.01,56.34 244.62,56.34 R181.2 ; v2(23.72,56.09) 26.26,53.55 29.81,53.55
  IN03 w0.091: v2(141.7,38.81) 141.07,39.45 141.07,40.21 135.73,45.55 119.81,45.55 107.62,33.35 96.62,33.35 96.11,32.85 96.11,31.19 95.51,30.6 86.29,30.6 86.1,30.79 73.4,30.79 70.83,33.35 58.77,33.35 57.97,34.16 47.55,34.16 45.51,36.2 44.73,36.2 44.4,36.53 44.04,36.53 v2(43.15,37.42)
  IN05 w0.091: v2(23.72,56.09) 23.84,56.21 24.35,56.21 24.86,56.72 25.5,56.72 26.51,55.71 26.51,52.02 27.33,51.2 27.33,41.68 28.92,40.08 28.92,38.59 30.48,37.04 37.81,37.04 38.45,37.67 40.1,37.67 40.85,38.42 40.85,38.93 41.24,39.32 42.77,39.32 43.28,38.81 43.28,37.54 v2(43.15,37.42)
  IN10 w0.091: v3(240.76,56.09) 240.38,55.71 240.38,53.17 239.62,52.4 239.24,52.4 238.73,51.9 235.3,51.9 234.97,51.57 232.33,51.57 232.14,51.38 231.13,51.38 230.22,50.48 227.57,50.48 226.66,51.39 224.08,51.39 222.43,53.04 221.69,53.04 219.86,54.86 218.33,54.86 217.9,54.44 198.05,54.44 197.43,53.82 197.43,52.99 195.75,51.31 179.75,51.31 179.42,51.64 175.99,51.64 175.09,50.74 171.3,50.74 170.3,49.74 149.8,49.74 142.46,42.4 142.46,39.58 v2(141.7,38.81)
  BOTTOM w0.097: v3(240.76,56.09) 240.21,55.53 U2.AT17
KBRST_N_R: length 1.6
  TOP w0.089: D2.1 32.94,53.42 v1(33.24,53.72)
  BOTTOM w0.089: U5.H4 33.77,53.42 33.47,53.72 v1(33.24,53.72)
LAN_CK_REQ_N: length 9.2
  TOP w0.097: Q35.1 50.77,71.98 50.77,71.58 50.26,71.07 v1(50.26,71.05) 50.26,69.88 49.83,69.45 49.83,68.43 49.61,68.2 R277.2 49.37,67.74 47.72,66.09 47.72,65.99 47.56,65.83 U6.4
LAN_LX:
  vias: v1(51.35,65.84)
LAN_PPS: length 2
  TOP w0.097: U6.24 46.36,59.23 46.7,58.88 v1(46.7,58.25)
LAN_RBIAS: length 3.9
  TOP w0.203: R280.1 44.52,67.03 44.52,66.37 44.04,65.89 v1(44.04,65.74) 44.04,65.36 44.53,64.86 45.01,64.86 45.16,65.01 U6.10
LAN_RST_N: length 7.9
  TOP w0.097: U6.2 48.36,66 49.09,66.73 49.68,66.73 51.48,68.53 52.85,68.53 R274.2 v1(53.36,69.96)
LAN_WAKE_N: length 55.5
  TOP w0.097: R276.1 50.29,69.32 50.9,69.93 v2(51.02,69.93)
  IN03 w0.091: v2(35.4,63.71) 39.47,63.71 42.72,66.96 45.64,66.96 46.58,67.9 48.99,67.9 v2(51.02,69.93)
  IN10 w0.089: 32.99,58.63 31.97,57.61 31.97,55.07 30.83,53.93 30.83,48.1 30.58,47.85 30.58,46.69
  IN10 w0.091: 30.58,46.69 32.73,44.53 33.75,44.53 35.78,42.5 v2(35.78,41.61) ; v2(35.4,63.71) 33.5,61.8 33.5,59.13 32.99,58.63
  BOTTOM w0.076: U5.B7 35.52,50.16 35.52,49.61
  BOTTOM w0.097: v2(35.78,41.61) 35.26,42.13 35.26,45.33 35.52,45.59 35.52,49.61
LAN_WAKE_N_R: length 5.7
  TOP w0.097: R275.2 51.38,69.04 50.54,68.2 R276.2 49.42,67.34 v1(49.42,67.21) 49.19,67.21 47.96,65.98 U6.3
LC_CK32K/GPJ6: length 3
  TOP w0.076: 70.85,7.18 70.85,7.62 U19.F2
  TOP w0.097: 70.85,7.18 71.04,6.99 71.04,5.57 71.09,5.52 R511.2
LC_CS_N: length 29.2
  TOP w0.089: v1(68.04,10.24) 68.17,10.37 U19.A7
  TOP w0.097: U16.1 v2(47.34,6.18)
  IN03 w0.089: v1(68.04,10.24) 66.77,10.24
  IN03 w0.091: 66.77,10.24 66.14,10.24 65.12,9.22 62.33,9.22 60.6,7.49 52.2,7.49 51.74,7.95 49.12,7.95 v2(47.34,6.18)
LC_GPA4: length 7.1
  TOP w0.089: U19.K6 73.26,9.87 v1(73.63,10.24)
  TOP w0.097: v1(75.84,13.49) 76.35,13.49 v1(76.55,13.29) 76.68,13.16 R879.1
  IN03 w0.089: v1(73.63,10.24) 74.14,10.75 74.14,12.02 74.64,12.53 75.41,12.53 76.17,13.29 v1(76.55,13.29)
LC_GPA5: length 7.6
  TOP w0.089: v1(72.1,9.86) 72.11,9.87 U19.J6
  TOP w0.097: v3(76.8,10.87) 76.73,10.8 R880.1
  IN03 w0.089: 76.55,11.76 76.42,11.89 75.66,11.89 74.52,10.75 74.52,10.49 73.88,9.86 v1(72.1,9.86)
  IN03 w0.091: 76.55,11.76 76.8,11.51 v3(76.8,10.87)
LC_GPB0: length 6.1
  TOP w0.089: U19.A4 68.29,8.87 68.02,8.59 67.15,8.59 v1(67.02,8.46)
  BOTTOM w0.089: v1(67.02,8.46) 66.77,8.21
  BOTTOM w0.097: 66.77,8.21 66.67,8.11 66.67,7.73 v1(65.89,6.94) 65.7,6.76 64.41,6.76 64.32,6.85 R814.1
LC_GPB3: length 6.1
  TOP w0.076: 68.21,9.11 68.79,9.11 69.03,8.87 U19.B4
  TOP w0.097: v1(66.26,8.56) 66.59,8.89 v1(66.69,8.89) 66.75,8.84 67.94,8.84 68.21,9.11
  BOTTOM w0.097: R825.1 64,7.73 64.16,7.89 65.59,7.89 v1(66.26,8.56)
LC_HOLD_N: length 1.6
  TOP w0.097: U16.7 R788.1
LC_I2C_CLK: length 9.5
  TOP w0.097: U19.B1 69.1,7.1 68.35,6.35 v2(68.35,5.92) 68.35,5.46 68.04,5.16 68.04,4.02 67.84,3.81 R524.2 67.53,3.51 v2(67.15,3.13)
  BOTTOM w0.097: TP153.1 63.47,3.64 66.64,3.64 v2(67.15,3.13)
LC_I2C_DATA: length 13.3
  TOP w0.097: R513.2 62.15,5.36 v2(61.82,5.03) ; U19.C1 69.6,6.84 69.18,6.43 v1(69.18,5.92)
  IN05 w0.089: v1(69.18,5.92) 68.8,5.54
  IN05 w0.091: v2(61.82,5.03) 62.07,5.29 68.55,5.29 68.8,5.54
  BOTTOM w0.097: v2(61.82,5.03) 61.06,5.79 TP154.1
LC_INT0_N: length 251.4
  TOP w0.097: R876.2 69.44,3.38 v2(69.56,3.25) R567.2
  IN03 w0.091: v2(63.6,30.65) 64.36,29.89 70.42,29.89 72.83,27.48 76.42,27.48 77.28,26.62 82.26,26.62 83.12,27.48 97.62,27.48 100.2,30.06 109.37,30.06 113.55,34.24 115.03,34.24 115.54,34.75 118.05,34.75 121.05,37.75 121.67,38.37 121.67,41.45 122.87,42.64 129.49,42.64 v2(133.32,38.81)
  IN08 w0.091: v2(69.56,3.25) 69.06,3.76 63.72,3.76 60.17,7.32 60.17,9.35 60.8,9.99 60.8,22.3 63.6,25.1 v2(63.6,30.65)
  IN10 w0.091: v3(229.48,65.61) 229.97,66.09 229.97,67.01 227.81,69.17 222.73,69.17 216.5,62.94 212.95,62.94 209.9,65.99 209.9,72.85 209.26,73.49 204.44,73.49 203.63,72.67 203.63,70.39 199.74,66.5 179.29,66.5 178.4,65.61 178.4,59.96 177.13,58.69 162.01,58.69 159.01,55.68 146.49,55.68 132.81,42 132.81,39.32 v2(133.32,38.81)
  BOTTOM w0.097: v3(229.48,65.61) 229.48,65.9 U2.R39
LC_INT0_N_R: length 3
  TOP w0.076: U19.D2 69.84,7.61 69.84,6.71
  TOP w0.097: R876.1 69.69,5.36 69.69,6.56 69.84,6.71
LC_INT1_N: length 92.8
  TOP w0.097: U19.F1 71.47,6.99 v3(71.47,5.92) 71.62,5.77 71.62,3.66 R620.2
  IN10 w0.089: v3(71.47,5.92) 71.09,5.54
  IN10 w0.091: 71.09,5.54 70.83,5.29 69.82,5.29 68.72,4.19 63.58,4.19 62.16,5.61 60.99,5.61 58.96,7.64 53.24,7.64 52.28,6.68 50.12,6.68 47.5,4.06 42.31,4.06 41.75,3.51 29.69,3.51 25.88,7.32 25.88,13.67 25.37,14.18 25.37,18.11 26.23,18.98 26.23,25.48 27.02,26.27 27.02,31.7 26.49,32.24 26.49,37.06 25.62,37.93 25.62,42.37 v2(26.13,42.88)
LC_KSI6: length 14.1
  TOP w0.097: U19.H13 72.1,14.04 72.74,14.68 72.74,15.57 71.98,16.33 71.98,17 v2(72.46,17.48)
  BOTTOM w0.097: v2(72.46,17.48) 72.61,17.48 72.74,17.61 72.74,21.67 72.02,22.39 72.02,23.66 71.04,24.64 TP145.1
LC_KSI7: length 15
  TOP w0.089: U19.G9 71.6,11.26 v1(72.23,10.62)
  IN05 w0.089: 66.77,10.75 69.06,10.75 69.44,10.37 69.82,10.37 70.45,11 71.98,11 72.23,10.75 v1(72.23,10.62)
  IN05 w0.091: v2(60.93,8.72) 61.69,8.72 62.71,9.73 65.5,9.73 66.52,10.75 66.77,10.75
  BOTTOM w0.097: TP146.1 v2(60.93,8.72)
LC_KSO16: length 75.6
  TOP w0.089: 37.31,46.69 38.2,47.58 39.19,47.58 41.5,49.89
  TOP w0.097: U19.K13 73.39,13.66 74,13.66 74.52,14.18 74.52,16.97 74.29,17.2 73.68,17.2 72.23,18.65 72.23,20.02 71.47,20.78 70.84,20.78 70.45,21.16 v2(70.45,22.05) ; 41.5,49.89 41.6,49.99 41.6,53.52 41.9,53.83 R578.1 ; v2(36.8,46.18) 37.31,46.69
  IN05 w0.091: v2(70.45,22.05) 69.56,21.16 55.34,21.16 54.97,21.54 54.97,25.86 46.45,34.37 43.28,34.37 v2(42.26,35.39)
  IN08 w0.091: v2(42.26,35.39) 41.62,36.02 38.58,36.02 38.07,36.53 38.07,38.05 36.67,39.45 36.67,46.05 v2(36.8,46.18)
LC_KSO17: length 74.3
  TOP w0.076: 72.85,13.54 72.85,12.12 U19.J10
  TOP w0.089: 74.26,15.07 74.26,14.43 73.76,13.93 73.24,13.93 72.85,13.54
  TOP w0.097: R579.1 42.41,55.96 v2(42.62,56.16) ; v2(69.44,22.05) 69.44,22.05 70.08,21.41 70.08,21.16 70.69,20.55 71.32,20.55 71.85,20.02 v1(71.85,19.51) 71.85,18.49 72.23,18.11 72.45,18.11 72.89,17.67 72.89,16.16 73.23,15.82 73.89,15.82 74.26,15.45 74.26,15.07
  IN05 w0.091: v2(69.44,22.05) 66.26,22.05 65.63,21.42 55.98,21.42 55.24,22.15 55.24,25.96 46.58,34.62 44.04,34.62 v2(43.28,35.39)
  IN08 w0.091: v2(42.62,56.16) 42.62,50.73 42.26,50.37 42.26,45.67 40.41,43.82 40.41,42.68 40.23,42.5 40.23,40.21 39.08,39.07 39.08,38.31 40.86,36.53 42.64,36.53 43.28,35.89 v2(43.28,35.39)
LC_SCK: length 20.3
  TOP w0.076: U19.B5 68.85,9.61 68.46,9.61 68.45,9.6
  TOP w0.097: v3(67.79,9.22) 67.91,9.35 68.19,9.35 68.45,9.6 ; R431.1 v2(52.34,3.64)
  IN05 w0.089: v3(67.79,9.22) 67.51,8.94 66.77,8.94
  IN05 w0.091: 66.77,8.94 62.68,8.94 59.28,5.54 55.72,5.54 53.82,3.64 v2(52.34,3.64)
LC_SCK_R: length 1.6
  TOP w0.097: U16.6 R431.2
LC_SI: length 21.9
  TOP w0.076: 68.42,8.61 69.21,8.61 69.44,8.84 69.44,9.53 U19.B6
  TOP w0.097: 68.42,8.61 68.14,8.33 67.66,8.33 67.28,7.95 v1(67.02,7.95) ; R432.1 v2(52.34,2.37)
  IN05 w0.091: v2(52.34,2.37) 53.31,2.37 56.1,5.16 59.66,5.16 61.39,6.89 65.96,6.89 v1(67.02,7.95)
LC_SI_R: length 3.5
  TOP w0.097: U16.5 49.32,2.37 49.78,1.91 49.78,1.4 49.96,1.22 v1(50.44,1.22) R432.2
LC_SO: length 33.9
  TOP w0.097: v3(67.02,9.35) 67.15,9.35 67.41,9.6 68.17,9.6 68.43,9.87 U19.A6 ; R434.2 39.14,2.37 v2(39.21,2.29)
  IN05 w0.089: v3(67.02,9.35) 66.77,9.6
  IN05 w0.091: 66.77,9.6 66.52,9.86 66.01,9.86 65.5,9.35 62.71,9.35 59.53,6.18 55.47,6.18 53.56,4.27 51.66,4.27 50.26,2.87 39.8,2.87 v2(39.21,2.29)
LC_SO_R: length 3.2
  TOP w0.097: U16.2 40.3,4.91 v1(39.8,4.4) 40.05,4.14 R434.1
LC_TEST1: length 14.7
  TOP w0.097: v1(60.4,6.1) R407.1 62,6.1 v2(62.07,6.18) 62.12,6.23 R793.1
  TOP w0.102: v1(70.96,10.62) 70.96,10.54 70.79,10.37 U19.E7
  IN05 w0.089: v1(70.96,10.62) 69.95,9.6 69.95,7.83 68.55,6.43 66.77,6.43
  IN05 w0.091: 66.77,6.43 65.37,6.43 65.25,6.3 62.2,6.3 v2(62.07,6.18)
LC_VCORE2/CK32KE: length 2.6
  TOP w0.089: v1(72,6.05) 72.36,5.69
  TOP w0.097: v1(72,6.05) 71.85,6.2 71.85,7.11 U19.G1 ; 72.36,5.69 C249.1
LC_WP_N: length 8.7
  TOP w0.097: U16.3 v2(42.89,3.64)
  BOTTOM w0.097: v2(42.89,3.64) 42.62,3.36 v1(42.62,2.87) 46.43,2.87 R783.1
LC_WRST_N: length 5.5
  TOP w0.089: 76.09,5.54 76.42,5.87 v1(76.42,6.68)
  TOP w0.097: 76.09,5.54 R525.2
  TOP w0.203: 73.75,6.31 73.6,6.46 U19.L1
  TOP w0.254: R525.2 C1368.1 75.03,5.79 74.77,6.05 74.01,6.05 73.75,6.31
LED_GPB6: length 4
  TOP w0.076: U19.H4 72.1,8.22 72.35,7.96 72.35,6.56
  TOP w0.097: TP142.1 73.2,5.34 72.61,5.92 72.61,6.29 72.35,6.56
LED_GPC0: length 2.1
  TOP w0.097: U19.D1 70.1,6.58 69.95,6.43 69.95,5.67 TP137.1
LED_GPC6: length 2.9
  TOP w0.097: U19.E1 70.6,7.13 70.78,6.94 70.78,5.67 70.58,5.46 70.58,5.16 TP139.1
LED_GPH0: length 3.9
  TOP w0.076: U19.D8 69.34,10.11 68.4,10.11
  TOP w0.089: 66.77,9.99 67.51,9.99 67.63,9.86
  TOP w0.097: 68.4,10.11 68.14,9.86 67.63,9.86 ; 66.77,9.99 TP134.1
LED_GPH3: length 2.9
  TOP w0.097: U19.A9 68.47,11.37 67.92,10.82 66.36,10.82 v1(66.03,10.49)
LED_GPH4: length 2.8
  TOP w0.076: U19.B8 68.84,11.12 68.49,11.12
  TOP w0.097: 68.49,11.12 67.93,10.56 66.71,10.56 TP136.1
LED_SPK_PWM_CB1: length 243
  IN03 w0.091: v2(290.07,17.53) 289.18,17.53 288.22,18.48 274.52,18.48 273.55,17.51 265.94,17.51 263.4,20.05 263.4,35.84 261.98,37.26 258.83,37.26 258.1,37.99 211.63,37.99 210.89,37.25 206.51,37.25 205.87,37.89 203.63,37.89 203.55,37.81 203.04,37.81 202.96,37.89 202.36,37.89 202.28,37.81 201.77,37.81 201.69,37.89 201.12,37.89 201.02,37.79 200.49,37.79 200.39,37.89 123.41,37.89 120.01,34.49 120.01,30.53 118.67,29.18 112.12,29.18 111,28.07 99.19,28.07 96.65,25.53 87.27,25.53 v2(83.53,21.8)
  BOTTOM w0.097: v2(83.53,21.8) 82.9,21.16 v1(82.9,20.78) 82.9,20.15 83.74,19.3 83.74,17.32 82.59,16.17 JKB1.19 ; JSPBL1.1 290.19,17.4 v2(290.07,17.53)
LED_SPK_PWM_CB2: length 241.6
  IN08 w0.091: v2(82.55,16.76) 82.8,16.76 83.31,17.27 83.31,17.65 90.55,24.89 96.39,24.89 97.66,26.16 111.38,26.16 113.36,28.14 121.56,28.14 122.28,28.85 122.28,36.93 123.23,37.89 179.24,37.89 180.21,38.86 204.09,38.86 206.81,41.58 211.1,41.58 214.78,37.9 258.81,37.9 259.37,37.34 261.96,37.34 263.27,36.02 263.27,23.8 266.24,20.83 272.92,20.83 274.01,19.74 277.57,19.74 v2(278.03,19.28) 278.97,18.34 285.83,18.34 287.15,17.02 288.04,17.02 v2(288.54,17.53)
  BOTTOM w0.097: v2(288.54,17.53) 289.05,17.53 289.39,17.19 JSPBL1.2 ; JKB1.20 82.09,16.11 82.55,16.56 v2(82.55,16.76)
LED_SPK_PWM_CB3: length 249.9
  IN08 w0.091: v2(288.54,15.49) 289.05,16 289.05,17.65 287.92,18.79 281.5,18.79 279.08,21.21 v2(278.03,21.21) 273.3,21.21 270.23,24.28 265.73,24.28 265.4,24.61 265.4,27.38 263.98,28.8 263.98,31.83 265.02,32.87 265.02,34.11 264.13,35 264.13,40.84 262.99,41.99 260.83,41.99 257.27,38.43 215.04,38.43 211.32,42.14 206.65,42.14 203.93,39.42 149.48,39.42 148.38,38.33 123.05,38.33 121.84,37.11 121.84,29.04 121.38,28.58 113.18,28.58 111.2,26.6 97.48,26.6 96.21,25.33 90.37,25.33 82.69,17.65 v2(82.55,17.65)
  BOTTOM w0.097: JSPBL1.3 288.59,15.54 v2(288.54,15.49) ; JKB1.21 81.59,16.11 81.86,16.38 81.99,16.38 82.12,16.51 82.12,17.22 v2(82.55,17.65)
LED_SPK_PWM_CB4: length 240.2
  IN08 w0.091: v2(287.27,17.53) 286.23,18.57 280.14,18.57 278.74,19.96 274.17,19.96 273.05,21.08 267.94,21.08 265.33,23.7 v2(264.52,23.7) 263.5,24.71 263.5,36.12 262.05,37.57 259.46,37.57 258.82,38.21 214.82,38.21 211.2,41.84 206.74,41.84 204.02,39.12 180.14,39.12 179.13,38.11 123.14,38.11 122.06,37.02 122.06,28.95 121.47,28.36 113.27,28.36 111.29,26.38 97.57,26.38 96.3,25.11 90.46,25.11 83.03,17.68 83.03,17.5 82.74,17.21 82.36,17.21 81.91,16.76 v2(81.66,16.76)
  BOTTOM w0.097: JKB1.22 81.09,16.2 v2(81.66,16.76) ; v2(287.27,17.53) 287.54,17.53 287.79,17.27 JSPBL1.4
LED_SPK_PWM_CB5: length 288.9
  TOP w0.097: v1(286.79,15.04) 286.79,15.11 v2(286.41,15.49)
  IN03 w0.091: v2(200.76,38.43) 161.13,38.43 149.55,50.01 119.14,50.01 107.56,38.43 99.79,38.43 98.18,40.04 89.97,40.04 89.05,39.12 74.16,39.12 v3(72.14,41.15)
  IN08 w0.091: v3(72.14,41.15) 72.14,41.07 80.14,33.07 80.14,28.53 79.22,27.61 79.22,22.81 81.05,20.97 81.05,18.59 81.66,17.98 v2(81.66,17.65)
  IN10 w0.091: v2(286.41,15.49) 286.64,15.72 286.64,17.65 284.1,20.19 276.61,20.19 275.97,20.83 274.7,20.83 272.72,18.85 267.72,18.85 264,22.56 264,25.48 264.76,26.24 264.76,27.89 264.26,28.4 264.26,33.61 264.67,34.02 264.67,40.51 262.59,42.59 260.58,42.59 256.95,38.96 213.56,38.96 210.53,41.99 208.47,41.99 205.68,39.2 201.52,39.2 v2(200.76,38.43)
  BOTTOM w0.097: JSPBL1.5 286.99,15.72 286.77,15.49 v2(286.41,15.49) ; v2(81.66,17.65) 81.66,17.53 80.59,16.46 JKB1.23
LED_SPK_PWM_CB6: length 286.1
  IN03 w0.091: v3(202.03,38.43) 201.52,38.94 160.98,38.94 149.7,50.23 119.05,50.23 107.51,38.69 99.92,38.69 98.31,40.3 88.7,40.3 88.41,40.01 74.29,40.01 v3(73.15,41.15)
  IN08 w0.091: v2(82.55,18.54) 82.55,18.67 81.66,19.56 81.66,21.08 79.76,22.99 79.76,27.43 80.64,28.32 80.64,33.66 74.68,39.62 74.68,41.27 74.29,41.66 73.66,41.66 v3(73.15,41.15)
  IN10 w0.091: v2(286,17.53) 283.56,19.97 274.6,19.97 272.17,17.53 268.63,17.53 263.71,22.44 263.71,25.6 264.51,26.4 264.51,27.64 263.62,28.53 263.62,36.02 264.16,36.56 264.16,40.51 262.37,42.3 260.7,42.3 257.14,38.74 213.46,38.74 210.43,41.77 208.66,41.77 205.83,38.94 202.53,38.94 v3(202.03,38.43)
  BOTTOM w0.097: v2(82.55,18.54) 82.37,18.36 81.61,18.36 80.09,16.85 JKB1.24 ; JSPBL1.6 286.19,17.34 v2(286,17.53)
LED_SPK_PWM_CB7: length 282.6
  IN03 w0.091: v3(74.17,41.15) 74.85,40.47 88.36,40.47 88.87,40.97 98.01,40.97 100.04,38.94 107.45,38.94 118.96,50.45 149.84,50.45 160.96,39.32 202.53,39.32 203.3,38.56 v3(203.3,38.43)
  IN08 w0.091: v2(81.48,18.8) 81.41,18.87 81.41,20.98 79.5,22.88 79.5,27.54 80.39,28.43 80.39,33.55 74.17,39.77 v3(74.17,41.15)
  IN10 w0.091: v2(285.24,15.49) 285.24,17.91 283.41,19.74 274.75,19.74 272.31,17.3 268.52,17.3 263.37,22.45 263.37,36.66 263.78,37.07 263.78,40.39 262.17,41.99 260.9,41.99 257.42,38.5 213.38,38.5 210.44,41.45 208.72,41.45 205.71,38.43 v3(203.3,38.43)
  BOTTOM w0.097: JKB1.25 79.59,16.73 81.48,18.62 v2(81.48,18.8) ; v2(285.24,15.49) 285.39,15.64 JSPBL1.7
LED_SPK_PWM_CB8: length 241.2
  IN10 w0.091: v2(284.73,17.53) 283.58,18.68 274.21,18.68 272.53,17.01 268.42,17.01 263.08,22.34 263.08,36.49 262.07,37.51 259.83,37.51 259.22,38.12 211.11,38.12 210.48,37.48 207.86,37.48 207.23,38.12 203.64,38.12 203.56,38.03 203.13,38.03 203.02,38.14 202.3,38.14 202.19,38.03 201.86,38.03 201.75,38.14 201.07,38.14 200.93,38.01 200.58,38.01 200.45,38.14 122.29,38.14 120.74,36.59 120.74,30.62 119.31,29.2 115.12,29.2 107.35,21.43 95.21,21.43 87.97,14.19 82.59,14.19 82.46,14.06 79.33,14.06 v2(78.61,14.78)
  BOTTOM w0.097: JKB1.26 79.09,15.26 v2(78.61,14.78) ; JSPBL1.8 284.59,17.38 v2(284.73,17.53)
LED_SPK_PWM_CB9: length 244.6
  IN10 w0.091: v2(77.34,14.78) 78.28,13.84 82.55,13.84 82.68,13.97 88.06,13.97 95.3,21.21 107.44,21.21 115.21,28.98 119.41,28.98 120.95,30.53 120.95,36.5 122.38,37.92 200.35,37.92 200.49,37.79 201.02,37.79 201.16,37.92 201.66,37.92 201.77,37.81 202.28,37.81 202.39,37.92 202.93,37.92 203.13,37.72 203.56,37.72 203.73,37.9 207.14,37.9 207.77,37.26 210.57,37.26 211.2,37.9 259.13,37.9 259.74,37.29 261.98,37.29 262.86,36.4 262.86,22.25 268.33,16.79 272.69,16.79 274.37,18.47 283.29,18.47 283.97,17.78 v2(283.97,15.49)
  BOTTOM w0.097: v2(283.97,15.49) 283.79,15.68 JSPBL1.9 ; JKB1.27 78.59,15.37 78,14.78 v2(77.34,14.78)
LED_TP_PWM_CA1: length 55.5
  IN10 w0.091: v2(89.28,17.91) 87.12,20.07 77.62,20.07 76.22,18.67 71.93,18.67 69.39,16.13 67.94,16.13 67.11,15.29 62.41,15.29 60.2,13.08 59.25,13.08 58.36,12.19 52,12.19 50.86,13.34 46.48,13.34 45.47,12.32 v2(42.67,12.32)
  BOTTOM w0.097: JKB1.7 88.59,16.2 89.28,16.89 v2(89.28,17.91) ; JTPBL1.1 42.63,12.37 v2(42.67,12.32)
LED_TP_PWM_CA2: length 56.9
  IN10 w0.091: v2(41.15,11.3) 47.24,11.3 48.51,12.57 50.55,12.57 51.69,11.43 58.67,11.43 59.56,12.32 60.83,12.32 61.47,12.95 67.31,12.95 68.58,14.22 69.85,14.22 70.36,14.73 70.36,15.11 71.25,16 75.82,16 77.22,17.4 80.77,17.4 81.46,18.08 82.98,18.08 83.31,18.41 84.33,18.41 85.47,17.27 87.38,17.27 v2(88.01,17.91)
  BOTTOM w0.097: v2(41.15,11.3) 41.63,11.78 JTPBL1.2 ; JKB1.8 88.09,16.11 88.52,16.54 88.52,17.4 v2(88.01,17.91)
LED_TP_PWM_CA3: length 58.1
  IN10 w0.091: v2(88.01,16.64) 86.74,15.37 77.09,15.37 76.45,14.73 73.53,14.73 72.14,13.34 70.87,13.34 70.48,12.95 69.21,12.95 67.94,11.68 62.36,11.68 60.07,9.4 58.04,9.4 57.78,9.14 56.64,9.14 56.51,9.27 55.88,9.27 55.75,9.14 52.07,9.14 50.8,10.41 48.51,10.41 47.6,9.5 40.23,9.5 v2(40,9.27)
  BOTTOM w0.097: JKB1.9 87.59,16.22 v2(88.01,16.64) ; v2(40,9.27) 40.72,9.98 40.72,11.34 40.63,11.43 JTPBL1.3
LED_TP_PWM_CA4: length 56.5
  IN10 w0.091: v2(40,12.32) 40.51,12.83 41.27,12.83 42.34,11.76 46.81,11.76 48.13,13.08 50.76,13.08 51.9,11.94 58.46,11.94 59.35,12.83 60.32,12.83 62.53,15.04 67.23,15.04 68.07,15.88 69.49,15.88 72.03,18.41 76.33,18.41 77.72,19.81 84.84,19.81 v2(86.74,17.91)
  BOTTOM w0.097: v2(40,12.32) 39.63,12.7 JTPBL1.4 ; JKB1.10 87.09,16.23 87.25,16.38 87.25,17.4 v2(86.74,17.91)
LED_TP_PWM_CA5: length 59.3
  IN10 w0.091: v2(38.86,9.27) 39.32,9.73 47.52,9.73 48.42,10.63 50.89,10.63 52.12,9.4 55.65,9.4 55.77,9.53 56.62,9.53 56.75,9.4 57.68,9.4 57.93,9.65 59.97,9.65 62.25,11.94 67.84,11.94 69.11,13.21 70.38,13.21 70.76,13.59 72.03,13.59 73.43,14.99 76.35,14.99 76.98,15.62 85.72,15.62 v2(86.74,16.64)
  BOTTOM w0.097: v2(38.86,9.27) 39.37,9.78 40.13,9.78 40.43,10.08 40.43,11.13 39.37,12.19 39.37,12.57 38.63,13.32 JTPBL1.5 ; v2(86.74,16.64) 86.59,16.49 JKB1.11
LED_TP_PWM_CA6: length 56.5
  IN10 w0.091: v2(85.47,17.91) 83.82,19.56 78.96,19.56 75.62,16.22 71.16,16.22 70.14,15.2 70.14,14.82 69.76,14.44 68.49,14.44 67.25,13.21 61.34,13.21 60.67,12.54 59.47,12.54 58.58,11.65 51.78,11.65 50.64,12.79 48.22,12.79 46.96,11.53 41.81,11.53 41.53,11.81 39.37,11.81 v2(38.86,12.32)
  BOTTOM w0.097: JKB1.12 86.09,17.28 v2(85.47,17.91) ; v2(38.86,12.32) 38.73,12.32 37.62,13.43 JTPBL1.6
LED_TP_PWM_CA7: length 55.9
  IN10 w0.091: v2(40,10.29) 40.28,10.01 47.48,10.01 48.39,10.92 51.01,10.92 52.28,9.65 55.54,9.65 55.67,9.78 56.73,9.78 56.85,9.65 57.57,9.65 57.83,9.91 59.86,9.91 62.15,12.19 67.69,12.19 68.96,13.46 70.23,13.46 70.61,13.84 71.88,13.84 73.28,15.24 76.24,15.24 76.88,15.88 84.71,15.88 v2(85.47,16.64)
  BOTTOM w0.097: JTPBL1.7 36.62,13.41 38.23,11.81 39.24,11.81 40,11.05 v2(40,10.29) ; v2(85.47,16.64) 85.59,16.51 JKB1.13
LED_TP_PWM_CA8: length 56
  IN10 w0.091: v2(84.2,17.91) 83.5,17.21 81.34,17.21 81.28,17.14 77.34,17.14 75.95,15.75 73.07,15.75 71.67,14.35 70.4,14.35 70.02,13.97 68.75,13.97 67.48,12.7 61.85,12.7 60.58,11.43 59.18,11.43 58.93,11.18 51.56,11.18 51.31,11.43 48.26,11.43 47.28,10.45 41.37,10.45 40.51,11.3 v2(38.86,11.3)
  BOTTOM w0.097: JTPBL1.8 35.62,13.4 37.72,11.3 v2(38.86,11.3) ; v2(84.2,17.91) 84.84,17.27 84.84,16.64 85.09,16.38 JKB1.14
LED_TP_PWM_CA9: length 56.5
  IN10 w0.091: v2(38.86,10.29) 39.37,10.79 40.64,10.79 41.21,10.23 47.39,10.23 48.3,11.14 51.1,11.14 52.34,9.91 55.44,9.91 55.56,10.03 56.83,10.03 56.96,9.91 57.47,9.91 57.72,10.16 59.75,10.16 62.04,12.45 67.59,12.45 68.86,13.72 70.13,13.72 70.51,14.1 71.78,14.1 73.17,15.49 76.14,15.49 76.77,16.13 83.69,16.13 v2(84.2,16.64)
  BOTTOM w0.097: JKB1.15 84.59,16.24 v2(84.2,16.64) ; v2(38.86,10.29) 37.72,10.29 34.62,13.38 JTPBL1.9
LG_3V: length 10.4
  TOP w0.508: PQ301.8 54.99,19.79 v2(54.86,19.66)
  IN03 w0.508: v2(46.86,16.89) 49.63,19.66 v2(54.86,19.66)
  vias: v1(47.9,16.84)
LID_30_N: length 525.8
  TOP w0.097: R368.2 184.47,194.97 v2(184.63,194.82) ; R368.2 R369.2 ; R368.2 183.96,195.07 D20.1 ; U51.2 6.44,146.51 v1(8.6,146.51) 9.62,147.53 v2(9.62,147.55)
  IN05 w0.091: v2(194.41,45.42) 192.79,43.8 121.83,43.8 120.55,42.53 120.55,30.37 119.52,29.34 114.57,29.34 111.4,26.16 97.3,26.16 96.11,24.97 82.92,24.97 82.28,25.61 79.34,25.61 77.18,23.45 73.5,23.45 72.61,22.56 68.45,22.56 68.24,22.35 63.9,22.35 63.34,21.8 56.18,21.8 55.7,22.28 55.7,23.57 56.23,24.1 56.23,25.61 55.98,25.86 55.65,25.86 46.63,34.88 44.55,34.88 v2(44.04,35.39)
  IN08 w0.089: 41.12,46.69 41.12,49.48 38.7,51.9 38.7,57.36 37.56,58.5 34.26,58.5 34.13,58.63
  IN08 w0.091: v2(9.62,147.55) 9.62,145.77 15.34,140.06 15.34,126.19 35.15,106.38 35.15,102.67 33.98,101.5 33.98,90.48 20.03,76.53 20.03,73.87 23.72,70.18 23.72,68.02 24.86,66.88 24.86,65.1 26.38,63.58 32.61,63.58 33.75,62.44 33.75,59.01 34.13,58.63 ; v2(184.63,194.82) 184.63,195.28 185.64,196.29 188.06,196.29 188.57,196.8 197.58,196.8 202.28,192.1 207.77,192.1 209.9,189.98 209.9,183.21 209.81,183.12 209.81,176.65 209.52,176.36 209.01,176.36 207.99,175.34 207.99,171.28 206.72,170.01 206.72,156.29 205.2,154.77 205.2,151.34 199.1,145.24 199.1,130 193.26,124.16 193.26,117.55 201.26,109.55 201.26,85.8 202.24,84.82 202.24,62.66 202.13,62.54 202.13,61.29 202.51,60.91 203.04,60.91 203.22,60.73 203.22,60.15 199.28,56.21 199.28,46.21 197.51,44.44 195.26,44.44 194.41,45.29 v2(194.41,45.42) ; v2(44.04,35.39) 43.53,34.88 43.15,34.88 42.77,35.26 42.77,35.89 42.39,36.27 40.61,36.27 37.69,39.2 37.69,41.1 39.47,42.88 39.47,44.02 41.12,45.67 41.12,46.69
LPC_AD0_ESPI_IO0: length 280.5
  IN05 w0.091: v2(23.72,53.67) 25.11,52.28 25.11,48.85 23.41,47.15 23.41,38.23 23.65,38 26,38 29.67,34.32 39.72,34.32 41.29,35.89 45.31,35.89 46.07,35.13 46.69,35.13 55.7,26.11 56.23,26.11 56.45,25.9 56.45,24.23 57.3,23.38 62.45,23.38 63.21,24.13 72.53,24.13 75.03,26.62 82.9,26.62 83.53,27.26 94.44,27.26 95.24,28.06 98.69,28.06 100.76,30.13 110.89,30.13 v2(111.47,29.54)
  IN08 w0.091: v2(181.07,53.42) 181.07,50.5 180.47,49.9 119.04,49.9 112.66,43.53 112.66,30.13 112.08,29.54 v2(111.47,29.54)
  IN10 w0.091: v3(238.47,56.21) 238.35,56.21 238.17,56.04 236.87,56.04 236.7,56.21 235.3,56.21 233.01,53.92 233.01,52.76 232.78,52.53 232.43,52.53 231.92,53.04 231.31,53.04 230.3,54.05 229.58,54.05 229.2,54.44 223.85,54.44 223.11,55.17 223.11,55.68 220.8,57.99 218.41,57.99 217.52,57.1 204.49,57.1 203.83,56.44 195.78,56.44 195.12,55.78 188.36,55.78 185.74,53.17 181.32,53.17 v2(181.07,53.42)
  BOTTOM w0.097: U5.K1 31.68,54.41 31.21,54.88 30.51,54.88 29.43,53.8 27.97,53.8 27.64,53.47 25.96,53.47 25.24,54.18 24.23,54.18 v2(23.72,53.67) ; U2.AT22 237.87,55.61 v3(238.47,56.21)
LPC_AD1_ESPI_IO1: length 268.2
  IN05 w0.091: v2(27.15,53.04) 27.83,52.35 27.83,41.86 29.43,40.26 29.43,38.78 30.69,37.51 36.9,37.51 37.69,38.31 38.7,38.31 39.52,39.12 39.9,39.12 40.61,39.83 43.66,39.83 44.42,39.07 47.14,39.07 48.84,37.36 48.84,34.52 56.26,27.1 62.36,27.1 64.23,25.23 72.1,25.23 74.52,27.64 82.42,27.64 83.03,28.24 94.05,28.24 94.97,29.16 98.14,29.16 100.09,31.11 111.39,31.11 v2(111.6,31.32)
  IN08 w0.091: v2(177.9,53.42) 177.9,51.77 178.66,51.01 178.66,50.63 178.37,50.34 118.86,50.34 111.6,43.08 v2(111.6,31.32)
  IN10 w0.091: v3(238.47,55.32) 238.35,55.32 237.84,54.82 235.76,54.82 235.43,54.49 235.43,54.33 235.15,54.05 234.74,54.05 234.41,53.72 234.41,53.61 232.94,52.14 232.09,52.14 231.9,51.96 229.02,51.96 228.57,51.51 227.64,51.51 226.49,52.66 225.65,52.66 225.2,53.11 223.57,53.11 220.49,56.18 205.17,56.18 204.36,55.38 196.34,55.38 195.17,54.21 195.17,53.17 194.15,52.15 180.23,52.15 179.47,52.91 178.4,52.91 v2(177.9,53.42)
  BOTTOM w0.076: U5.J2 32.77,53.91 32.51,54.17 32.1,54.17
  BOTTOM w0.089: 29.81,53.8 30.18,54.17 32.09,54.17 32.1,54.17
  BOTTOM w0.097: v2(27.15,53.04) 27.53,53.04 28.07,53.58 29.59,53.58 29.81,53.8 ; v3(238.47,55.32) 237.92,54.77 U2.AV22
LPC_AD2_ESPI_IO2: length 268
  IN05 w0.091: v2(28.29,53.04) 28.67,53.04 29.43,52.28 29.43,49.61 28.8,48.97 28.62,48.97 28.27,48.62 28.27,42.14 29.94,40.47 29.94,39.07 30.32,38.69 38.7,38.69 39.36,39.35 39.75,39.35 40.61,40.21 44.67,40.21 45.56,39.32 47.21,39.32 49.07,37.46 49.07,34.67 55.45,28.29 56.21,28.29 57.12,27.38 62.45,27.38 64.36,25.48 72.05,25.48 74.46,27.89 82.33,27.89 82.9,28.46 93.96,28.46 94.92,29.42 98.01,29.42 99.93,31.33 110.95,31.33 111.37,31.75 111.81,31.75 v2(112.24,31.32)
  IN08 w0.091: v2(112.24,31.32) 112.24,43.41 118.95,50.12 179.42,50.12 179.8,50.5 179.8,51.51 179.17,52.15 v2(179.17,53.42)
  IN10 w0.091: v2(179.17,53.42) 179.42,53.42 180.44,52.4 194.01,52.4 194.89,53.28 194.89,54.32 196.22,55.65 204.29,55.65 205.03,56.4 220.58,56.4 223.65,53.33 225.31,53.33 225.73,52.91 226.51,52.91 227.63,51.8 228.49,51.8 229.48,52.78 231.87,52.78 232.32,52.34 232.86,52.34 234.09,53.57 234.09,54.32 234.64,54.87 235.22,54.87 235.81,55.45 237.97,55.45 238.35,55.83 239.36,55.83 v3(239.62,55.58)
  BOTTOM w0.089: 29.81,53.49 30.31,53.98 31.97,53.98
  BOTTOM w0.097: U2.AT19 239.57,55.53 v3(239.62,55.58) ; v2(28.29,53.04) 29.36,53.04 29.81,53.49 ; 31.97,53.98 32.04,53.91 U5.J1
LPC_AD3_ESPI_IO3: length 275
  IN05 w0.091: v2(25.11,53.67) 25.5,53.29 25.5,48.85 23.84,47.2 23.84,39.2 24.09,38.95 25.37,38.95 29.78,34.54 39.59,34.54 41.2,36.15 45.36,36.15 46.15,35.36 46.86,35.36 55.85,26.37 56.49,26.37 56.67,26.19 56.67,24.32 57.39,23.6 62.36,23.6 63.23,24.46 72.49,24.46 74.9,26.88 82.77,26.88 83.41,27.51 94.33,27.51 95.19,28.37 98.54,28.37 100.55,30.39 111.65,30.39 v2(111.98,30.05)
  IN08 w0.091: v2(111.98,30.05) 111.09,30.94 111.09,42.88 118.76,50.55 176.3,50.55 v2(176.63,50.88)
  IN10 w0.091: v2(176.63,50.88) 177.39,50.12 196.31,50.12 198.72,52.53 217.52,52.53 220.01,50.04 225.34,50.04 225.65,49.74 230.73,49.74 231.24,50.24 236.19,50.24 236.32,50.12 236.32,49.86 236.7,49.48 237.2,49.48 237.33,49.61 237.33,49.83 239.27,51.77 240,51.77 v3(240.56,52.33)
  BOTTOM w0.076: U5.H2 32.77,53.41 32.51,53.67 31.97,53.67
  BOTTOM w0.089: 29.81,53.17 30.45,53.8 31.84,53.8
  BOTTOM w0.097: v2(25.11,53.67) 26.18,52.61 29.26,52.61 29.81,53.17 ; v3(240.56,52.33) 240.7,52.18 U2.BD16 ; 31.97,53.67 31.84,53.8
