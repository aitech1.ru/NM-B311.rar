# Allegro board NM-B311.BRD (continued)
## Nets (continued)
+1.2V_VDDQ: C39.1 C40.1 C41.1 C42.1 C43.1 C44.1 C45.1 C46.1 C47.1 C48.1 C49.1 C55.1 C56.1 C57.1 C58.1 C59.1 C60.1 C61.1 C62.1 C63.1 C64.1 C72.1 C73.1 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 C82.1 C88.1 C89.1 C90.1 C91.1 C92.1 C93.1 C94.1 C95.1 C96.1 C97.1 C105.1 C106.1 C107.1 C108.1 C109.1 C110.1 C111.1 C112.1 C113.1 C114.1 C115.1 C121.1 C122.1 C123.1 C124.1 C125.1 C126.1 C127.1 C128.1 C129.1 C130.1 C138.1 C139.1 C140.1 C141.1 C142.1 C143.1 C144.1 C145.1 C146.1 C147.1 C148.1 C154.1 C155.1 C156.1 C157.1 C158.1 C159.1 C160.1 C161.1 C162.1 C163.1 C171.2 C174.2 C426.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 JDIMM3.12 JDIMM3.33 JDIMM3.54 JDIMM3.75 JDIMM3.96 JDIMM3.111 JDIMM3.112 JDIMM3.117 JDIMM3.118 JDIMM3.123 JDIMM3.124 JDIMM3.129 JDIMM3.130 JDIMM3.135 JDIMM3.136 JDIMM3.141 JDIMM3.142 JDIMM3.147 JDIMM3.148 JDIMM3.153 JDIMM3.154 JDIMM3.159 JDIMM3.160 JDIMM3.163 JDIMM3.178 JDIMM3.199 JDIMM3.220 JDIMM3.241 JDIMM4.12 JDIMM4.33 JDIMM4.54 JDIMM4.75 JDIMM4.96 JDIMM4.111 JDIMM4.112 JDIMM4.117 JDIMM4.118 JDIMM4.123 JDIMM4.124 JDIMM4.129 JDIMM4.130 JDIMM4.135 JDIMM4.136 JDIMM4.141 JDIMM4.142 JDIMM4.147 JDIMM4.148 JDIMM4.153 JDIMM4.154 JDIMM4.159 JDIMM4.160 JDIMM4.163 JDIMM4.178 JDIMM4.199 JDIMM4.220 JDIMM4.241 PC820.1 PC1258.1 PJ15.1 PJ402.1 PJ403.1 PR440.2 PR1407.2 PU1254.3 R84.2 R89.2 R93.2 U56.5
+1.2VDDQ: PC403.2 PC408.1 PC409.1 PJ402.2 PJ403.2 PL401.2 PR441.2 PU401.5 PU401.19
+1.05V_DGPU_PGOOD: D51.2 D70.1 PR722.1
+1.8V: PJ602.1 PJ611.1 R284.2
+1.8V_AON: C1333.1 C1339.1 C1401.1 C1402.1 C2204.1 C2210.1 C2211.1 C2212.1 C2213.1 G2.BA10 G2.BB14 G2.BC14 PR27.2 PR32.2 PR3549.2 PR3551.1 PR3561.1 Q93.2 R796.1 R944.2 R962.1 R974.1 R975.1 R977.1 R980.1 R982.1 R983.2 R986.1 R987.1 R990.1 R993.1 R995.1 R999.1 R1000.1 R1002.1 R1016.1 R2150.1 R2152.1 R2154.1 R2183.1 R2251.1 R2254.1 R2255.1 R2256.1 R2264.2 R2271.1 U62.5 U63.5 U2021.3 U2021.7 U2021.8
+1.8V_MAIN: C666.1 C667.1 C668.1 C669.1 C676.1 C677.1 C678.1 C683.1 C684.1 G2.BB26 G2.BB27 G2.BB29 G2.BB32 G2.BC26 G2.BC27 G2.BC29 G2.BC30 G2.BC32 G2.BD27 G2.BD30 L18.2 L20.2 PJ1506.1 R16.1 R963.2 R2147.1 R2267.2
+1.8V_SW: PJ1255.1 PU8.A2 PU1607.3
+1.8V_SW_PGOOD: D2007.2 PC15.1 PU7.B2 R2183.2
+1.8VA_AUD: C300.2 C301.2 C322.2 C323.1 R284.1 U7.24
+1.8VALW_PCH: C547.2 R290.2
+1.8VP: PC3529.1 PC3530.1 PC3536.1 PC3537.1 PC3540.1 PJ602.2 PJ1255.2 PL1807.2 PR3458.2 PR3459.1
+1.55V_DGPU_PGOOD: PR704.2 R1007.1
+1.55VG: PC706.1 PC707.1 PC730.1 PC731.1 PJ701.2 PJ702.2 PJ1504.2 PL701.2 PL711.2
+1.55VSG: C596.1 C597.1 C598.1 C619.1 C620.1 C2176.1 C2177.1 C2178.1 C2179.1 C2180.1 C2181.1 C2182.1 C2183.1 C2184.1 C2185.1 C2186.1 C2187.1 C2188.1 C2319.1 C2320.1 C2322.1 C2329.1 C2332.1 C2339.1 C2347.1 C2351.1 C2357.1 C2362.1 C2368.1 C2394.1 C2395.1 C2396.1 C2397.1 C2398.1 C2399.1 C2400.1 C2401.1 C2402.1 C2403.1 C2404.1 C2405.1 C2406.1 C2407.1 C2408.1 C2409.1 C2448.1 C2449.1 C2450.1 C2451.1 C2452.1 C2453.1 C2454.1 C2455.1 C2456.1 C2457.1 C2458.1 C2459.1 C2460.1 C2461.1 C2462.1 C2463.1 C2464.1 C2465.1 C2466.1 C2467.1 C2468.1 C2469.1 C2470.1 C2471.1 C2472.1 C2473.1 C2474.1 C2475.1 C2476.1 C2477.1 C2478.1 C2479.1 C2480.1 C2481.1 C2482.1 C2483.1 C2484.1 C2485.1 C2486.1 C2487.1 C2488.1 C2489.1 C2490.1 C2491.1 C2492.1 C2493.1 C2494.1 C2495.1 C2496.1 C2497.1 C2498.1 C2499.1 C2500.1 C2501.1 C2502.1 C2503.1 C2504.1 C2505.1 C2506.1 C2507.1 C2508.1 C2509.1 C2510.1 C2511.1 C2512.1 C2513.1 C2514.1 C2515.1 C2516.1 C2517.1 C2518.1 C2519.1 C2520.1 C2521.1 C2522.1 C2523.1 C2524.1 C2525.1 C2526.1 C2527.1 C2528.1 C2529.1 C2530.1 C2531.1 C2532.1 C2533.1 C2534.1 C2535.1 C2536.1 C2537.1 C2538.1 C2539.1 C2540.1 C2541.1 C2542.1 C2543.1 C2544.1 C2545.1 C2546.1 C2547.1 C2548.1 C2549.1 C2550.1 C2551.1 C2552.1 C2553.1 C2554.1 C2555.1 C2556.1 C2557.1 C2558.1 C2559.1 C2560.1 C2561.1 C2562.1 C2563.1 C2564.1 C2565.1 C2566.1 C2567.1 C2568.1 C2569.1 C2570.1 C2571.1 C2572.1 C2573.1 C2574.1 C2575.1 C2576.1 C2577.1 C2578.1 C2579.1 C2580.1 C2581.1 C2582.1 C2583.1 C2584.1 C2585.1 C2586.1 C2587.1 C2588.1 C2589.1 C2590.1 C2591.1 C2592.1 C2593.1 C2594.1 C2595.1 C2596.1 C2597.1 C2598.1 C2599.1 C2600.1 C2601.1 C2602.1 C2603.1 C2604.1 C2605.1 C2606.1 C2607.1 C2608.1 C2609.1 C2610.1 C2611.1 C2612.1 C2613.1 C2614.1 C2615.1 C2616.1 C2617.1 C2618.1 C2619.1 C2620.1 C2621.1 C2622.1 C2623.1 C2624.1 C2625.1 C2626.1 C2627.1 C2628.1 C2629.1 C2630.1 C2631.1 C2632.1 C2633.1 C2634.1 C2635.1 C2636.1 C2637.1 C2638.1 C2639.1 C2640.1 C2641.1 C2642.1 C2643.1 C2644.1 C2645.1 C2646.1 C2647.1 C2648.1 C2649.1 C2650.1 C2651.1 C2652.1 C2653.1 C2654.1 C2655.1 C2656.1 C2657.1 C2658.1 C2659.1 C2660.1 C2661.1 C2662.1 C2663.1 C2664.1 C2665.1 C2666.1 C2667.1 C2668.1 C2669.1 C2670.1 C2671.1 C2672.1 C2673.1 C2674.1 C2675.1 C2676.1 C2677.1 C2678.1 C2679.1 G2.AA10 G2.AA11 G2.AA42 G2.AA43 G2.AC10 G2.AC11 G2.AC42 G2.AC43 G2.AD10 G2.AD11 G2.AD42 G2.AD43 G2.AF10 G2.AF43 G2.AG10 G2.AG11 G2.AG42 G2.AG43 G2.AJ10 G2.AJ11 G2.AJ42 G2.AJ43 G2.AK10 G2.AK11 G2.AK42 G2.AK43 G2.AM42 G2.AM43 G2.AN43 G2.AR42 G2.AR43 G2.AT43 G2.K12 G2.K14 G2.K15 G2.K17 G2.K18 G2.K20 G2.K21 G2.K23 G2.K24 G2.K26 G2.K27 G2.K29 G2.K30 G2.K32 G2.K33 G2.K35 G2.K36 G2.K38 G2.K39 G2.K41 G2.L14 G2.L15 G2.L18 G2.L20 G2.L21 G2.L23 G2.L24 G2.L26 G2.L27 G2.L30 G2.L32 G2.L33 G2.L35 G2.L36 G2.L39 G2.M10 G2.M43 G2.P10 G2.P11 G2.P42 G2.P43 G2.R10 G2.R11 G2.R42 G2.R43 G2.U10 G2.U11 G2.U43 G2.V10 G2.V42 G2.V43 G2.Y10 G2.Y11 G2.Y42 G2.Y43 PC724.1 PC725.1 PC726.1 PC727.1 PC728.1 PC729.1 PJ701.1 PJ702.1 PJ1504.1 PR3422.2 R607.2 R608.2 R609.2 R610.2 R611.2 R612.2 R613.2 R614.2 R859.1 R867.1 R874.1 R897.1 R900.1 R910.1 R913.1 R1022.1 R1024.1 R2195.2 R2197.2 R2198.2 R2199.2 R2202.2 R2203.2 R2204.2 R2205.2 R2217.1 R2335.1 R2336.1 R2337.1 R2338.1 U48.B1 U48.B3 U48.B12 U48.B14 U48.C5 U48.C10 U48.D1 U48.D3 U48.D11 U48.D12 U48.D14 U48.E5 U48.E10 U48.F1 U48.F3 U48.F12 U48.F14 U48.G1 U48.G2 U48.G4 U48.G11 U48.G13 U48.G14 U48.H3 U48.H12 U48.K3 U48.K12 U48.L1 U48.L2 U48.L4 U48.L11 U48.L13 U48.L14 U48.M1 U48.M3 U48.M12 U48.M14 U48.N5 U48.N10 U48.P1 U48.P3 U48.P11 U48.P12 U48.P14 U48.R5 U48.R10 U48.T1 U48.T3 U48.T12 U48.T14 U55.B1 U55.B3 U55.B12 U55.B14 U55.C5 U55.C10 U55.D1 U55.D3 U55.D11 U55.D12 U55.D14 U55.E5 U55.E10 U55.F1 U55.F3 U55.F12 U55.F14 U55.G1 U55.G2 U55.G4 U55.G11 U55.G13 U55.G14 U55.H3 U55.H12 U55.K3 U55.K12 U55.L1 U55.L2 U55.L4 U55.L11 U55.L13 U55.L14 U55.M1 U55.M3 U55.M12 U55.M14 U55.N5 U55.N10 U55.P1 U55.P3 U55.P11 U55.P12 U55.P14 U55.R5 U55.R10 U55.T1 U55.T3 U55.T12 U55.T14 U60.B1 U60.B3 U60.B12 U60.B14 U60.C5 U60.C10 U60.D1 U60.D3 U60.D11 U60.D12 U60.D14 U60.E5 U60.E10 U60.F1 U60.F3 U60.F12 U60.F14 U60.G1 U60.G2 U60.G4 U60.G11 U60.G13 U60.G14 U60.H3 U60.H12 U60.K3 U60.K12 U60.L1 U60.L2 U60.L4 U60.L11 U60.L13 U60.L14 U60.M1 U60.M3 U60.M12 U60.M14 U60.N5 U60.N10 U60.P1 U60.P3 U60.P11 U60.P12 U60.P14 U60.R5 U60.R10 U60.T1 U60.T3 U60.T12 U60.T14 U2022.B1 U2022.B3 U2022.B12 U2022.B14 U2022.C5 U2022.C10 U2022.D1 U2022.D3 U2022.D11 U2022.D12 U2022.D14 U2022.E5 U2022.E10 U2022.F1 U2022.F3 U2022.F12 U2022.F14 U2022.G1 U2022.G2 U2022.G4 U2022.G11 U2022.G13 U2022.G14 U2022.H3 U2022.H12 U2022.K3 U2022.K12 U2022.L1 U2022.L2 U2022.L4 U2022.L11 U2022.L13 U2022.L14 U2022.M1 U2022.M3 U2022.M12 U2022.M14 U2022.N5 U2022.N10 U2022.P1 U2022.P3 U2022.P11 U2022.P12 U2022.P14 U2022.R5 U2022.R10 U2022.T1 U2022.T3 U2022.T12 U2022.T14 U2023.B1 U2023.B3 U2023.B12 U2023.B14 U2023.C5 U2023.C10 U2023.D1 U2023.D3 U2023.D11 U2023.D12 U2023.D14 U2023.E5 U2023.E10 U2023.F1 U2023.F3 U2023.F12 U2023.F14 U2023.G1 U2023.G2 U2023.G4 U2023.G11 U2023.G13 U2023.G14 U2023.H3 U2023.H12 U2023.K3 U2023.K12 U2023.L1 U2023.L2 U2023.L4 U2023.L11 U2023.L13 U2023.L14 U2023.M1 U2023.M3 U2023.M12 U2023.M14 U2023.N5 U2023.N10 U2023.P1 U2023.P3 U2023.P11 U2023.P12 U2023.P14 U2023.R5 U2023.R10 U2023.T1 U2023.T3 U2023.T12 U2023.T14 U2024.B1 U2024.B3 U2024.B12 U2024.B14 U2024.C5 U2024.C10 U2024.D1 U2024.D3 U2024.D11 U2024.D12 U2024.D14 U2024.E5 U2024.E10 U2024.F1 U2024.F3 U2024.F12 U2024.F14 U2024.G1 U2024.G2 U2024.G4 U2024.G11 U2024.G13 U2024.G14 U2024.H3 U2024.H12 U2024.K3 U2024.K12 U2024.L1 U2024.L2 U2024.L4 U2024.L11 U2024.L13 U2024.L14 U2024.M1 U2024.M3 U2024.M12 U2024.M14 U2024.N5 U2024.N10 U2024.P1 U2024.P3 U2024.P11 U2024.P12 U2024.P14 U2024.R5 U2024.R10 U2024.T1 U2024.T3 U2024.T12 U2024.T14 U2025.B1 U2025.B3 U2025.B12 U2025.B14 U2025.C5 U2025.C10 U2025.D1 U2025.D3 U2025.D11 U2025.D12 U2025.D14 U2025.E5 U2025.E10 U2025.F1 U2025.F3 U2025.F12 U2025.F14 U2025.G1 U2025.G2 U2025.G4 U2025.G11 U2025.G13 U2025.G14 U2025.H3 U2025.H12 U2025.K3 U2025.K12 U2025.L1 U2025.L2 U2025.L4 U2025.L11 U2025.L13 U2025.L14 U2025.M1 U2025.M3 U2025.M12 U2025.M14 U2025.N5 U2025.N10 U2025.P1 U2025.P3 U2025.P11 U2025.P12 U2025.P14 U2025.R5 U2025.R10 U2025.T1 U2025.T3 U2025.T12 U2025.T14 U2026.B1 U2026.B3 U2026.B12 U2026.B14 U2026.C5 U2026.C10 U2026.D1 U2026.D3 U2026.D11 U2026.D12 U2026.D14 U2026.E5 U2026.E10 U2026.F1 U2026.F3 U2026.F12 U2026.F14 U2026.G1 U2026.G2 U2026.G4 U2026.G11 U2026.G13 U2026.G14 U2026.H3 U2026.H12 U2026.K3 U2026.K12 U2026.L1 U2026.L2 U2026.L4 U2026.L11 U2026.L13 U2026.L14 U2026.M1 U2026.M3 U2026.M12 U2026.M14 U2026.N5 U2026.N10 U2026.P1 U2026.P3 U2026.P11 U2026.P12 U2026.P14 U2026.R5 U2026.R10 U2026.T1 U2026.T3 U2026.T12 U2026.T14
+2.5V_MEM: C50.1 C51.1 C52.1 C53.1 C83.1 C84.1 C85.1 C86.1 C116.1 C117.1 C118.1 C119.1 C149.1 C150.1 C151.1 C152.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 JDIMM3.257 JDIMM3.259 JDIMM4.257 JDIMM4.259 PC422.1 PC423.1 PC425.1 PC426.1 PC438.1 PL410.2 PR429.1 PR438.2
+3V: C35.2 C36.1 C68.2 C69.1 C101.2 C102.1 C134.2 C135.1 C179.2 C347.1 C348.2 C553.1 C632.1 C2701.1 C2716.1 JDIMM1.255 JDIMM2.255 JDIMM2.256 JDIMM3.255 JDIMM3.260 JDIMM4.255 JDIMM4.256 JDIMM4.260 JIO1.11 JIO1.12 JIO1.13 JIO1.14 JIO1.15 JIO1.16 L11.1 L12.1 PC1304.1 PC1323.1 PJ8.2 PJ10.2 PJ11.2 PR624.1 PR1240.1 PR1315.2 PR1413.2 PU7.A2 PU1301.8 PU1303.B1 PU1303.B4 PU1307.3 Q1.2 Q1.5 Q2.2 Q2.5 R49.2 R61.2 R99.2 R102.2 R103.2 R106.2 R107.2 R108.1 R109.2 R110.2 R111.2 R112.2 R113.2 R136.1 R161.1 R162.1 R164.2 R165.1 R166.1 R168.2 R169.1 R170.2 R171.2 R173.1 R179.2 R180.2 R181.1 R182.1 R185.2 R186.2 R219.1 R233.1 R241.2 R242.2 R253.1 R254.1 R255.2 R285.2 R303.2 R304.1 R309.1 R337.2 R380.1 R382.2 R421.2 R424.2 R461.1 R548.1 R549.1 R553.1 R566.1 R574.1 R787.1 R827.2 R830.1 R856.2 R2055.1 R2184.1 R2185.1 R2187.1 R2188.1 R2312.2 R2313.2 R2327.2 R2328.2 R2339.1 R2347.2 RP2.1 RP2.2 RP2.3 RP2.4 TP19.1 U4.5 U26.5 U2030.6 U2031.6
+3V_1.8V_EC: C242.2 R233.2 U5.J5
+3V_CAMERA: C433.1 C434.2 JCAM1.1 PR1304.2
+3V_DP_CON: C463.1 C464.1 C465.2 JDP1.20 R410.2 U2030.1
+3V_DPA_REP: C435.1 C436.2 C437.2 C438.2 C439.2 C449.1 C450.2 C2715.2 R382.1 R387.2 R395.2 R396.2 R2108.2 R2109.2 R2144.2 U2015.3 U2015.6 U2015.9 U2015.12 U2015.15 U2015.24 U2015.27 U2015.30 U2015.33 U2015.36 U2016.9
+3V_DPE_REP: C493.2 C496.2 C497.2 C526.1 C527.2 C528.2 C529.1 R421.1 R454.1 R492.1 R510.2 R518.1 R2280.2 U2013.1 U2013.6 U2013.12 U2013.25 U2013.32 U2013.36
+3V_DPF_REP: C507.2 C508.2 C514.2 C538.1 C539.2 C540.2 C573.1 R424.1 R439.2 R487.1 R590.1 R591.1 R2281.2 U2014.1 U2014.6 U2014.12 U2014.25 U2014.32 U2014.36
+3V_EDP: PC1314.1 PR1411.2 PU1307.4 R65.1 R784.2
+3V_EDP_CONN: C427.1 C428.2 JEDP1.17 JEDP1.18 JEDP1.19 JEDP1.20 R65.2 R373.2
+3V_GPU: C2694.1 C2695.1 C2696.1 PR22.1 PR28.2 PR39.2 PR703.1 PR712.1 PR720.1 PR801.2 PR3424.1 PR3428.1 PR3449.1 PR3525.1 Q41.2 Q41.5 Q80.2 Q80.5 R600.1 R797.1 R798.1 R1004.1 R1006.2 R2145.1 R2146.1 R2244.1 R2270.2 R2294.2 R2295.2 R2296.2 R2297.2 R2298.2 R2299.2 U2027.5 U2028.5 U2029.5
+3V_GPU_EN_N: Q94.5 Q94.6 R2260.2
+3V_HDMI_REP: C2166.2 C2167.2 C2168.2 C2169.1 C2170.2 C2721.2 C2722.2 R2130.2 R2131.2 R2137.1 R2143.2 U2019.3 U2019.9 U2019.15 U2019.24 U2019.27 U2019.33 U2019.36
+3V_REP: C2171.2 C2172.1 R2137.2 U2031.1
+3V_SATA: C554.1 C555.2 C556.2 C557.2 R461.2 R462.1 R465.2 R466.2 R467.2 R468.2 R469.2 R470.2 U14.10 U14.20
+3V_SSD1: C574.2 C575.2 C576.2 C577.2 C609.1 C610.1 C611.1 C612.1 JSSD1.2 JSSD1.4 JSSD1.12 JSSD1.14 JSSD1.16 JSSD1.18 JSSD1.70 JSSD1.72 JSSD1.74 PJ10.1 Q9.2 R480.2
+3V_SSD2: C578.2 C579.2 C580.2 C581.2 C613.1 C614.1 C615.1 C616.1 JSSD2.2 JSSD2.4 JSSD2.12 JSSD2.14 JSSD2.16 JSSD2.18 JSSD2.70 JSSD2.72 JSSD2.74 PJ11.1 Q9.5 R486.2
+3V_THERM: C630.1 C631.2 R553.2 R554.1 U25.1
+3V_TP: C641.1 C642.2 JTP1.1 R574.2
+3V_WLAN: C549.2 C550.2 C551.2 C552.2 C603.1 C604.1 C605.2 C606.2 C607.1 C608.1 JWLAN1.2 JWLAN1.4 JWLAN1.72 JWLAN1.74 PJ8.1 Q8.2 R460.2
+3VA_AMP: C349.2 L11.2 U8.14
+3VALW: C250.1 C251.1 C512.2 C622.2 C623.2 L2.1 L21.1 PC434.1 PC513.1 PC719.1 PC1256.1 PC1269.1 PC1301.1 PC1302.1 PC1329.1 PC3539.1 PJ18.1 PJ301.1 PJ610.2 PJ1508.2 PR105.1 PR407.2 PR411.2 PR423.1 PR427.1 PR501.2 PR509.1 PR626.1 PR648.2 PR649.1 PR723.1 PR1221.1 PR1406.2 PR3463.1 PR3464.1 PU403.7 PU501.7 PU702.7 PU1301.1 PU1301.2 PU1301.9 PU1308.1 PU1309.7 R51.2 R64.1 R271.2 R273.2 R286.2 R297.1 R368.1 R588.1 R831.2 R2056.1 R2098.1 U51.1 U58.5 U61.5
+3VALW_AUD: C304.2 C305.2 R286.1 U7.10
+3VALW_EC_FSPI: C308.2 R297.2 U5.D5
+3VALW_LC: C1359.2 C1361.2 C1362.2 C1363.2 C1364.2 C1365.2 C1367.1 C1369.2 L21.2 R380.2 R433.2 R513.1 R524.1 R525.1 R567.1 R620.1 R793.2 R814.2 R825.2 U19.A1 U19.D4 U19.D5 U19.D10 U19.E4 U19.E9 U19.J5 U19.K4 U19.K10
+3VALW_LC_SPI: C475.1 C476.2 R433.1 R783.2 R788.2 U16.8
+3VALW_PCH: C546.2 C2692.2 L38.1 PJ18.2 R115.2 R137.2 R138.2 R139.1 R142.2 R143.2 R150.2 R151.2 R153.2 R155.2 R158.2 R159.2 R167.2 R206.2 R208.2 R210.2 R211.2 R213.2 R215.2 R222.1 R228.1 R229.1 R230.2 R231.2 R266.1 R288.2 R381.1 R534.1 R535.1 R536.1 R875.1 RP1.5 RP1.6 RP1.7 RP1.8
+3VALW_SLG: C505.1 C506.2 R831.1 U22.1
+3VALW_SPI: C177.1 C178.2 R115.1 R116.2 R118.2 R931.1 R936.1 R937.1 R938.1 U3.8
+3VALWP: PC319.1 PC320.1 PC321.1 PJ301.2 PL301.1 PR301.1
+3VD_AMP: C350.2 L12.2 R323.2 U8.30 U8.31
+3VD_AUD: C302.2 C303.2 JCAM1.8 R285.1 R289.2 R292.2 R310.2 U7.7 U7.19
+3VLP: L1.1 PR103.1 PR304.2 PR355.2 R429.1 R569.2
+3VLP_EC: C230.1 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 L1.2 L2.2 L3.1 R232.1 R236.1 R238.1 R243.1 R244.1 R245.1 R246.1 R247.1 R249.1 R250.1 R251.1 R258.1 R259.2 R268.1 R299.1 R379.1 R563.1 R564.1 U5.D4 U5.D10 U5.E4 U5.K4 U5.K10
+3VLP_EC_AVCC: C241.2 L3.2 R557.1 U5.E9
+5V: C292.1 C293.2 C296.1 C297.2 C541.2 L7.1 L8.1 PC1257.1 PC1308.1 PC1325.1 PC3579.1 PJ9.2 PR1309.2 PR1412.2 PU1.3 PU1254.1 PU1304.8 PU1307.1 PU1607.1 R327.1 R341.2 R342.2 R386.2 R559.1 R560.1 TP15.1
+5V_DEBUG: JDBUG1.1 R326.2 R327.2
+5V_FAN1: C637.1 JFAN1.1 R559.2
+5V_FAN2: C639.1 JFAN2.1 R560.2
+5V_HDD: C558.1 C559.1 C560.1 C561.1 C562.2 C563.2 JHDD1.8 JHDD1.9 JHDD1.10 PJ9.1
+5V_HDMI_CON: C542.1 C543.2 C544.2 D2014.2 D2015.2 JHDMI1.18 R440.1
+5V_USB1: C495.1 C1335.1 C2717.1 C2718.1 JUSB1.1 U18.1
+5V_USB2: C624.1 C625.1 C2719.1 C2720.1 JUSB2.1 U21.12
+5V_USB_KB: C1371.1 C1372.1 JKB1.1 JKB1.2 JKB1.3 JKB1.4 JKB1.5 JKB1.6 U50.1
+5VA_AUD: C298.1 C299.2 L8.2 U7.45
+5VALW: C137.1 C494.1 C1370.1 JIO1.1 JIO1.2 JIO1.3 JIO1.4 JIO1.5 JIO1.6 JIO1.7 JIO1.8 JIO1.9 JIO1.10 PC190.2 PC191.2 PC192.2 PC204.1 PC414.1 PC415.1 PC1280.1 PC1305.1 PC1306.1 PC1319.1 PC3599.1 PJ12.2 PJ302.1 PQ904.1 PQ904.2 PQ904.3 PQ905.1 PQ905.2 PQ905.3 PR234.1 PR405.1 PR409.1 PR903.1 PR904.2 PR909.2 PR910.1 PR911.1 PR915.1 PR918.2 PR920.2 PR1002.1 PR1009.2 PR1014.2 PR1020.1 PR1021.1 PR1022.2 PR1023.1 PR1053.2 PR1186.1 PR1200.1 PR1226.1 PR1251.1 PR1401.2 PR1409.2 PR1471.2 PR1502.1 PR1503.2 PR1509.1 PR1510.2 PR1595.2 PR1596.1 PR1597.2 PR1598.1 PR1602.1 PR1603.2 PR1609.1 PR1610.2 PR1616.1 PR1617.2 PR1624.2 PR1625.1 PR1628.1 PR1630.1 PR1631.2 PR1633.2 PR3401.1 PR3442.1 PR3526.1 PR3534.1 PR3536.2 PR3537.1 PR3539.2 PR3577.1 PR3582.1 PR3588.2 PR3598.1 PU402.1 PU1204.18 PU1301.3 PU1303.A3 PU1304.1 PU1304.2 PU1304.3 PU1304.9 PU1608.1 PU1609.1 PU1610.1 Q29.1 R378.2 R810.1 R1010.1 R1014.1 R2260.1 R2265.1 R2268.1 U18.6 U50.6
+5VALW_USB_CHG: C600.1 C602.1 Q29.3 R376.2 R378.1 R503.2 U21.1
+5VALWP: PC312.1 PC318.1 PC322.1 PJ302.2 PL302.2 PR302.1 PU301.14
+5VD_AUD: C294.1 C295.2 L7.2 U7.46 U7.51
+5VLDO: PR312.1 PR1414.2 R326.1 R376.1 R377.1
+12V_PUMP: PC3596.1 PC3597.1 PC3600.1 PC3602.1 PD602.1 PJ1509.2 PR3597.1 PU604.8
+12V_SWF_BOOST: PC668.1 PC669.1 PC670.1 PC671.1 PD601.1 PJ7.2 PR609.1 PU603.8
+AVDD33_LAN: C268.1 C269.2 C270.2 R273.1 U6.16
+AVDDH_LAN: C273.2 R272.2 U6.22
+AVDDHREG_LAN: C271.1 C272.2 R272.1 U6.9
+AVDDL_LAN: C260.1 C261.2 C262.2 C263.2 C264.2 L5.2 L6.1 U6.6 U6.13 U6.19 U6.31
+AVDDVCO_LAN: C265.1 C266.1 C267.2 L6.2 U6.34
+DVDDL_LAN: C255.1 C256.2 C257.2 C258.1 C259.2 L4.2 L5.1 U6.37
+PVCC_AMP: C341.1 C342.1 C343.1 C344.1 C345.1 C346.1 PJ4.1 U8.6 U8.7 U8.41 U8.42 U8.43
+V1.00DX: PC1255.1 PJ1253.2 PR1321.2 PU1252.4
+V1.0U_VCCST_VCCSFR: PR1318.1 PU1308.4
+V3.3A_1.8A_VCCPGPPA: R208.1 R290.1 U2.BA31
+V3.3A_VCCPAZIO: C400.2 C405.2 L38.2 U2.BA15
+V3.3A_VCCPGPPBCH: C221.2 R210.1 U2.BC42 U2.BD40
+V3.3A_VCCPGPPD: R230.1 U2.BA45 U2.BB45 U2.BC44 U2.BC45
+V3.3A_VCCPGPPEF: C223.2 R211.1 U2.AJ41 U2.AL41
+V3.3A_VCCPGPPG: C224.2 R213.1 U2.AD41
+V3.3A_VCCPSPI: R228.2 U2.BE41 U2.BE42 U2.BE43
+V3.3S_VCCATS: C222.1 R219.2 U2.AD13
+VBAT_EC: R235.2 U5.J4
+VCC19P2_1P0: R207.1 U2.N17
+VCC_RTC: C640.1 Q11.1 R114.1 R160.2 R163.2 R225.1 R571.1
+VCC_SWF: C367.1 C368.1 C369.1 C370.1 C371.1 C372.1 PJ7.1 R329.2 U9.15 U9.16 U9.27 U9.28
+VCCAAZPLL_1P0_L: C398.2 C399.1 L39.2 R226.1 U2.AN19
+VCCAMPHYPLL_1P0: C217.1 C316.1 C319.1 R234.2 U2.A43 U2.B43 U2.C44 U2.C45
+VCCAPLLEBB_1P0: R218.1 U2.V28
+VCCAUSB_1P0_L: R224.1 U2.AJ5 U2.AL5
+VCCDSW_1P0: C212.1 R205.1 U2.BA29
+VCCDTS_1P0: R217.2 U2.AD15
+VCCDUSB_1P0: C219.1 R221.2 U2.AC17
+VCCF24_1P0_L: C213.1 C214.1 C215.1 R189.2 R305.2 U2.K2 U2.K3
+VCCF100_1P0: R214.1 U2.R17 U2.V17
+VCCF100OC_1P0: R212.1 U2.U20
+VCCF135_1P0: R209.1 U2.R19
+VCCFHV_2P8: R204.2 U2.AL22
+VCCIO: C240.2 C311.2 C871.1 C872.1 C873.1 PJ1206.1 PR316.2 PR317.2 PR1201.2 R1.1 R2.2 U1.AG12 U1.G15 U1.G17 U1.G19 U1.G21 U1.H15 U1.H16 U1.H17 U1.H19 U1.H20 U1.H21 U1.H26 U1.H27 U1.J15 U1.J16 U1.J17 U1.J19 U1.J20 U1.J21 U1.J26 U1.J27
+VCCMPHY_1P0: C216.1 C314.1 PJ1252.1 R218.2 R234.1 U2.U21 U2.U23 U2.U25 U2.U26 U2.V26
+VCCPDSW_3P3: R206.1 U2.BA24
+VCCPFUSE_3P3: R231.1 U2.BD3 U2.BE3 U2.BE4
+VCCPHVC_3P3: C225.2 R215.1 U2.AN5
+VCCPRIM_1P0: PJ16.1 U2.AA23 U2.AA26 U2.AA28 U2.AC23 U2.AC26 U2.AC28 U2.AE23 U2.AE26 U2.AJ20 U2.AJ21 U2.AJ23 U2.AJ25 U2.Y23 U2.Y25
+VCCPRTC_3P3: C228.1 C229.2 R225.2 U2.BA22
+VCCPRTCPRIM_3P3: C226.1 C227.2 R222.2 U2.BA20
+VCCPUSBDSW_3P3: C220.1 R229.2 U2.W15
+VCCSA: C312.2 C929.2 C930.1 C931.1 C932.1 C933.1 C934.1 C935.1 C936.1 C937.1 C938.2 C939.2 C940.2 C941.1 C942.1 PC1649.1 PC1652.1 PC1653.1 PC1654.1 PC1655.1 PC1656.1 PC1657.1 PC1658.1 PC1660.1 PC1661.1 PC1662.1 PC1663.1 PL1603.4 PR316.1 PR1172.1 U1.J30 U1.K29 U1.K30 U1.K31 U1.K32 U1.K33 U1.K34 U1.K35 U1.L31 U1.L32 U1.L35 U1.L36 U1.L37 U1.L38 U1.M29 U1.M30 U1.M31 U1.M32 U1.M33 U1.M34 U1.M35 U1.M36
+VCCSFR_OC: C950.2 C951.2 PL1202.2 PL1203.2 PR1257.2 U1.BH13 U1.G11
+VCCSFR_OC_S: PC1260.1 PL1202.1 PL1203.1 PU1254.4
+VCCVDDQ_CLK: C949.1 R52.2 U1.Y12
+VDD33_LAN: C252.1 C253.2 C254.2 Q35.2 R271.1 R275.1 R282.2 R477.2 U6.1
AGND: C298.2 C299.1 C300.1 C301.1 C306.1 C307.2 C309.2 C313.2 C315.2 C317.2 C322.1 C323.2 C324.1 C325.2 C326.1 C327.1 J2.2 J3.2 JIO1.63 JIO1.70 JIO1.73 JIO1.76 R315.2 R316.2 R317.2 U7.20 U7.30 U7.42
