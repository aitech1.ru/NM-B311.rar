# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_SI: length 10.1
  BOTTOM w0.076: 35.02,49.67 35.02,50.16 U5.B6
  BOTTOM w0.097: 35.02,49.67 35.02,46.38 34.81,46.18 v1(34.81,45.85) 34.81,41.78 34.01,40.98 RP4.7
EC_SMB_CLK0: length 190.2
  TOP w0.089: 41.28,49.27 40.86,48.85 40.86,47.88 39.92,46.94 38.45,46.94
  TOP w0.097: PR228.1 79.93,10.21 79.62,10.21 79.09,10.75 v3(79.09,10.87) ; 38.45,46.94 v3(37.69,46.18) ; 41.28,49.27 41.88,49.86 41.88,52.28 43.28,53.67 43.28,57.51 39.08,61.7 39.08,61.93 v1(38.7,62.31) R2059.1
  IN03 w0.091: v3(37.05,4.52) 37.05,4.4 37.43,4.02 40.12,4.02 41.88,5.77 41.88,8.44 42.66,9.22 45.67,9.22 46.32,8.57 46.32,6.41 47.06,5.67 50.16,5.67 51.68,7.19 61.18,7.19 62.45,8.46 64.87,8.46 65.87,7.46 72.88,7.46 74,8.57 74,9.08 75.22,10.31 76.53,10.31 76.53,10.31 78.52,10.31 v3(79.09,10.87) 79.09,11 80.74,12.65 87.96,12.65 88.95,13.64 90.14,13.64 91.29,14.78 93.07,14.78 v3(94.41,16.13)
  IN05 w0.091: v3(77.18,31.93) 76.83,31.58 73.76,31.58 70.96,28.78 66.52,28.78 63.85,31.45 57.75,31.45 52.62,36.58 52.62,40.49 48.27,44.83 39.03,44.83 v3(37.69,46.18)
  IN08 w0.091: v3(77.18,31.93) 77.18,19.4 77.44,19.15 77.44,16.57 77.93,16.08 78.97,16.08 79.72,15.32 79.72,13.67 78.84,12.78 78.84,11.4 79.09,11.15 v3(79.09,10.87)
  BOTTOM w0.097: v3(37.05,4.52) 36.31,3.78 29.59,3.78 29.46,3.91 JDBUG1.2 ; R236.2 38.05,46.02 37.85,46.02 v3(37.69,46.18) 37.69,46.94 36.78,47.86 U5.A10 ; PR101.1 94.55,16.13 v3(94.41,16.13)
EC_SMB_CLK1: length 325.4
  TOP w0.097: Q80.6 219.41,121.25 219.17,121.49 211.17,121.49 207.61,117.94 207.61,116.64 206.72,115.76 206.72,111.2 207.49,110.44 v3(208.12,110.44)
  IN03 w0.089: 40.56,48.77 39.93,48.77 38.83,49.86 37.81,49.86 36.04,48.09 v3(32.48,48.09)
  IN03 w0.091: 40.56,48.77 41.63,47.69 46.44,47.69 46.92,48.18 54.72,48.18 55.15,47.75 58.18,47.75 61.31,50.88 61.31,51.51 63.47,53.67 70.96,53.67 72.71,55.43 76.19,55.43 76.8,54.82 86.67,54.82 89.13,57.28 104.19,57.28 106.56,59.64 110.46,59.64 111.47,58.63 126.36,58.63 127.25,57.74 128.62,57.74 129.38,56.98 155.86,56.98 161.45,51.39 197.71,51.39 198.06,51.74 198.19,51.74 198.4,51.53 198.53,51.53 198.92,51.91 198.92,52.04 198.71,52.26 198.71,52.39 199.09,52.77 199.22,52.77 199.43,52.56 199.56,52.56 199.95,52.94 199.95,53.07 199.73,53.28 199.73,53.41 200.25,53.93 200.85,53.93 200.94,53.84 200.94,53.38 201.03,53.29 201.58,53.29 201.67,53.38 201.67,53.84 201.76,53.93 202.3,53.93 202.4,53.84 202.4,53.38 202.49,53.29 203.03,53.29 203.12,53.38 203.12,53.84 203.21,53.93 203.76,53.93 203.85,53.84 203.85,53.38 203.94,53.29 204.48,53.29 204.58,53.38 204.58,53.84 204.67,53.93 205.21,53.93 205.3,53.84 205.3,53.38 205.39,53.29 205.94,53.29 206.03,53.38 206.03,53.84 206.12,53.93 206.66,53.93 206.75,53.84 206.75,53.38 206.85,53.29 207.39,53.29 207.48,53.38 207.48,53.84 207.57,53.93 208.12,53.93 208.21,53.84 208.21,53.38 208.3,53.29 208.84,53.29 208.93,53.38 208.93,53.84 209.03,53.93 209.57,53.93 209.66,53.84 209.66,53.38 209.75,53.29 210.3,53.29 210.39,53.38 210.39,53.84 210.48,53.93 211.02,53.93 211.11,53.84 211.11,53.38 211.21,53.29 211.75,53.29 211.84,53.38 211.84,53.84 211.93,53.93 214.57,53.93 218.79,49.71 218.79,48.21 217.65,47.07 v3(217.65,43.89)
  IN08 w0.091: v3(217.65,43.89) 216.7,43.89 212.98,47.61 210.06,47.61 208.88,48.79 208.88,63.2 204.44,67.64 204.44,106.76 v3(208.12,110.44)
  BOTTOM w0.076: U5.B3 33.27,50.4 33.02,50.15 33.02,49.61
  BOTTOM w0.097: 33.02,49.61 32.86,49.45 32.86,48.47 v3(32.48,48.09) ; U25.10 205.09,110.59 205.58,111.08 207.23,111.08 207.87,110.44 v3(208.12,110.44) ; Q2.1 217.91,45.81 217.7,45.6 R166.2 216.88,44.66 v3(217.65,43.89)
EC_SMB_DAT0: length 188.3
  TOP w0.089: 41.5,49.05 41.12,48.67 41.12,47.7 40.1,46.69
  TOP w0.097: v3(79.72,10.87) 79.98,10.62 PR227.1 ; 41.5,49.05 42.13,49.69 42.13,52.02 43.58,53.47 43.58,57.53 39.59,61.52 v1(39.59,68.41) R2058.1 ; v3(38.8,46.18) 39.18,46.56 39.97,46.56 40.1,46.69
  IN03 w0.091: v3(94.41,15.25) 93.64,14.48 91.47,14.48 90.3,13.31 89,13.31 88.09,12.4 81.25,12.4 v3(79.72,10.87) 78.71,9.86 76.53,9.86 76.53,9.86 75.15,9.86 74.26,8.97 74.26,8.46 72.23,6.43 65.5,6.43 65.12,6.81 61.69,6.81 61.56,6.94 51.78,6.94 50.26,5.41 46.96,5.41 46.07,6.3 46.07,8.46 45.56,8.97 42.77,8.97 42.13,8.33 42.13,5.67 40.23,3.76 36.93,3.76 36.42,4.27 v3(36.42,4.58)
  IN05 w0.091: v3(38.8,46.18) 38.93,46.31 43.92,46.31 44.05,46.43 46.58,46.43 46.86,46.16 47.85,46.16 53.06,40.94 53.06,36.9 58.01,31.96 65.88,31.96 68.55,29.29 70.58,29.29 73.37,32.08 76.17,32.08 76.68,32.59 77.87,32.59 78.07,32.39 v3(78.07,32.01)
  IN08 w0.091: v3(78.07,32.01) 78.2,31.88 78.2,20.91 77.82,20.53 77.82,18.29 80.36,15.75 80.36,11.51 v3(79.72,10.87)
  BOTTOM w0.076: 37.02,49.61 37.02,50.16 U5.B10
  BOTTOM w0.097: 37.02,49.61 37.02,47.96 v3(38.8,46.18) 39.85,45.13 R243.2 ; JDBUG1.3 29.5,4.41 29.84,4.06 36.07,4.06 36.42,4.41 v3(36.42,4.58) ; PR102.1 94.48,15.25 v3(94.41,15.25)
EC_SMB_DAT1: length 325.9
  TOP w0.097: v3(208.12,109.81) 208.53,110.21 208.53,110.67 208.32,110.87 207.44,110.87 206.98,111.33 206.98,115.65 207.87,116.54 207.87,117.86 211.25,121.24 216.68,121.24 216.94,120.98 216.94,120.17 217.26,119.85 Q80.3
  IN03 w0.089: 30.45,47.32 30.83,47.7 30.83,48.97 31.21,49.36 36.8,49.36 37.76,50.32 39.14,50.32
  IN03 w0.091: 30.45,47.32 30.31,47.17 29.03,47.17 v1(28.67,46.82) ; v3(220.39,43.89) 218.92,43.89 218.03,44.78 218.03,46.82 219.17,47.96 219.17,49.69 214.67,54.18 199.99,54.18 197.47,51.66 161.56,51.66 155.97,57.25 129.49,57.25 128.73,58.01 127.36,58.01 126.49,58.88 111.73,58.88 110.74,59.87 106.3,59.87 103.96,57.53 89.04,57.53 86.58,55.07 77.06,55.07 76.48,55.64 72.55,55.64 70.83,53.93 63.34,53.93 61.06,51.64 61.06,51.01 58.99,48.95 46.2,48.95 46.02,48.77 45.33,48.77 44.41,49.69 39.77,49.69 39.14,50.32
  IN08 w0.091: v3(208.12,109.81) 204.69,106.38 204.69,67.77 209.14,63.33 209.14,48.85 210.15,47.83 213.07,47.83 216.5,44.4 219.88,44.4 v3(220.39,43.89)
  BOTTOM w0.076: 32.14,50.66 32.51,50.66 32.77,50.41 U5.B2
  BOTTOM w0.097: Q2.4 218.91,44.54 219.5,43.95 R165.2 220.14,43.64 v3(220.39,43.89) ; 32.14,50.66 30.83,49.36 30.83,48.19 30.04,47.4 29.38,47.4 28.8,46.82 v1(28.67,46.82) ; v3(208.12,109.81) 207.99,109.81 207.11,110.7 205.84,110.7 205.59,110.45 U25.9
EC_SMI_N: length 251.3
  TOP w0.097: R182.2 224.76,67.64 v3(225.27,67.14)
  IN03 w0.091: v2(35.02,38.18) 35.02,39.07 35.4,39.45 40.05,39.45 40.63,38.87 40.63,38.42 40.74,38.31 40.74,34.62 42.89,32.46 57.12,32.46 57.75,31.83 66.83,31.83 68.1,30.56 70.76,30.56 73.08,28.24 76.87,28.24 77.73,27.38 81.88,27.38 82.74,28.24 97.34,28.24 99.82,30.72 109.1,30.72 113.44,35.06 114.57,35.06 115.03,35.51 116.73,35.51 121.01,39.8 121.01,42.05 122.5,43.53 130.89,43.53 v2(134.33,40.08)
  IN05 w0.091: v2(27.02,55.96) 27.15,55.96 27.78,55.32 27.78,52.86 28.11,52.53 28.42,52.53 29.18,51.77 29.18,49.74 28.67,49.23 28.54,49.23 28.05,48.74 28.05,42.05 29.69,40.41 29.69,38.83 30.79,37.73 34.57,37.73 v2(35.02,38.18)
  IN10 w0.091: v2(134.33,40.08) 134.33,41.61 147.03,54.31 159.73,54.31 160.37,54.94 166.17,54.94 168.2,56.98 180.18,56.98 182.72,59.52 182.72,61.8 183.37,62.45 203.79,62.45 204.31,61.93 217.24,61.93 220.24,64.93 220.39,64.93 222.12,66.65 224.78,66.65 v3(225.27,67.14)
  BOTTOM w0.097: v2(27.02,55.96) 27.27,56.21 27.81,56.21 ; v3(225.27,67.14) 225.75,67.14 U2.M45
EC_SMI_N_R: length 4.9
  BOTTOM w0.076: 31.97,55.17 32.51,55.17 32.77,54.91 U5.L2
  BOTTOM w0.089: 29.81,55.96 v1(30.07,55.96) 31.08,55.96
  BOTTOM w0.097: 31.97,55.17 31.88,55.17 31.08,55.96 ; 29.81,55.96 29.69,55.83 28.89,55.83 D1.1
EC_SO: length 9.1
  BOTTOM w0.097: U5.A6 34.77,47.31 v1(34.6,47.13) 34.41,46.94 34.41,45.55 34.59,45.37 34.59,42.07 34,41.48 RP4.6
EC_TEST1: length 12.7
  TOP w0.097: v2(29.31,56.34) 29.31,56.98 v1(28.92,57.36) 28.62,57.05 R259.1
  IN08 w0.089: 29.81,56.85 29.86,56.89 33.45,56.89 33.88,56.47 33.88,53.83 v1(34.79,52.91)
  IN08 w0.091: v2(29.31,56.34) 29.81,56.85
  BOTTOM w0.089: U5.E7 34.79,52.39 v1(34.79,52.91)
EC_THERM_ALERT_N: length 270.7
  TOP w0.097: v2(244.32,106.51) 244.56,106.75 Q93.6
  IN03 w0.089: 41.5,51.01 40.99,51.01 40.74,51.26 40.1,51.26 39.47,50.63 37.56,50.63 36.54,49.61 31.08,49.61 30.45,48.97 30.45,48.21 30.35,48.11 29.81,48.11
  IN03 w0.091: v2(74.14,57.61) 72.99,56.47 63.85,56.47 58.52,51.13 56.36,51.13 55.21,49.99 51.15,49.99 49.68,51.46 42.46,51.46 42.01,51.01 41.5,51.01 ; v3(28.67,47.7) 29.05,47.7 29.46,48.11 29.81,48.11 ; v2(244.32,106.51) 241.52,106.51 240.76,105.74 240.76,91.9 v2(239.36,90.5)
  IN05 w0.091: v2(74.14,57.61) 74.14,57.74 75.95,59.55 92.08,59.55 94.2,61.67 94.2,62.21 94.66,62.66 94.66,63.69 96.23,65.27 97.03,65.27 97.5,65.74 97.5,67.44 103.88,73.82 104.77,73.82 105.41,74.47 108.59,74.47 109.86,75.74 123.9,75.74 128.4,80.24 128.4,86.28 129.29,87.17 134.37,87.17 135.01,87.8 135.01,90.47 138.6,94.06 175.86,94.06 177.55,95.75 208.59,95.75 209.26,95.08 209.26,93.3 209.67,92.89 211.45,92.89 212.57,91.77 216,91.77 217.55,90.22 239.08,90.22 v2(239.36,90.5)
  BOTTOM w0.076: U5.D2 32.52,51.67 31.97,51.67
  BOTTOM w0.097: 31.97,51.67 31.97,51.67 30.5,50.19 30.35,50.19 30.02,49.86 29.69,49.86 29.31,49.48 29.31,48.34 v3(28.67,47.7) 28.54,47.58 R337.1
EC_VCORE2/CK32KE: length 5.4
  BOTTOM w0.097: C243.1 28.42,50.68 28.56,50.68 29.58,51.69 v1(29.99,51.69) 30.61,51.69 31.83,52.91 U5.G1
EC_WRST_N: length 4.8
  TOP w0.097: R246.2 v2(29.59,55.2)
  BOTTOM w0.089: 29.81,55.2 29.86,55.24 31.52,55.24 31.85,54.91
  BOTTOM w0.097: U5.L1 31.85,54.91 ; 29.81,55.2 v2(29.59,55.2) R246.2
EDP_AUX_C_DN: length 4.9
  BOTTOM w0.097: JEDP1.15 199.57,198.47 199.67,198.37 199.67,196.05 199.59,195.96 ; R373.1 199.59,195.96 ; 199.59,195.96 199.67,195.88 199.67,195.55 199.24,195.13 C425.2
EDP_AUX_C_DP: length 4.9
  BOTTOM w0.097: 200.12,196.47 199.94,196.65 199.94,198.35 200.07,198.47 JEDP1.14 ; 200.12,196.47 R374.1 ; 200.12,196.47 199.94,196.29 199.94,195.3 C424.2
EDP_BL_EN: length 71.2
  TOP w0.097: Q5.6 205.69,200.37 v2(205.33,200.74) ; R985.2 v2(209.72,168.23) ; v2(192.53,200.96) 191.86,201.63 186.02,201.63 183.99,199.6 v2(183.99,197.82) 183.99,197.23 183.81,197.06 182.98,197.06 182.42,196.5 C418.2 182.7,196.04 D20.2
  IN08 w0.091: v2(209.72,168.23) 209.9,168.23 210.53,168.86 210.53,172.29 211.8,173.56 211.8,182.58 212.57,183.34 212.57,194.98 209.51,198.04 209.33,198.04 206.63,200.74 v2(205.33,200.74)
  BOTTOM w0.097: JEDP1.30 192.07,200.5 v2(192.53,200.96) 192.53,201.28 192.75,201.5 194.28,201.5 194.53,201.25 194.53,200.61 194.66,200.49 199.99,200.49 201.14,201.63 204.44,201.63 v2(205.33,200.74)
EDP_BL_PWM: length 22.7
  TOP w0.097: R979.2 206.22,195.71 v2(206.22,195.28) 206.22,194.9 205.96,194.64 v2(205.71,194.64)
  IN08 w0.091: v2(191.74,200.99) 191.74,199.85 194.53,197.06 204.95,197.06 206.22,195.79 206.22,195.15 v2(205.71,194.64)
  BOTTOM w0.097: JEDP1.31 191.57,200.82 v2(191.74,200.99)
EDP_RCOMP: length 4.5
  BOTTOM w0.203: U1.D37 188.16,156.61 188.16,156.92 188.23,156.99 188.23,157.99 188.44,158.19
  BOTTOM w0.508: 188.44,158.19 189.25,159.01 R2.1
EDP_TX0_C_DN: length 2.7
  BOTTOM w0.097: JEDP1.11 201.57,198.6 201.46,198.49 201.46,198.26 201.65,198.07 201.83,198.07 202.11,197.78 202.11,197.43 C422.2
EDP_TX0_C_DP: length 2.7
  BOTTOM w0.097: JEDP1.12 201.07,198.6 201.18,198.49 201.18,198.15 201.53,197.8 201.71,197.8 201.84,197.67 201.84,197.46 C423.2
EDP_TX1_C_DN: length 2.9
  BOTTOM w0.097: C421.2 203.87,197.44 203.87,197.66 203.53,198 203.12,198 202.96,198.16 202.96,198.49 203.07,198.6 JEDP1.8
EDP_TX1_C_DP: length 2.9
  BOTTOM w0.097: C419.2 203.6,197.44 203.6,197.54 203.42,197.72 203.01,197.72 202.68,198.05 202.68,198.49 202.57,198.6 JEDP1.9
EDP_UTIL: length 3.3
  BOTTOM w0.097: U1.A33 192.34,154.48 TP1.1
EDP_VDD_EN: length 30.5
  TOP w0.097: v2(206.34,193.12) 206.98,193.12 207.26,193.4 R905.2
  IN05 w0.091: v2(206.34,193.12) 205.2,194.26 205.2,195.66 204.57,196.29 198.22,196.29 195.8,193.88 193.77,193.88 v2(193.14,193.25) 191.99,194.39 191.99,196.04 191.15,196.88 187.32,196.88 v2(187.09,197.11)
  BOTTOM w0.097: PR1410.1 206.52,193.3 v2(206.34,193.12) ; PR1311.2 193.14,194.08 v2(193.14,193.25) ; PR1310.1 PR1313.1 186.49,197.11 v2(187.09,197.11)
EDP_VDD_EN_N: length 1
  BOTTOM w0.254: PQ1405.6 209.9,193.38 210.09,193.2 PR1409.1
FB_1PH_A: length 10.6
  TOP w0.203: v2(124.53,186.9) 124.53,186.92 125.13,187.53 PU1101.17
  TOP w0.254: v2(124.53,186.9) 124.81,186.62 PR1159.1 PC1151.2
  BOTTOM w0.254: PC1149.1 PR1194.1 123.31,184.31 122.7,184.92 v1(122.7,185.7) 122.7,186.29 123.31,186.9 v2(124.53,186.9) 124.56,186.92 124.56,186.95 124.81,187.2 PR1210.2
FB_3PH_A: length 14.6
  TOP w0.203: v2(123.67,196.68) 124.15,196.68 125.13,195.69 PU1101.49
  TOP w0.254: v2(123.67,196.68) 123.16,196.68 122.22,197.62 PR1157.1 PC1158.2
  BOTTOM w0.254: PR1209.2 124.56,196.33 124.21,196.68 v2(123.67,196.68) v1(121.63,196.68) 121.13,196.68 120.69,197.11 120.69,199.04 121.2,199.55 PR1162.1 PC1120.1
FB_3V: length 4.2
  TOP w0.203: PU301.4 44.95,12
  TOP w0.254: 44.95,12 45.18,11.76 45.18,11.54 v1(45.33,11.38) 45.89,10.82 45.89,10.24 PR301.2 PR303.2
FB_5V: length 4.6
  TOP w0.203: PU301.2 44.15,11.82
  TOP w0.254: 44.15,11.82 43.71,11.38 v1(43.15,11.38) 43.15,10.06 PR305.1 PR302.2
FB_REFPLL_AVDD_GPU: length 73.5
  TOP w0.254: v2(227.93,127.84) 227.4,128.38 v1(226.92,128.38)
  TOP w0.356: v3(254.34,141.52) 254.78,141.07 C689.1 ; C688.1 263.78,132.06 v3(264.23,132.52)
  TOP w0.508: v2(227.93,127.84) 227.93,127.59 227.3,126.95 R20.2
  IN03 w0.381: v3(264.23,132.52) 263.62,133.13 263.62,139.91 262.73,140.8 255.06,140.8 v3(254.34,141.52)
  IN03 w0.406: v3(264.23,132.52) 263.62,131.9 263.62,125.05 263.11,124.54 263.11,122.76 262.35,122 245.16,122 243.89,123.27 243.89,124.33 243.55,124.67 237.2,124.67 234.16,127.71 234.16,128.48 233.65,128.98 228.7,128.98 227.93,128.22 v2(227.93,127.84)
  BOTTOM w0.254: v3(264.23,132.52) 264.34,132.52 G2.L29 ; G2.AF42 254.34,141.62 v3(254.34,141.52)
FBA_DEBUG0: length 10.2
  TOP w0.097: v3(259.39,153.77) 259.39,156.61 R607.1
  BOTTOM w0.097: v3(259.39,153.77) 258.81,153.19 258.81,150.86 258.67,150.73 258.67,149.38 258.84,149.21 258.84,148.53 258.6,148.3 258.6,147.78 G2.Y50
FBA_DEBUG1: length 6.9
  TOP w0.097: R608.1 248.8,150.19 248,150.99 247.53,150.99 247.43,150.9 v3(247.23,150.9)
  BOTTOM w0.097: G2.AR50 247.79,147.67 248.1,147.99 248.1,148.34 248.39,148.63 248.39,150.61 247.98,151.03 247.36,151.03 v3(247.23,150.9)
FBA_VREFC: length 9.8
  BOTTOM w0.097: U48.J14 251.25,171.09
  BOTTOM w0.381: R2212.1 C890.1 249.02,171.09 251.25,171.09 ; R2212.1 248.13,172.09 R2217.2 R2213.1 ; R2212.1 248.03,171.2 v1(247.11,171.2) C889.1 243.73,171.2 U2022.J14
FBA_WCK01: length 27
  IN05 w0.127: v3(260.69,143.67) 260.47,143.46 260.24,143.46 260.11,143.58 260.11,147.72 259.26,148.57 259.26,149.88 258.86,150.29 258.86,154.7 259.3,155.14 259.3,163.72 258.32,164.7 258.32,166.06 258.61,166.35 259.31,166.35 v3(259.71,166.75)
  BOTTOM w0.127: G2.U45 v3(260.69,143.67) ; v3(259.71,166.75) U48.P4
FBA_WCK01_N: length 27
  IN05 w0.127: v3(258.91,166.75) 258.61,166.75 258.04,166.18 258.04,164.59 259.02,163.61 259.02,155.26 258.58,154.81 258.58,150.17 258.98,149.77 258.98,148.46 259.83,147.6 259.83,143.47 260.12,143.18 260.47,143.18 v3(260.69,142.97)
  BOTTOM w0.127: v3(258.91,166.75) U48.P5 ; G2.U44 v3(260.69,142.97)
FBA_WCK23: length 41.9
  IN05 w0.127: v3(258.91,174.75) 258.5,174.34 257.42,174.34 255.35,172.27 252.14,172.27 249.61,169.74 249.61,163.4 254.27,158.74 254.27,149.74 255.9,148.11 255.9,143.58 256.03,143.46 256.27,143.46 v3(256.48,143.67)
  BOTTOM w0.122: G2.AC45 v3(256.48,143.67)
  BOTTOM w0.127: U48.D4 259.31,175.15 v3(258.91,174.75)
FBA_WCK23_N: length 41.9
  IN05 w0.127: v3(256.48,142.97) 256.27,143.18 255.91,143.18 255.62,143.47 255.62,148 253.99,149.63 253.99,158.63 249.33,163.29 249.33,169.85 252.02,172.55 255.23,172.55 257.43,174.75 v3(258.11,174.75)
  BOTTOM w0.122: G2.AC44 v3(256.48,142.97)
  BOTTOM w0.127: v3(258.11,174.75) 258.51,175.15 U48.D5
FBA_WCK45: length 32.9
  IN05 w0.127: v3(245.98,145.07) 245.9,144.99 245.63,144.99 245.46,145.15 245.46,149.56 244.85,150.17 240.54,150.17 236.69,154.02 236.69,164.4 237.37,165.07 237.37,167.57 236.99,167.95 235.67,167.95 v3(235.27,167.55)
  BOTTOM w0.122: G2.AV47 v3(245.98,145.07) ; U2022.D4 v3(235.27,167.55)
FBA_WCK45_N: length 33.1
  IN05 w0.127: v3(236.07,167.55) 236.19,167.67 236.88,167.67 237.09,167.45 237.09,165.19 236.41,164.51 236.41,153.9 240.43,149.89 244.73,149.89 245.18,149.44 245.18,145.04 245.51,144.71 245.8,144.71 245.98,144.52 v3(245.98,144.37)
  BOTTOM w0.127: G2.AV46 245.55,144.54 245.55,144.42 245.64,144.33 245.95,144.33 v3(245.98,144.37) ; U2022.D5 236.47,167.03 236.39,166.95 236.14,166.95 236.07,167.01 v3(236.07,167.55)
FBA_WCK67: length 44.5
  IN05 w0.127: v3(236.07,175.55) 236.47,175.95 237.45,175.95 239.54,173.86 239.54,173.12 240.13,172.53 243.38,172.53 244.12,171.79 244.85,171.79 245.9,170.75 245.9,161.02 250.34,156.58 250.34,150.81 247.5,147.98 247.5,143.58 247.63,143.46 247.87,143.46 v3(248.08,143.67)
  BOTTOM w0.122: U2022.P4 v3(236.07,175.55)
  BOTTOM w0.127: G2.AR45 v3(248.08,143.67)
FBA_WCK67_N: length 44.5
  IN05 w0.127: v3(236.87,175.55) 236.99,175.67 237.33,175.67 239.26,173.74 239.26,173.01 240.02,172.25 243.27,172.25 244,171.51 244.73,171.51 245.62,170.63 245.62,160.91 250.06,156.47 250.06,150.93 247.22,148.09 247.22,143.47 247.52,143.17 247.88,143.17 v3(248.08,142.97)
  BOTTOM w0.127: v3(248.08,142.97) 248.03,142.91 247.68,142.91 247.6,142.99 247.6,143.19 247.67,143.26 247.78,143.26 G2.AR44 ; v3(236.87,175.55) 236.92,175.55 237,175.46 237,175.23 236.93,175.15 236.48,175.15 U2022.P5
FBA_ZQ_1_B: length 4
  TOP w0.097: v3(251.71,170.75) 251.32,170.75 v2(251.14,170.93) 250.49,171.58 249.45,171.58 248.99,171.13 R2211.1
  BOTTOM w0.097: U48.J13 v3(251.71,170.75)
FBA_ZQ_2_B: length 5.1
  TOP w0.097: v3(243.27,170.75) 244.19,171.66 v2(244.57,171.66) 246.56,171.66 246.96,171.26 R826.1
  BOTTOM w0.097: U2022.J13 v3(243.27,170.75)
FBB_DEBUG0: length 6.4
  TOP w0.097: R610.1 275.16,136.57 v3(275.16,135.72)
  BOTTOM w0.097: v3(275.16,135.72) 274.51,136.36 271.28,136.36 271.02,136.62 270.54,136.62 G2.C35
FBB_DEBUG1: length 3.1
  TOP w0.097: v3(271.19,147.77) 271.45,148.03 272.26,148.03 v1(272.38,148.16) 272.51,148.29 272.51,148.85 R609.1
  BOTTOM w0.097: G2.B50 v3(271.19,147.77)
FBB_VREFC: length 29.1
  BOTTOM w0.381: R865.1 C910.1 294.05,156.59 U2023.J14 ; R865.1 294.05,160.28 293.59,160.73 285.21,160.73 282.33,163.62 v1(282.33,163.91) R866.1 281.25,171.2 C909.1 281.1,171.15 U55.J14 ; R865.1 R867.2
FBB_WCK01: length 32.4
  IN05 w0.127: v3(289.7,148.14) 289.7,148.14 289.3,148.54 289.3,149.15 288.99,149.46 287.18,149.46 274.32,136.59 272.03,136.59 270.45,135.01 266.23,135.01 265.9,135.35 265.9,135.66 v3(265.69,135.87)
  BOTTOM w0.127: G2.J33 v3(265.69,135.87) ; U2023.P4 v3(289.7,148.14)
FBB_WCK01_N: length 32.4
  IN05 w0.127: v3(289.7,148.94) 289.7,149.14 289.1,149.74 287.07,149.74 274.21,136.87 271.91,136.87 270.33,135.29 266.35,135.29 266.17,135.47 266.17,135.66 v3(266.39,135.87)
  BOTTOM w0.122: U2023.P5 290.1,149.1 289.94,148.94 v3(289.7,148.94) ; G2.H33 266.69,135.35 266.6,135.26 266.43,135.26 266.33,135.36 266.33,135.81 v3(266.39,135.87)
FBB_WCK23: length 47.9
  IN05 w0.127: v3(265.69,140.07) 265.9,139.86 265.9,139.61 266.17,139.34 270.31,139.34 283.5,152.53 283.5,154.03 286.95,157.48 293.4,157.48 295.08,155.79 295.08,152.48 297.3,150.26 297.3,149.33 v3(297.7,148.94)
  BOTTOM w0.122: U2023.D4 v3(297.7,148.94) ; G2.J39 v3(265.69,140.07)
FBB_WCK23_N: length 48
  IN05 w0.127: v3(266.39,140.07) 266.17,139.86 266.17,139.73 266.28,139.62 270.19,139.62 283.22,152.65 283.22,154.14 286.84,157.76 293.51,157.76 295.36,155.91 295.36,152.6 297.58,150.38 297.58,149.85 v3(297.7,149.74)
  BOTTOM w0.122: U2023.D5 298.1,149.72 298.04,149.79 297.75,149.79 v3(297.7,149.74) ; v3(266.39,140.07) 266.34,140.02 266.34,139.51 266.42,139.43 266.6,139.43 266.69,139.52 G2.H39
FBB_WCK45: length 29.7
  IN05 w0.127: v3(270.33,167.55) 270.73,167.95 271.29,167.95 271.83,167.41 271.83,158.8 265.64,152.61 264.98,152.61 264.58,152.21 264.58,148.78 264.32,148.52 264.32,144.93 v3(264.88,144.37)
  BOTTOM w0.127: U55.D4 270.33,167.55 v3(270.33,167.55) ; G2.L46 v3(264.88,144.37)
FBB_WCK45_N: length 29.7
  IN05 w0.127: v3(264.88,143.67) 264.04,144.51 264.04,148.63 264.3,148.9 264.3,152.32 264.87,152.89 265.53,152.89 271.55,158.91 271.55,167.3 271.3,167.55 v3(271.13,167.55)
  BOTTOM w0.122: v3(271.13,167.55) 271.13,167.32 271.29,167.15 U55.D5
  BOTTOM w0.127: G2.L45 264.41,143.79 264.41,143.65 264.52,143.54 264.76,143.54 v3(264.88,143.67)
FBB_WCK67: length 45.5
  IN05 w0.127: v3(271.13,175.55) 271.53,175.95 271.93,175.95 271.93,175.95 272.32,175.95 274.47,173.8 274.47,173.25 275.26,172.45 278.03,172.45 280.11,170.37 280.11,164.58 277.76,162.23 277.76,156.15 272.51,150.9 269.87,150.9 268.81,149.85 268.81,149.29 268.31,148.79 268.1,148.79 266.53,147.22 266.53,145.65 266.68,145.51 266.82,145.51 v3(267.04,145.72)
  BOTTOM w0.122: G2.H47 v3(267.04,145.72)
  BOTTOM w0.127: U55.P4 v3(271.13,175.55)
FBB_WCK67_N: length 45.5
  IN05 w0.127: v3(267.04,145.02) 266.82,145.23 266.56,145.23 266.25,145.54 266.25,147.34 267.99,149.07 268.2,149.07 268.53,149.41 268.53,149.96 269.75,151.18 272.4,151.18 277.48,156.26 277.48,162.34 279.83,164.7 279.83,170.25 277.91,172.17 275.15,172.17 274.19,173.13 274.19,173.69 272.21,175.67 272.05,175.67 v3(271.93,175.55)
  BOTTOM w0.122: v3(267.04,145.02) 267.03,145.01 266.67,145.01 266.57,144.91 266.57,144.75 266.66,144.67 G2.H46
  BOTTOM w0.127: v3(271.93,175.55) 272.06,175.55 272.16,175.45 272.16,175.24 272.07,175.15 U55.P5
FBB_ZQ_1_B: length 1.4
  TOP w0.097: v3(293.7,156.14) 293.73,156.16 R868.1
  BOTTOM w0.097: U2023.J13 v3(293.7,156.14)
FBB_ZQ_2_B: length 5.7
  TOP w0.097: R869.1 282.39,171.78 281.96,172.21 281.06,172.21 v1(280.26,171.4) 279.8,170.94 278.52,170.94 v3(278.33,170.75)
  BOTTOM w0.097: U55.J13 v3(278.33,170.75)
FBC_DEBUG0: length 3
  TOP w0.097: R612.1 273.45,118.82 v3(273.43,118.84)
  BOTTOM w0.097: G2.A9 272.06,119.24 273.03,119.24 v3(273.43,118.84)
FBC_DEBUG1: length 6.3
  TOP w0.097: R611.1 275.18,130.55 v3(275.01,130.72)
  BOTTOM w0.097: G2.C24 270.4,129.27 270.74,129.61 271.07,129.61 271.29,129.82 274.11,129.82 v3(275.01,130.72)
FBC_VREFC: length 9.5
  BOTTOM w0.381: U2025.J14 294.18,121.54 C1355.1 R895.1 R897.2 R2224.1 295.04,125.68 v1(294.22,125.68) C1354.1 294.22,129.12 U2024.J14
FBC_WCK01: length 26.6
  IN05 w0.127: v3(289.83,113.09) 289.43,113.49 289.43,114.19 285.48,118.14 270.95,118.14 270.72,118.38 267.75,118.38 267.52,118.15 267.52,117.93 v3(267.74,117.72)
  BOTTOM w0.122: G2.F8 v3(267.74,117.72)
  BOTTOM w0.127: U2025.P4 290.22,113.48 v3(289.83,113.09)
FBC_WCK01_N: length 26.6
  IN05 w0.127: v3(289.83,113.88) 289.83,114.19 285.59,118.42 271.06,118.42 270.83,118.65 267.64,118.65 267.25,118.26 267.25,117.93 v3(267.04,117.72)
  BOTTOM w0.122: v3(267.04,117.72) G2.G8 ; U2025.P5 v3(289.83,113.88)
FBC_WCK23: length 39.7
  IN05 w0.127: v3(297.83,113.88) 297.42,114.29 297.42,114.94 295.13,117.23 295.13,120.55 293.36,122.32 287.21,122.32 285.75,120.86 272.87,120.86 272.29,120.28 266.87,120.28 266.6,120.56 266.6,120.96 v3(266.39,121.17)
  BOTTOM w0.122: U2025.D4 v3(297.83,113.88)
  BOTTOM w0.127: G2.H12 v3(266.39,121.17)
FBC_WCK23_N: length 39.7
  IN05 w0.127: v3(297.83,114.68) 297.83,114.69 297.83,114.93 295.41,117.35 295.41,120.67 293.47,122.6 287.09,122.6 285.63,121.14 272.75,121.14 272.18,120.56 266.99,120.56 266.87,120.68 266.87,120.96 v3(267.09,121.17)
  BOTTOM w0.127: v3(267.09,121.17) 267,121.09 267,120.65 267.08,120.57 267.29,120.57 267.39,120.67 G2.G12 ; v3(297.83,114.68) 298.05,114.68 298.23,114.5 U2025.D5
FBC_WCK45: length 31
  IN05 w0.127: v3(290.63,137.52) 291.02,137.12 291.02,136.12 290.58,135.68 284.07,135.68 281.74,133.35 272.06,133.35 271.25,132.55 271.25,131.86 270.25,130.85 266.19,130.85 265.81,131.23 265.81,131.55 v3(265.69,131.67)
  BOTTOM w0.122: U2024.D4 v3(290.63,137.52) ; G2.J27 v3(265.69,131.67)
FBC_WCK45_N: length 31.2
  IN05 w0.127: v3(290.63,136.72) 290.74,136.6 290.74,136.24 290.47,135.96 283.95,135.96 281.63,133.63 271.94,133.63 270.97,132.67 270.97,131.97 270.13,131.13 266.3,131.13 266.08,131.35 266.08,131.6 266.14,131.65 266.37,131.65 v3(266.39,131.67)
  BOTTOM w0.122: v3(266.39,131.67) 266.33,131.61 266.33,131.13 266.42,131.04 266.58,131.04 266.69,131.14 G2.H27
  BOTTOM w0.127: U2024.D5 289.86,136.32 289.77,136.41 289.77,136.62 289.87,136.72 v3(290.63,136.72)
FBC_WCK67: length 39.7
  IN05 w0.127: v3(298.63,136.72) 299.03,136.32 299.03,135.54 296.69,133.2 296.15,133.2 295.65,132.7 295.65,129.76 293.82,127.92 270.83,127.92 270.07,128.69 268.53,128.69 268.34,128.87 267.71,128.87 267.47,128.64 267.47,128.48 v2(267.69,128.27)
  BOTTOM w0.122: v3(298.63,136.72) U2024.P4
  BOTTOM w0.127: G2.G23 v2(267.69,128.27)
FBC_WCK67_N: length 39.7
  IN05 w0.127: v2(266.98,128.27) 267.2,128.48 267.2,128.76 267.59,129.15 268.45,129.15 268.64,128.96 270.18,128.96 270.95,128.2 293.7,128.2 295.37,129.87 295.37,132.82 296.03,133.48 296.57,133.48 298.75,135.65 298.75,135.8 v3(298.63,135.92)
  BOTTOM w0.127: G2.H23 266.69,128.59 266.79,128.69 266.95,128.69 267.06,128.58 267.06,128.35 v2(266.98,128.27) ; v3(298.63,135.92) 298.48,135.77 298.22,135.77 298.14,135.85 298.14,136.23 U2024.P5
FBC_ZQ_1_B: length 1.4
  TOP w0.097: v3(293.82,121.08) 294.58,121.08 R898.1
  BOTTOM w0.097: v3(293.82,121.08) 294.22,120.68 U2025.J13
FBC_ZQ_2_B: length 1.3
  TOP w0.097: R899.1 293.93,129.41 v3(293.83,129.52)
  BOTTOM w0.097: U2024.J13 v3(293.83,129.52)
FBD_DEBUG0: length 9.1
  TOP w0.097: v3(254.1,108.04) v2(254.74,108.04) 255.45,108.04 R614.1
  BOTTOM w0.097: v3(254.1,108.04) 254.97,108.92 254.97,113.45 255.14,113.61 255.14,114.22 G2.AD3
FBD_DEBUG1: length 5.9
  TOP w0.097: R613.1 265.91,110.19 v3(265.98,110.26)
  BOTTOM w0.097: G2.J3 265.98,114.34 265.64,113.99 265.64,113.72 265.38,113.46 265.38,110.87 v3(265.98,110.26)
FBD_VREFC: length 9.5
  BOTTOM w0.381: U60.J14 262.18,91.57 C1374.1 259.23,91.57 258.92,91.27 R909.1 R910.2 C1375.1 R908.1 U2026.J14
FBD_WCK01: length 27
  IN05 w0.127: v3(246.07,95.92) 246.47,96.32 247.17,96.32 247.43,96.58 247.43,98.93 251.27,102.76 251.27,108.45 251.95,109.13 251.95,113.92 251.42,114.45 251.42,117.8 251.88,118.26 252.17,118.26 v3(252.28,118.37)
  BOTTOM w0.122: G2.AJ8 v3(252.28,118.37) ; U2026.P4 v3(246.07,95.92)
FBD_WCK01_N: length 27.2
  IN05 w0.127: v3(252.28,117.67) 252.28,117.84 252.15,117.98 251.99,117.98 251.7,117.68 251.7,114.57 252.23,114.04 252.23,109.02 251.55,108.34 251.55,102.64 247.71,98.81 247.71,96.26 247.31,95.86 246.93,95.86 v3(246.87,95.92)
  BOTTOM w0.122: v3(252.28,117.67) 252.23,117.73 251.86,117.73 251.76,117.63 251.76,117.47 251.86,117.37 G2.AJ7 ; v3(246.87,95.92) 247.11,95.92 247.27,95.76 U2026.P5
FBD_WCK23: length 39.3
  IN05 w0.127: v3(246.87,87.92) 247.27,88.32 248.1,88.32 250.21,90.43 253.76,90.43 255.57,92.23 255.57,92.97 255.37,93.17 255.37,100.55 256.6,101.79 256.6,112.8 255.72,113.68 255.72,118.45 255.59,118.58 255.4,118.58 v3(255.19,118.36)
  BOTTOM w0.127: U2026.D4 v3(246.87,87.92) ; G2.AD8 v3(255.19,118.36)
FBD_WCK23_N: length 39.3
  IN05 w0.127: v3(247.67,87.92) 247.79,88.04 248.22,88.04 250.33,90.15 253.88,90.15 255.85,92.11 255.85,93.09 255.65,93.29 255.65,100.44 256.88,101.67 256.88,112.92 256,113.8 256,118.57 255.71,118.86 255.39,118.86 v3(255.18,119.07)
  BOTTOM w0.127: G2.AD9 v3(255.18,119.07) ; U2026.D5 v3(247.67,87.92)
FBD_WCK45: length 28.6
  IN05 w0.127: v3(265.69,116.97) 265.78,117.06 266.06,117.06 266.22,116.9 266.22,114.28 266.97,113.53 268.03,113.53 268.35,113.21 268.35,109.8 270.6,107.55 270.6,99.69 268.95,98.04 268.95,95.08 269.31,94.73 270.24,94.73 v3(270.63,95.12)
  BOTTOM w0.122: U60.D4 v3(270.63,95.12) ; G2.J6 v3(265.69,116.97)
FBD_WCK45_N: length 28.8
  IN05 w0.127: v3(269.83,95.12) 269.72,95.01 269.42,95.01 269.23,95.2 269.23,97.92 270.88,99.57 270.88,107.67 268.63,109.92 268.63,113.33 268.15,113.81 267.08,113.81 266.5,114.39 266.5,117.12 266.28,117.34 265.85,117.34 265.69,117.5 v3(265.69,117.67)
  BOTTOM w0.122: U60.D5 269.43,95.28 269.59,95.12 v3(269.83,95.12)
  BOTTOM w0.127: v3(265.69,117.67) 265.74,117.72 266.2,117.72 266.28,117.64 266.28,117.43 266.21,117.36 265.99,117.36 G2.J7
FBD_WCK67: length 41.5
  IN05 w0.127: v3(262.79,118.37) 262.68,118.26 262.42,118.26 262.03,117.87 262.03,113.96 262.27,113.72 262.27,101.13 259.77,98.63 259.77,92.54 261.09,91.21 262.23,91.21 263.17,90.28 265.72,90.28 266.46,89.54 266.46,88.85 268.58,86.73 269.44,86.73 v3(269.83,87.12)
  BOTTOM w0.122: U60.P4 v3(269.83,87.12) ; G2.P8 v3(262.79,118.37)
FBD_WCK67_N: length 41.8
  IN05 w0.127: v3(269.03,87.12) 268.93,87.02 268.68,87.02 266.74,88.96 266.74,89.65 265.83,90.56 263.28,90.56 262.35,91.49 261.21,91.49 260.05,92.66 260.05,98.51 262.55,101.02 262.55,113.84 262.31,114.08 262.31,117.76 262.54,117.98 262.68,117.98 262.79,117.88 v3(262.79,117.67)
  BOTTOM w0.122: v3(262.79,117.67) 262.74,117.72 262.25,117.72 262.12,117.6 262.12,117.46 262.22,117.37 G2.P7
  BOTTOM w0.127: v3(269.03,87.12) 268.7,87.12 268.58,87.24 268.58,87.52 268.66,87.6 269.35,87.6 U60.P5
FBD_ZQ_1_B: length 1.4
  TOP w0.097: R911.1 254.07,91.16 v3(254.07,91.92)
  BOTTOM w0.097: U2026.J13 v3(254.07,91.92)
FBD_ZQ_2_B: length 1.3
  TOP w0.097: R912.1 262.53,91.81 v3(262.63,91.92)
  BOTTOM w0.097: U60.J13 v3(262.63,91.92)
FBVDD_VCC_SENSE: length 114.1
  TOP w0.254: R1025.2 274.42,148.92 275.43,147.91 v2(275.81,147.91)
  IN10 w0.254: v2(275.81,147.91) 275.69,147.91 275.05,148.54 275.05,149.43 286.48,160.86 286.48,161.75 v2(286.35,161.88)
  BOTTOM w0.254: v2(286.35,161.88) 286.48,162 286.48,162.85 287.16,163.53 302.01,163.53 306.8,158.73 306.8,124 305.53,122.73 305.53,113.52 307.47,111.59 308.2,111.59 310.99,108.79 310.99,96.6 309.47,95.08 308.15,95.08 PR3421.2
FBVDD_VSS_SENSE: length 110.4
  TOP w0.254: v2(275.81,148.54) 275.43,148.54 275.18,148.8 275.18,149.1 R1026.2
  IN10 w0.254: v2(286.99,161.88) 286.86,161.75 286.86,160.61 275.43,149.18 275.43,148.92 v2(275.81,148.54)
  BOTTOM w0.254: PR3414.2 308.15,95.46 309.31,95.46 310.61,96.76 310.61,108.63 308.04,111.2 307.31,111.2 305.15,113.36 305.15,122.89 306.42,124.16 306.42,158.58 301.85,163.15 287.37,163.15 286.86,162.64 286.86,162 v2(286.99,161.88)
FBVDDQ_BS1: length 1.5
  BOTTOM w0.254: 300.96,99.39 301.17,99.18 PU701.1
  BOTTOM w0.508: PR3404.1 300.32,100.03 300.96,99.39
FBVDDQ_BS2: length 1.9
  BOTTOM w0.254: PU701.15 301.17,95.8 300.7,95.33
  BOTTOM w0.508: 300.7,95.33 300.07,94.69 PR3409.1
FBVDDQ_COMP: length 3.7
  BOTTOM w0.254: PR3419.1 PR3418.1 302.99,94.26 PC196.1 302.74,94.52 302.74,95.08 302.37,95.44 PU701.12
FBVDDQ_EN_R: length 4.4
  BOTTOM w0.097: PU701.3 301.97,100.21 PC704.1 302.41,100.33 302.61,100.54 302.61,102.24 PR3567.1
FBVDDQ_FB: length 7.3
  BOTTOM w0.254: PR3420.1 308.02,93.68 307.82,93.48 PR3417.1 306.57,93.48 PR3574.2 PR3572.2 305.63,93.48 PC3439.2 304.77,93.68 304.45,94 304.17,94 PC196.2 303.85,94.67 303.19,95.33 303.12,95.33 302.77,95.67 PU701.11
FBVDDQ_FBRTN: length 3.9
  BOTTOM w0.254: PR3414.1 PC3436.1 PR3412.1 304.9,95.71 304.77,95.84 304.51,95.84 303.66,96.69 PU701.10
FBVDDQ_FS: length 1.7
  BOTTOM w0.254: PR3416.2 304.74,96.85 304.18,96.85 303.95,97.09 PU701.9
FBVDDQ_HG1: length 9.3
  BOTTOM w0.254: PU701.2 301.57,99.69 301.21,100.05
  BOTTOM w0.508: 301.21,100.05 301.21,102.06 300.4,102.87 299.47,102.87 297.1,105.24 PQ701.1
FBVDDQ_HG2: length 7.2
  IN03 w0.508: v2(297.18,98.04) 297.56,98.04 298.58,97.03 299.49,97.03 v2(301.34,95.18)
  BOTTOM w0.254: v2(301.34,95.18) 301.57,95.41 PU701.14
  BOTTOM w0.381: PQ702.1 297.1,98.04 v2(297.18,98.04)
FBVDDQ_LG1: length 17.4
  IN03 w0.508: v2(290.19,105.41) 290.19,102.49 291.97,100.71 298.45,100.71 299.56,99.6 v2(299.56,98.12)
  BOTTOM w0.254: PU701.19 299.8,97.89 v2(299.56,98.12)
  BOTTOM w0.508: v2(290.19,105.41) 290.37,105.24 PQ701.8
FBVDDQ_LG2: length 13.4
  IN03 w0.508: v2(299.05,96.35) 295.58,96.35 294.51,97.41 v2(289.69,97.41)
  BOTTOM w0.254: 299.59,96.88 299.71,96.88 299.92,97.09 PU701.17
  BOTTOM w0.508: PQ702.8 v2(289.69,97.41) ; v2(299.05,96.35) 299.59,96.88
FBVDDQ_PH1: length 3.4
  TOP w0.508: PR3405.1 289.27,106.38 287.37,104.47 v2(286.71,104.47)
FBVDDQ_PH2: length 1.3
  TOP w0.508: v2(288.13,91.14) 288.55,91.56 PR3410.1
FBVDDQ_PSI_R: length 6.3
  TOP w0.097: v2(303.12,101.93) 301.97,100.79 PR3589.2
  BOTTOM w0.097: PR3424.2 v2(303.12,101.93) 302.84,101.65 302.84,100.82 PR3423.1 302.37,99.39 PU701.4
FBVDDQ_PVCC: length 10
  TOP w0.254: PR3589.1 301.26,99.7 300.2,98.63 300.2,98 299.87,97.67 PC3407.1
  TOP w0.305: v2(298.96,97.66) 299.26,97.36 PC3407.1
  TOP w0.356: PR3401.2 301.91,95.84 v1(300.45,95.84) 300.2,95.84 299.87,96.17 PC3407.1
  BOTTOM w0.254: v2(298.96,97.66) 299.13,97.49 PU701.18
FBVDDQ_REFIN: length 9.2
  BOTTOM w0.254: PU701.7 304.01,97.89 304.75,98.63 PC3435.1 304.95,98.94 305.28,99.27 305.78,99.27 305.99,99.47 PR3413.1 306.75,99.14 307.05,99.14 308.25,97.95 PR415.1 PR3415.1 307.69,96.6 307.64,96.65 PR3411.2
FBVDDQ_SN1: length 1.1
  TOP w0.508: PC3416.1 PR3405.2
FBVDDQ_SN2: length 1.3
  TOP w0.508: PC3433.1 290.51,92.03 PR3410.2
FBVDDQ_TGR1: length 7.8
  BOTTOM w0.254: 300.07,98.55 300.07,98.5 300.29,98.29 PU701.20
  BOTTOM w0.508: 300.07,98.55 299.05,99.57 PC3409.2 298.2,100.95 298.2,102.87 297.1,103.97 PQ701.2
FBVDDQ_VID_R: length 5.1
  BOTTOM w0.097: PU701.5 302.77,99.18 303.5,99.9 303.7,99.9 304.13,100.33 PC3424.1 304.44,100.33 304.72,100.61 304.72,102.16 PR3408.2
FBVDDQ_VIDBUF: length 2.5
  BOTTOM w0.254: PR3413.2 304.01,98.83 304.01,98.5 303.79,98.29 PU701.6
FBVDDQ_VREF: length 4.5
  BOTTOM w0.254: PR3411.1 306.85,98.02 305.18,98.02 305,97.84 PC3434.1 PU701.8
FP_RST_N: length 2.8
  TOP w0.097: v2(254.1,51.64) 253.59,52.15 v1(253.46,52.15)
  BOTTOM w0.097: R178.2 v2(254.1,51.64)
FPBACK: length 184.5
  TOP w0.097: v3(228.57,66.75) 228.31,67.01 R97.2 ; Q5.2 206.34,198.58 v2(206.85,198.07)
  IN08 w0.091: v2(206.85,198.07) 206.85,196.68 207.23,196.29 207.23,192.74 207.36,192.61 207.74,192.61 210.18,190.17 210.18,183.11 210.03,182.96 210.03,176.48 209.65,176.1 209.14,176.1 208.25,175.21 208.25,171.15 206.98,169.88 206.98,154.64 205.96,153.62 205.96,150.57 199.61,144.22 199.61,129.49 193.77,123.65 193.77,118.19 200.5,111.46 206.85,111.46 207.16,111.76 208.39,111.76 208.55,111.6 208.55,107.95 208.33,107.73 206.43,107.73 204.95,106.25 204.95,72.6 v2(205.84,71.71)
  IN10 w0.091: v2(205.84,71.71) 206.85,70.69 206.85,67.77 212.19,62.44 216.88,62.44 223.11,68.66 226.99,68.66 227.81,67.84 227.81,67.52 v3(228.57,66.75)
  BOTTOM w0.097: U2.P43 228.45,66.63 v3(228.57,66.75)
FRAME_LOCK_N: length 120.4
  TOP w0.097: v2(218.16,119.32) 218.17,119.32 219.04,118.44 220.69,118.44 221.28,119.03 223.54,119.03 224.5,118.06 226.66,118.06 228.19,116.54 233.14,116.54 v1(234.03,115.65) 234.34,115.96 234.75,115.96 235.3,116.51 238.53,116.51 238.88,116.16 239.24,116.16 239.36,116.03 239.36,115.32 239.26,115.22 239.26,114.18 239.81,113.63 v3(239.81,113.44)
  IN08 w0.091: v2(218.16,119.32) 217.38,120.09 212.57,120.09 211.42,121.24 210.84,121.24 207.36,124.72 207.36,127.33 207.99,127.97 207.99,129.24 207.82,129.41 207.82,144.69 211.09,147.95 211.09,161.07 208.25,163.91 208.25,168.61 208.96,169.32 209.98,169.32 210.23,169.57 210.23,172.37 211.42,173.56 211.42,182.58 212.31,183.47 212.31,192.36 v2(211.55,193.12)
  BOTTOM w0.097: R2271.2 208.17,196.04 R780.2 208.42,195.8 Q49.6 209.27,195.4 209.52,195.15 210.53,195.15 211.04,194.64 211.04,193.63 v2(211.55,193.12) ; G2.BG2 v3(239.81,113.44)
FRAME_LOCK_N_R: length 4.3
  BOTTOM w0.097: Q49.1 209.1,196.88 R780.1 208.07,197.06 R894.1 206.8,196.55 205.78,196.55 R784.1
GC6_FB_EN: length 99.6
  TOP w0.097: v3(242.46,116.26) 242.89,115.83 R660.2 ; R2189.1 298.04,78.57 v1(297.91,78.69) 297.91,79.53 v2(298.34,79.96)
  IN10 w0.091: v3(242.46,116.26) 242.46,116.23 243.55,115.14 243.55,110.7 243.33,110.47 243.33,101.71 240.25,98.63 240.25,87.12 239.62,86.49 239.62,84.57 242.49,81.7 250.08,81.7 250.54,81.23 266.74,81.23 267,81.49 277.34,81.49 277.67,81.16 297.15,81.16 v2(298.34,79.96)
  BOTTOM w0.097: v3(242.46,116.26) 242.59,116.26 G2.BB5
GC6_FB_EN_LS: length 123.6
  TOP w0.097: D2012.2 v2(295.62,74.88) 296.13,74.88 v1(296.26,74.76) ; R2262.2 295.42,78.9 v2(298.55,75.77) 299.05,76.28 300.45,76.28 300.78,76.61 R2187.2 301.34,76.79 Q86.3
  IN05 w0.091: v2(257.52,69.8) 257.78,70.06 261.91,70.06 264.19,67.77 274.35,67.77 276.51,69.93 279.43,69.93 280.83,68.53 284.83,68.53 286.1,67.26 v2(288,67.26)
  IN08 w0.091: v2(257.52,69.8) 257.78,69.8 258.29,69.29 258.29,62.69 257.14,61.55 257.14,60.02 257.52,59.64 258.41,59.64 258.67,59.39 258.67,53.29 257.5,52.12 253.05,52.12 252.95,52.02 252.06,52.02 251.94,52.15 249.4,52.15 248.76,51.51 233.27,51.51 231.49,53.29 v3(231.49,53.42) ; v2(295.62,74.88) 295.62,73.87 296.13,73.36 296.13,69.17 293.47,66.5 293.47,63.45 291.69,61.67 287.12,61.67 286.23,62.56 286.23,66.37 287.12,67.26 v2(288,67.26)
  BOTTOM w0.097: U2.BA35 231.37,53.3 v3(231.49,53.42) ; v2(298.55,75.77) 297.66,74.88 v2(295.62,74.88)
GPU_ALL_PGOOD: length 74.5
  TOP w0.097: v2(287.62,71.96) 287.97,72.31 D71.2 D70.2 D69.2 290.29,73.14 290.4,73.03 R1007.2 R1006.1 ; R113.1 230.91,63.07 230.22,63.75 v1(229.71,63.75) 229.33,63.38 v3(229.33,63.33)
  IN05 w0.091: v2(254.6,69.8) 255.62,70.82 262.22,70.82 264.51,68.53 274.03,68.53 276.19,70.69 280.38,70.69 282,72.31 287.27,72.31 v2(287.62,71.96)
  IN08 w0.091: v2(254.6,69.8) 254.35,69.8 252.95,68.41 252.95,67.01 252.06,66.12 249.14,66.12 245.97,62.94 241.9,62.94 241.14,62.18 240,62.18 239.87,62.06 232.38,62.06 230.6,63.83 229.97,63.83 229.46,63.33 v3(229.33,63.33)
  BOTTOM w0.097: U2.W39 229.03,63.63 v3(229.33,63.33)
GPU_B+: length 27.2
  TOP w0.356: PR818.2 v2(294.48,190.2)
  IN05 w0.356: 268.32,191.09 268.45,190.96 293.72,190.96 v2(294.48,190.2)
  vias: v1(206.72,205.69) v2(205.33,205.06) v2(205.33,204.3) v2(205.96,205.06) v2(205.96,204.3) v2(206.6,205.06) v2(206.6,204.3) v2(207.23,205.06) v2(207.23,204.3) v2(207.87,205.06) v2(207.87,204.3) v2(208.5,205.06) v2(208.5,204.3) v2(209.14,205.06) v2(209.14,204.3) v2(209.77,205.06) v2(210.41,205.06) v2(216.12,202.26) v2(216.12,201.63) v2(216.76,202.26) v2(216.76,201.63) v2(217.39,202.26) v2(217.39,201.63) v2(228.7,202.14) v2(228.7,201.5) v2(229.33,202.14) v2(229.33,201.5) v2(229.97,202.14) v2(229.97,201.5) v2(241.01,202.14) v2(241.01,201.5) v2(241.65,202.14) v2(241.65,201.5) v2(242.28,202.14) v2(242.28,201.5) v2(253.08,202.14) v2(253.08,201.5) v2(253.71,202.14) v2(253.71,201.5) v2(254.35,202.14) v2(254.35,201.5) v2(265.27,202.14) v2(265.27,201.5) v2(265.91,202.14) v2(265.91,201.5) v2(266.54,202.14) v2(266.54,201.5)
GPU_COMP: length 4.6
  TOP w0.254: PU1605.30 294,181.67 294.53,181.13 295.6,181.13 296.51,180.22 PC1430.1 PC1431.1
GPU_CSCOMP: length 35.7
  TOP w0.203: PC3576.2 289.99,179.78 291.2,180.99 PU1605.23
  TOP w0.254: v2(276.32,188.67) 276.46,188.54 276.46,187.36 277.59,186.23 277.59,184.86 281.78,180.67 281.78,176.99 282.8,175.97 287.12,175.97 288,176.86 290.54,176.86 291,177.32 PR1446.1 291,178.87 PR1447.2 290.87,178.9 PC803.2 PC3576.2
  BOTTOM w0.254: PH1108.2 272.71,190.96 v1(274.16,190.96) 275.18,190.96 276.45,189.69 276.45,188.8 v2(276.32,188.67)
GPU_CSP1: length 7.3
  TOP w0.254: PU1605.20 289,182.43 v1(287.5,180.93) 287.37,180.8 287.37,179.4 286.73,178.77 PC1426.1 PR3566.1 PR1445.1
GPU_CSP2: length 5.5
  TOP w0.254: PR1442.1 PR3565.1 PC1425.1 287.12,181.44 v1(288,182.32) 288.51,182.83 PU1605.19
GPU_CSP3: length 5.3
  TOP w0.254: PU1605.18 288.09,183.23 v1(287.73,183.59) 287.22,184.1 PC1424.1 PR3564.1 PR1439.1
GPU_CSP4: length 7.5
  TOP w0.254: PR1436.1 PR3563.1 PC1423.1 287.37,186.77 287.5,186.64 v1(287.5,185.12) 287.5,184.48 288.35,183.63 PU1605.17
GPU_CSP5: length 9.6
  TOP w0.254: PR1433.1 PR3562.1 PC1422.1 287.24,189.44 287.5,189.18 287.5,187.91 v1(287.75,187.66) 288,187.4 288,184.61 288.59,184.03 PU1605.16
GPU_CSSUM: length 30
  TOP w0.254: PU1605.22 290.8,181.18 290.16,180.55 289.4,180.55 289.07,180.22 PC3576.1 PC803.1 289.07,178.77 PR1449.2 287.75,178.01 v2(287.5,177.75)
  TOP w0.305: PR1451.1 282.77,181.94 282.42,182.29 v2(282.42,182.32) 282.04,182.71 v1(281.78,182.71)
  TOP w0.356: PR1453.1 v2(283.18,187.66) ; PR1452.1 v2(283.18,184.99) ; v2(283.05,179.4) 283.74,179.4 PR1450.1 ; PR1457.1 v2(283.18,176.99)
  BOTTOM w0.508: v2(283.18,187.66) v2(283.18,184.99) 282.42,184.23 v2(282.42,182.32) 282.42,182.07 283.31,181.18 283.81,181.18 284.32,180.67 284.32,179.94 283.79,179.4 v2(283.05,179.4) 282.42,178.77 282.42,177.24 282.67,176.99 v2(283.18,176.99) 286.73,176.99 v2(287.5,177.75)
GPU_DIFF: length 3.4
  TOP w0.254: PR1462.2 PR1461.2 294.48,179.75 293.2,181.04 PU1605.28
GPU_DISB: length 2.7
  TOP w0.254: v2(292.4,180.55) PU1605.26
  BOTTOM w0.254: v2(292.4,180.55) 292.7,180.24 PR1459.1
GPU_DPA_AUX_DN_SDA: length 225.2
  TOP w0.097: v2(75.15,84.15) 74.85,84.46 v2(74.85,84.92) 74.85,85.17 75.23,85.55 75.23,87.71 R402.1 ; R919.1 238.39,120.31 v3(238.39,119.87)
  IN05 w0.102: v3(238.39,119.87) 238.47,119.95 238.47,120.36 238.15,120.68 236.77,120.68 236.49,120.96 230.7,120.96 230.35,120.6 229.06,120.6 228.17,119.71 226.13,119.71 225.88,119.46 219.9,119.46 218,121.36 209.5,121.36 208.48,120.35 207.44,120.35 200.96,113.87 194.41,113.87 186.28,105.74 128.24,105.74 126.71,104.22 121.89,104.22 117.7,100.03 106.17,100.03 104.24,98.1 104.24,95.58 102.08,93.42 99.16,93.42 97.63,91.9 97.63,81.38 96.98,80.72 94.46,80.72 91.28,77.55 91.28,76.68 88.06,73.46 88.06,69.36 86.72,68.02 81.4,68.02 79.98,69.44 79.98,75.77 77.18,78.57 77.18,80.6 76.55,81.23 75.68,81.23 74.29,82.63 72.49,82.63 71.85,83.26 71.85,84.89 72.38,85.42 74.37,85.42 74.95,84.84 74.95,84.35 v2(75.15,84.15)
  BOTTOM w0.097: v2(75.15,84.15) 74.91,84.4 74.91,84.73 C460.1 ; G2.BH11 v3(238.39,119.87)
GPU_DPA_AUX_DP_SCL: length 225.1
  TOP w0.097: v2(74.26,84.15) 74.57,84.46 74.57,85.28 74.95,85.66 v2(74.95,86.82) 74.95,87.71 R403.1 ; R2208.1 239.36,120.15 v3(239.09,119.87)
  IN05 w0.102: v2(74.26,84.15) 74.26,84.06 74.38,83.95 74.55,83.95 74.7,84.09 74.7,84.74 74.26,85.17 72.49,85.17 72.1,84.79 72.1,83.37 72.59,82.88 74.39,82.88 75.79,81.49 76.66,81.49 77.44,80.7 77.44,78.67 80.23,75.88 80.23,69.55 81.5,68.28 86.62,68.28 87.8,69.46 87.8,73.56 91.03,76.79 91.03,77.66 94.35,80.98 96.87,80.98 97.38,81.49 97.38,92.01 99.05,93.68 101.97,93.68 103.98,95.69 103.98,98.2 106.06,100.28 117.59,100.28 121.78,104.47 126.61,104.47 128.13,106 186.17,106 194.3,114.13 200.85,114.13 207.33,120.6 208.38,120.6 209.39,121.62 218.1,121.62 220.01,119.71 225.77,119.71 226.03,119.97 228.06,119.97 228.95,120.86 230.24,120.86 230.6,121.21 236.6,121.21 236.87,120.93 238.26,120.93 238.72,120.47 238.72,120.05 238.91,119.87 v3(239.09,119.87)
  BOTTOM w0.097: v2(74.26,84.15) 74.64,84.53 74.64,84.85 C461.1 ; G2.BG11 v3(239.09,119.87)
GPU_DPA_HPD_R: length 231.4
  TOP w0.097: v2(66.24,78.82) 66.01,78.82 v1(65.63,79.2) 65.63,79.78 R993.2 66.78,79.65 Q74.3
  IN05 w0.091: v3(239.69,114.97) 239.11,114.39 239.11,112.58 237.61,111.08 236.7,111.08 236.48,110.86 236.48,109.72 233.88,107.12 233.88,105.46 232.88,104.46 219.92,104.46 217.52,102.06 211.42,102.06 208.5,99.14 208.5,98.55 207.87,97.92 205.07,97.92 203.88,96.73 138.29,96.73 135.1,93.53 135.1,92.39 133.45,90.74 133.45,88.7 132.96,88.22 129.15,88.22 127.71,86.78 127.71,80.54 123.66,76.5 109.42,76.5 108.46,75.54 104.44,75.54 100.86,71.96 100.19,71.96 95.89,67.66 95.89,65.85 93.3,63.26 93.3,62.07 91.44,60.21 74.7,60.21 73.88,59.39 72.9,59.39 72.1,60.18 72.1,61.04 66.39,66.75 64.1,66.75 61.82,69.04 61.82,72.6 66.77,77.55 66.77,78.29 v2(66.24,78.82)
  BOTTOM w0.097: G2.BG4 v3(239.69,114.97)
GPU_DPA_SCL: length 18.6
  TOP w0.097: R403.2 74.95,89.23 74.95,89.67 75.3,90.02 77.71,90.02 77.82,90.13 77.82,90.58 v2(77.64,90.76)
  IN10 w0.102: v2(77.64,90.76) 77.83,90.95 77.83,91.73 76.75,92.81 76.75,97.79 76.52,98.02 75.63,98.02 75.53,97.92 v2(75.53,97.5)
  BOTTOM w0.097: U2016.5 75.97,89.98 76.07,90.08 76.54,90.08 76.66,90.2 76.66,90.42 76.55,90.53 76.55,91.01 76.93,91.39 77.78,91.39 77.92,91.25 77.92,91 77.68,90.76 v2(77.64,90.76) ; Q7.4 v2(75.53,97.5)
GPU_DPA_SDA: length 18.7
  TOP w0.097: R402.2 75.22,89.24 75.22,89.55 75.41,89.74 77.82,89.74 78.1,90.02 78.1,90.58 v2(78.28,90.76)
  IN10 w0.102: v2(78.28,90.76) 78.09,90.95 78.09,91.84 77.01,92.92 77.01,97.9 76.63,98.28 75.76,98.28 v2(75.53,98.5)
  BOTTOM w0.097: v2(75.53,98.5) 76.15,98.5 Q7.1 ; U2016.4 76.11,90.38 76.28,90.54 76.28,91.13 76.82,91.67 77.89,91.67 78.2,91.36 78.2,90.84 v2(78.28,90.76)
GPU_DPA_TX0_DN: length 193.4
  IN05 w0.102: v2(72.87,92.03) 72.69,92.21 72.08,92.21 71.62,92.66 71.62,94.55 72.69,95.61 75.33,95.61 77.21,97.49 77.95,97.49 80.61,100.16 85.86,100.16 96.67,110.97 108.97,110.97 114.98,116.98 181.63,116.98 194.96,130.31 197.78,130.31 203.32,135.84 222.73,135.84 225.01,133.56 230.85,133.56 234,130.41 236.48,130.41 236.59,130.52 237.72,130.52 238.26,129.98 239.98,129.98 v3(240.39,129.57)
  BOTTOM w0.097: C451.1 72.48,92.32 72.79,92.32 72.87,92.24 v2(72.87,92.03) ; G2.BF24 v3(240.39,129.57)
GPU_DPA_TX0_DP: length 193.4
  IN05 w0.102: v3(239.69,129.57) 239.53,129.72 238.15,129.72 237.61,130.26 236.7,130.26 236.58,130.15 233.89,130.15 230.74,133.3 224.91,133.3 222.62,135.59 203.42,135.59 197.89,130.05 195.07,130.05 181.74,116.72 115.09,116.72 109.08,110.71 96.77,110.71 85.96,99.9 80.72,99.9 78.05,97.23 77.31,97.23 75.43,95.36 72.79,95.36 71.88,94.44 71.88,92.76 72.18,92.46 73.44,92.46 73.57,92.59 73.57,92.82 73.46,92.92 v2(72.87,92.92)
  BOTTOM w0.097: C448.1 72.5,92.6 72.75,92.6 72.87,92.72 v2(72.87,92.92) ; G2.BG24 v3(239.69,129.57)
GPU_DPA_TX1_DN: length 191.5
  IN05 w0.102: v3(240.39,128.27) 240.39,128.5 240.26,128.63 238.31,128.63 237.96,128.98 236.44,128.98 236.11,129.31 234.84,129.31 234.74,129.42 233.55,129.42 230.67,132.3 224.36,132.3 222.22,134.45 203.68,134.45 198.52,129.29 195.55,129.29 182.04,115.78 115.64,115.78 109.68,109.82 97.15,109.82 84.93,97.6 84.93,96.11 81.74,92.92 78.4,92.92 76.4,90.92 74.17,90.92 73.94,90.68 72.76,90.68 72.64,90.56 72.64,90.35 72.74,90.25 v2(72.87,90.25)
  BOTTOM w0.097: v2(72.87,90.25) 72.87,90.47 72.79,90.55 72.48,90.55 C453.1 ; G2.BF23 v3(240.39,128.27)
GPU_DPA_TX1_DP: length 191.5
  IN05 w0.102: v3(241.09,128.27) 240.47,128.88 238.42,128.88 238.06,129.24 236.55,129.24 236.22,129.57 234.95,129.57 234.85,129.67 233.66,129.67 230.77,132.56 224.47,132.56 222.32,134.7 203.57,134.7 198.42,129.54 195.44,129.54 181.93,116.03 115.54,116.03 109.58,110.07 97.04,110.07 84.68,97.71 84.68,96.22 81.63,93.17 78.3,93.17 76.29,91.17 74.07,91.17 73.83,90.94 73.07,90.94 v2(72.87,91.14)
  BOTTOM w0.097: v2(72.87,91.14) 72.87,90.94 72.75,90.82 72.5,90.82 C452.1 ; G2.BE23 v3(241.09,128.27)
GPU_DPA_TX2_DN: length 190.6
  IN05 w0.102: v2(72.87,88.47) 72.97,88.47 73.29,88.79 74.56,88.79 75.46,89.69 77.38,89.69 77.97,89.11 80.23,89.11 85.95,94.82 85.95,97.35 97.52,108.92 110.08,108.92 116.05,114.89 182.44,114.89 196.03,128.48 199.05,128.48 203.5,132.92 209.16,132.92 209.42,133.18 221.73,133.18 223.64,131.27 230.57,131.27 233.16,128.68 234.21,128.68 234.41,128.48 235.98,128.48 236.23,128.22 237.63,128.22 238.04,127.81 238.65,127.81 239.08,128.24 v3(239.09,128.24)
  BOTTOM w0.097: C455.1 72.48,88.77 72.79,88.77 72.87,88.69 v2(72.87,88.47) ; v3(239.09,128.24) 239.09,128.33 239.33,128.57 G2.BG23
GPU_DPA_TX2_DP: length 190.7
  IN05 w0.102: v2(72.87,89.36) 72.68,89.36 72.58,89.26 72.58,89.04 72.7,88.92 73.06,88.92 73.18,89.04 74.45,89.04 75.36,89.95 77.49,89.95 78.07,89.36 80.13,89.36 85.69,94.93 85.69,97.45 97.41,109.17 109.97,109.17 115.94,115.14 182.34,115.14 195.93,128.73 198.95,128.73 203.39,133.18 209.06,133.18 209.31,133.43 221.84,133.43 223.74,131.52 230.68,131.52 233.27,128.93 234.31,128.93 234.52,128.73 236.09,128.73 236.34,128.48 237.76,128.48 238.15,128.09 238.32,128.09 v3(238.42,128.19)
  BOTTOM w0.097: v2(72.87,89.36) 72.87,89.16 72.75,89.04 72.5,89.04 C454.1 ; v3(238.42,128.19) 238.42,128.31 G2.BH23
GPU_DPA_TX3_DN: length 192.8
  IN05 w0.102: v2(72.87,86.69) 72.97,86.69 73.28,87.01 74.58,87.01 76.09,85.5 77.87,85.5 78.71,86.33 78.71,87.2 79.22,87.71 80.49,87.71 86.96,94.19 86.96,97.11 97.89,108.03 110.84,108.03 116.81,114 182.8,114 196.34,127.54 199.41,127.54 203.8,131.93 221.69,131.93 223.23,130.38 230.43,130.38 233.18,127.63 235.64,127.63 236.22,127.05 239.37,127.05 v3(239.79,127.47)
  BOTTOM w0.097: v2(72.87,86.69) 72.87,86.91 72.79,86.99 72.48,86.99 C457.1 ; G2.BF21 v3(239.79,127.47)
GPU_DPA_TX3_DP: length 192.8
  IN05 w0.102: v2(72.87,87.58) 72.68,87.58 72.59,87.49 72.59,87.23 72.67,87.15 73.06,87.15 73.18,87.27 74.69,87.27 76.2,85.75 77.77,85.75 78.45,86.44 78.45,87.31 79.11,87.96 80.38,87.96 86.71,94.29 86.71,97.21 97.78,108.28 110.73,108.28 116.7,114.25 182.7,114.25 196.23,127.79 199.3,127.79 203.7,132.19 221.79,132.19 223.34,130.64 230.54,130.64 233.29,127.88 235.74,127.88 236.32,127.31 238.92,127.31 v3(239.09,127.47)
  BOTTOM w0.097: v2(72.87,87.58) 72.87,87.38 72.75,87.27 72.5,87.27 C456.1 ; G2.BG21 v3(239.09,127.47)
GPU_DPE_AUX_DN_SDA: length 230.8
  IN05 w0.102: v3(232.25,116.92) 232.36,116.92 232.56,116.71 232.56,116.45 230.6,114.48 226.71,114.48 223.82,111.59 223.82,109.5 223.49,109.17 218.28,109.17 213.58,113.87 209.9,113.87 208.88,112.86 208.88,107.75 208.4,107.27 194.17,107.27 188.2,101.3 135.41,101.3 124.81,90.7 124.81,81.76 122.47,79.42 115.07,79.42 114.29,80.19 109.21,80.19 108.68,79.66 106.3,79.66 105.76,80.19 103.09,80.19 97.4,74.5 95.6,74.5 92.2,71.1 92.2,67.75 87.65,63.2 74.26,63.2 71.22,66.25 71.22,80.09 71.47,80.34 75.15,80.34 75.61,79.89 75.61,79.32 75.44,79.15 75.03,79.15 74.9,79.27 74.9,79.49 75,79.58 v2(75.15,79.58)
  BOTTOM w0.097: G2.BL8 236.58,118.12 236.5,118.2 236.36,118.2 236.27,118.12 236.27,118.1 236.28,118 236.02,117.74 232.78,117.74 232.54,117.5 232.54,117.11 232.35,116.92 v3(232.25,116.92) 232.25,116.75 232.15,116.65 231.48,116.65 231.03,117.1 230.51,117.1 230.38,117.23 230.38,117.38 R925.1 ; C530.1 v2(75.15,79.58)
GPU_DPE_AUX_DP_SCL: length 230.8
  IN05 w0.102: v3(232.89,116.92) 232.82,116.85 232.82,116.34 230.7,114.23 226.82,114.23 224.07,111.48 224.07,109.4 223.59,108.92 218.18,108.92 213.48,113.62 210.01,113.62 209.14,112.75 209.14,107.65 208.5,107.01 194.28,107.01 188.31,101.04 135.51,101.04 125.06,90.6 125.06,81.65 122.58,79.17 114.96,79.17 114.19,79.94 109.32,79.94 108.78,79.4 106.19,79.4 105.66,79.94 103.19,79.94 97.5,74.25 95.71,74.25 92.45,70.99 92.45,67.64 87.75,62.94 74.16,62.94 70.96,66.14 70.96,80.2 71.36,80.6 75.26,80.6 75.86,79.99 75.86,79.76 v2(76.04,79.58)
  BOTTOM w0.097: R924.1 231.04,116.67 231.35,116.36 232.33,116.36 v3(232.89,116.92) 232.82,116.99 232.82,117.39 232.9,117.47 236.13,117.47 236.39,117.72 236.7,117.72 236.72,117.74 237.05,118.07 G2.BK8 ; C531.1 v2(76.04,79.58)
