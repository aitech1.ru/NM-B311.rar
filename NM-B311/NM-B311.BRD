# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTA_MRESET_R: length 7.7
  TOP w0.089: v1(34.67,78.82) 34.67,79.73 v1(34.3,80.1) 33.88,80.52 R2099.2 33.09,80.72
  TOP w0.097: R2093.2 33.09,80.72
  BOTTOM w0.089: U2007.E11 34.25,78.41 v1(34.67,78.82) 34.51,78.97 R2065.2 R2103.2
TBTA_ROSC: length 4.5
  BOTTOM w0.076: 32.48,71.2 32.48,71.62 32.99,72.13 32.99,72.62 U2007.G2
  BOTTOM w0.178: 32.48,71.2 v1(31.72,70.44) 31.36,70.08 31.36,69.8 31.21,69.64 R2079.1
TBTA_RX0_N: length 41.9
  BOTTOM w0.076: U2005.A21 45.93,81.92 arc(46.04,82.03) 45.93,82.15 45.78,82.15 arc(45.69,82.11) 45.6,82.07
  BOTTOM w0.097: JTYPC1.B11 6.18,81.64 arc(6.33,81.54) 6.5,81.51 9.03,81.51 arc(9.12,81.52) 9.19,81.58 10.61,83 arc(10.87,83.16) 11.17,83.22 13.71,83.22 arc(13.77,83.23) 13.81,83.26 arc(13.91,83.33) 14.03,83.36 D62.2 14.43,83.36 arc(14.46,83.35) 14.5,83.33 14.57,83.25 arc(14.6,83.23) 14.64,83.22 15.97,83.22 15.98,83.23 35.74,83.23 arc(36.86,83.01) 37.81,82.38 arc(39.04,81.55) 40.49,81.27 43.76,81.27 arc(44.36,81.39) 44.88,81.73 arc(45.09,81.89) 45.33,81.97 arc(45.47,82.01) 45.6,82.07
TBTA_RX0_P: length 41.9
  BOTTOM w0.076: U2005.B21 46.14,81.77 arc(46.06,81.71) 45.95,81.69 45.66,81.69
  BOTTOM w0.097: 45.66,81.69 45.51,81.72 arc(45.45,81.71) 45.39,81.71 arc(45.22,81.64) 45.07,81.54 arc(44.47,81.13) 43.76,80.99 40.49,80.99 arc(38.94,81.3) 37.62,82.18 arc(36.76,82.76) 35.74,82.96 15.98,82.96 15.97,82.95 14.64,82.95 arc(14.6,82.94) 14.57,82.92 14.5,82.85 arc(14.46,82.83) 14.43,82.82 D63.2 13.97,82.82 arc(13.88,82.84) 13.81,82.88 arc(13.74,82.93) 13.65,82.95 11.17,82.95 arc(10.97,82.91) 10.81,82.8 9.39,81.38 arc(9.22,81.27) 9.03,81.23 6.41,81.23 arc(6.19,81.14) JTYPC1.B10
TBTA_RX1_N: length 41.8
  TOP w0.097: JTYPC1.A10 8.41,77.57 arc(8.45,77.56) 8.49,77.54 arc(8.57,77.49) 8.65,77.48 arc(8.68,77.48) 8.7,77.48 13.53,77.48 arc(13.61,77.5) 13.68,77.55 arc(13.76,77.6) 13.84,77.62 D66.2 14.33,77.62 arc(14.36,77.61) 14.39,77.59 14.47,77.51 arc(14.5,77.49) 14.54,77.48 14.65,77.48 arc(15.12,77.39) 15.51,77.13 16.32,76.32 arc(16.45,76.23) 16.61,76.2 17.16,76.2 arc(18.42,76.45) 19.49,77.16 20.77,78.45 arc(21.38,78.85) 22.09,78.99 arc(22.71,79.12) 23.24,79.47 24.02,80.25 arc(28.59,83.3) 33.99,84.38 38.73,84.38 arc(38.84,84.4) 38.93,84.46 arc(39.07,84.55) 39.24,84.59 39.86,84.59 arc(40.12,84.64) 40.34,84.79 v2(40.42,84.87)
  BOTTOM w0.076: 45.66,84.91 45.96,84.91 arc(45.98,84.91) 46,84.9 46.07,84.89 arc(46.11,84.88) 46.15,84.86 arc(46.19,84.83) 46.22,84.8 46.26,84.76 arc(46.29,84.72) U2005.B15
  BOTTOM w0.097: 45.66,84.91 45.59,84.91 arc(45.54,84.9) 45.5,84.89 45.33,84.84 arc(45.26,84.82) 45.19,84.81 arc(45.16,84.81) 45.12,84.81 41.55,84.81 arc(41.42,84.78) 41.32,84.71 arc(41.18,84.62) 41.02,84.59 40.74,84.59 arc(40.71,84.6) 40.68,84.62 v2(40.42,84.87)
TBTA_RX1_P: length 41.8
  TOP w0.097: JTYPC1.A11 8.37,77.07 arc(8.5,77.1) 8.6,77.17 arc(8.65,77.2) 8.7,77.21 13.59,77.21 arc(13.64,77.2) 13.68,77.17 arc(13.79,77.1) 13.9,77.08 D67.2 14.33,77.08 arc(14.36,77.09) 14.39,77.11 14.47,77.18 arc(14.5,77.2) 14.54,77.21 14.65,77.21 arc(15.01,77.14) 15.32,76.93 16.12,76.13 arc(16.35,75.98) 16.61,75.92 17.16,75.92 arc(18.53,76.19) 19.68,76.97 20.96,78.25 arc(21.48,78.6) 22.09,78.72 arc(22.82,78.86) 23.43,79.27 24.21,80.05 arc(28.7,83.05) 33.99,84.1 38.73,84.1 arc(38.94,84.15) 39.12,84.27 arc(39.17,84.3) 39.24,84.31 39.86,84.31 arc(40.12,84.26) 40.34,84.12 v2(40.42,84.03)
  BOTTOM w0.076: U2005.A15 45.94,84.68 arc(46.06,84.56) 45.94,84.45 45.67,84.45
  BOTTOM w0.097: v2(40.42,84.03) 40.68,84.29 arc(40.71,84.31) 40.74,84.31 41.02,84.31 arc(41.25,84.35) 41.46,84.47 arc(41.53,84.52) 41.62,84.53 45.12,84.53 arc(45.17,84.54) 45.22,84.54 45.22,84.54 45.22,84.53 arc(45.45,84.51) 45.67,84.45
TBTA_SBU1: length 30
  TOP w0.089: 26.97,71.45 27.53,72.01 27.53,74.96 R2089.2
  TOP w0.097: v2(18.79,78.57) 18.78,78.58 D58.2 17.5,78.58 17.49,78.57 13.81,78.57 13.66,78.72 v1(12.16,78.72) 11.97,78.72 11.85,78.85 9.67,78.85 9.4,78.57 8.01,78.57 JTYPC1.A8 ; v2(18.94,74.63) 18.94,73.43 21.43,70.95 26.46,70.95 26.97,71.45
  IN03 w0.091: v2(18.94,74.63) 18.94,78.41 v2(18.79,78.57)
TBTA_SBU2: length 39.3
  TOP w0.097: JTYPC1.B8 5.69,80.12 4.08,78.51 4.08,74.03 4.74,73.36 7.07,73.36 7.3,73.14 D57.2 v2(6.65,72.75) ; v2(13.18,74.25) 13.74,74.81 v1(14.45,74.81) 17.06,74.81 21.36,70.51 26.97,70.51 28.09,71.63 R2090.1
  IN03 w0.091: v2(6.65,72.75) 7.26,73.36 12.29,73.36 v2(13.18,74.25)
TBTA_TX0_N: length 39.4
  TOP w0.097: JTYPC1.A2 8,81.57 8.4,81.57 arc(8.43,81.56) 8.47,81.54 8.52,81.49 arc(8.55,81.46) 8.59,81.46 8.69,81.46 8.8,81.5 arc(8.81,81.51) 8.83,81.51 9.23,81.92 arc(9.48,82.08) 9.77,82.14 arc(9.83,82.15) 9.88,82.19 arc(11.03,82.95) 12.38,83.22 13.67,83.22 arc(13.71,83.23) 13.74,83.25 13.81,83.33 arc(13.85,83.35) 13.88,83.36 D61.2 14.47,83.36 14.6,83.22 23.13,83.22 arc(24.2,83.33) 25.22,83.64 27.87,84.74 arc(30.38,85.5) 32.98,85.75 40.39,85.75 arc(40.99,85.64) 41.5,85.3 arc(41.61,85.13) 41.65,84.93 41.65,82.95 arc(41.67,82.84) 41.73,82.75 arc(41.83,82.69) 41.94,82.67 42.01,82.67 arc(42.21,82.75) v2(42.29,82.95)
  BOTTOM w0.097: v2(42.29,82.95) 42.48,82.75 arc(42.58,82.69) 42.69,82.67 43.17,82.67 arc(43.36,82.7) C2069.2
TBTA_TX0_P: length 39.4
  TOP w0.097: JTYPC1.A3 8,81.07 8.4,81.07 arc(8.43,81.08) 8.47,81.1 8.52,81.15 arc(8.55,81.18) 8.59,81.18 8.73,81.18 arc(8.75,81.18) 8.77,81.19 8.9,81.25 arc(8.95,81.27) 9,81.3 9.43,81.73 arc(9.59,81.83) 9.77,81.87 arc(9.94,81.9) 10.08,81.99 arc(11.14,82.7) 12.38,82.95 13.67,82.95 arc(13.71,82.94) 13.74,82.92 13.81,82.85 arc(13.85,82.83) 13.88,82.82 D60.2 14.47,82.82 14.6,82.95 23.13,82.95 arc(24.25,83.06) 25.32,83.38 27.98,84.48 arc(30.43,85.23) 32.98,85.48 40.39,85.48 arc(40.89,85.38) 41.3,85.1 arc(41.36,85.02) 41.38,84.93 41.38,82.95 arc(41.42,82.74) 41.54,82.55 arc(41.72,82.43) 41.94,82.39 42.01,82.39 arc(42.21,82.31) v2(42.29,82.11)
  BOTTOM w0.097: v2(42.29,82.11) 42.48,82.31 arc(42.58,82.37) 42.69,82.39 43.17,82.39 arc(43.36,82.35) C2068.2
TBTA_TX1_N: length 49.1
  BOTTOM w0.097: JTYPC1.B3 5.77,77.72 arc(5.66,77.67) 5.61,77.55 arc(5.58,77.49) 5.51,77.46 5.31,77.46 arc(5.21,77.48) 5.12,77.53 D65.2 4.85,77.54 arc(4.65,77.5) 4.54,77.67 4.54,79.4 arc(4.58,79.51) 4.69,79.55 4.71,79.55 arc(4.82,79.6) 4.87,79.71 4.87,79.78 arc(4.82,79.89) 4.71,79.94 4.69,79.94 arc(4.58,79.99) 4.54,80.1 4.54,80.17 arc(4.58,80.28) 4.69,80.33 arc(4.8,80.37) 4.85,80.48 4.85,80.56 arc(4.8,80.67) 4.69,80.71 arc(4.58,80.76) 4.54,80.87 4.54,83.95 arc(4.56,84.08) 4.63,84.18 5.16,84.71 arc(5.37,84.85) 5.61,84.9 6.77,84.9 arc(6.97,84.86) 7.14,84.74 arc(7.34,84.61) 7.58,84.56 35.58,84.56 arc(37.11,84.3) 38.46,83.54 arc(39.04,83.16) 39.72,83.03 40.38,83.03 arc(41.11,83.17) 41.73,83.59 arc(41.82,83.65) 41.92,83.67 42.91,83.67 arc(43.24,83.6) C2067.2
TBTA_TX1_P: length 49.1
  BOTTOM w0.097: JTYPC1.B2 5.7,76.92 arc(5.64,76.95) 5.61,77.02 5.61,77.09 arc(5.59,77.14) 5.55,77.17 arc(5.53,77.18) 5.51,77.18 5.08,77.18 arc(5.02,77.17) D64.2 4.79,77.14 arc(4.42,77.3) 4.26,77.67 4.26,83.95 arc(4.31,84.18) 4.44,84.37 4.96,84.9 arc(5.26,85.1) 5.61,85.17 6.77,85.17 arc(7.08,85.11) 7.34,84.94 arc(7.45,84.86) 7.58,84.84 35.58,84.84 arc(37.21,84.56) 38.64,83.75 arc(39.13,83.42) 39.72,83.3 40.38,83.3 arc(41.01,83.43) 41.54,83.78 arc(41.72,83.9) 41.92,83.94 43.44,83.94 arc(43.48,83.95) C2066.2
TBTA_UART_RX: length 4.9
  BOTTOM w0.076: U2007.E2 34.35,72.88 34.51,72.73 34.51,71.98
  BOTTOM w0.102: R2064.2 v1(32.99,70.18) 32.99,70.26 34.51,71.78 34.51,71.98
  BOTTOM w0.178: U2007.F2 U2007.E2
TBTA_USB2_D_N: length 39.5
  IN03 w0.102: v1(47.32,81.88) 47.32,81.96 arc(47.32,81.99) 47.33,82.01 47.35,82.07 arc(47.4,82.13) 47.46,82.18 47.5,82.19 arc(47.51,82.2) 47.53,82.2 47.67,82.2 arc(47.79,82.14) 47.85,82.02 47.85,81.48 arc(47.73,81.2) 47.45,81.08 arc(46.5,80.89) 45.7,80.36 44.04,78.69 43.15,77.8 arc(42.92,77.47) 42.84,77.07 42.84,72.27 arc(42.8,72.06) 42.68,71.87 39.57,68.76 arc(37.82,67.6) 35.76,67.19 34,67.19 arc(33.85,67.21) 33.71,67.27 33.5,67.4 arc(33.41,67.47) 33.35,67.57 33.31,67.66 arc(33.3,67.71) 33.29,67.75 33.29,68.07 arc(33.22,68.45) 33,68.78 28.95,72.83 arc(28.15,73.36) 27.21,73.55 arc(27.08,73.61) v1(27.02,73.74)
  BOTTOM w0.076: 30.12,74.45 30.68,74.45 arc(30.78,74.47) 30.87,74.53 arc(30.98,74.61) 31.12,74.64 31.22,74.64 arc(31.48,74.59) 31.69,74.44 U2007.K5
  BOTTOM w0.097: U2005.D20 47.04,82.16 v1(47.32,81.88) ; 30.12,74.45 30.11,74.45 arc(29.69,74.37) 29.32,74.12 arc(28.94,73.87) 28.49,73.78 v2(27.78,73.78) 27.12,73.78 arc(27.06,73.77) v1(27.02,73.74)
TBTA_USB2_D_P: length 39.6
  IN03 w0.102: v1(47.97,82.48) arc(48.07,82.33) 48.1,82.16 48.1,81.96 48.1,81.92 48.1,81.48 arc(47.91,81.02) 47.45,80.83 arc(46.6,80.66) 45.88,80.18 44.22,78.51 43.33,77.62 arc(43.16,77.37) 43.1,77.07 43.1,72.27 arc(43.04,71.96) 42.86,71.7 39.75,68.59 arc(37.92,67.36) 35.76,66.93 34,66.93 arc(33.78,66.96) 33.58,67.05 33.36,67.18 arc(33.22,67.31) 33.12,67.47 33.08,67.57 arc(33.05,67.66) 33.04,67.75 33.04,68.07 arc(32.98,68.35) 32.82,68.6 28.77,72.65 arc(28.05,73.13) 27.21,73.3 arc(27.08,73.24) v1(27.02,73.1)
  BOTTOM w0.076: U2007.L5 31.26,74.38 arc(31.38,74.26) 31.26,74.14 29.99,74.14 arc(29.74,74.09) 29.53,73.95
  BOTTOM w0.097: U2005.E20 47.65,82.16 v1(47.97,82.48) ; 29.53,73.95 arc(29.05,73.62) 28.49,73.51 27.39,73.51 arc(27.31,73.47) 27.27,73.38 27.27,73.35 arc(27.2,73.18) v1(27.02,73.1)
TBTA_USB2_N_B: length 33
  IN08 w0.102: JTYPC1.B7 7.07,79.45 7.41,79.45 7.55,79.58 7.82,79.58 7.95,79.45 10.78,79.45 11.04,79.71 11.04,80.19 10.79,80.44 v2(10.6,80.44)
  BOTTOM w0.076: 30.88,75.37 30.89,75.38 U2007.L7
  BOTTOM w0.097: v2(10.6,80.44) 10.88,80.16 10.88,80.02 10.84,79.99 D2006.2 10.84,79.53 10.51,79.2 10.51,78.29 11.04,77.75 11.04,76.8 arc(11.17,76.18) 11.52,75.65 11.53,75.64 arc(12.37,75.08) 13.37,74.88 16.23,74.88 arc(16.58,74.95) 16.87,75.15 18.94,77.21 arc(20.01,77.93) 21.28,78.18 v2(22.7,78.18) 24.24,78.18 arc(25.17,78) 25.95,77.48 arc(26.35,77.21) 26.82,77.12 arc(27.04,77.07) 27.24,76.94 28.26,75.92 arc(28.63,75.63) 29.07,75.44 arc(29.33,75.39) 29.59,75.37 30.88,75.37
TBTA_USB2_N_T: length 26.7
  TOP w0.097: JTYPC1.A7 8.01,79.07 8.55,79.07 arc(8.59,79.08) 8.62,79.1 8.67,79.15 arc(8.69,79.17) 8.71,79.18 arc(8.72,79.18) 8.74,79.18 v2(10.64,79.18) 13.18,79.18 13.19,79.17 13.5,79.17 13.53,79.13 D2005.1 14.09,78.91 arc(14.13,78.88) 14.18,78.87 15.21,78.87 arc(15.4,78.91) 15.56,79.01 arc(15.72,79.12) 15.91,79.16 19.87,79.16 arc(20.04,79.09) v2(20.11,78.92)
  IN05 w0.102: v1(26.59,75.14) 26.59,75.41 arc(26.52,75.51) 26.41,75.49 arc(26.37,75.46) 26.33,75.45 26.19,75.45 arc(26.01,75.47) 25.84,75.54 25.83,75.54 arc(25.72,75.61) 25.62,75.7 arc(25.41,76.02) 25.34,76.39 arc(24.52,78.38) 22.53,79.2 20.39,79.2 arc(20.19,79.12) v2(20.11,78.92)
  BOTTOM w0.076: U2007.L6 31.24,74.88 30.67,74.88 arc(30.59,74.86) 30.53,74.82 arc(30.46,74.77) 30.38,74.75 30.14,74.75 30.14,74.75 30.12,74.75
  BOTTOM w0.097: 30.12,74.75 30.02,74.75 28.72,74.75 arc(28.2,74.85) 27.77,75.14 arc(27.51,75.31) 27.21,75.37 27.18,75.37 arc(27.03,75.38) 26.88,75.41 26.88,75.41 arc(26.83,75.43) 26.79,75.44 arc(26.65,75.43) 26.59,75.31 v1(26.59,75.14)
TBTA_USB2_P_B: length 33.1
  IN08 w0.102: v2(11.44,80.44) 11.3,80.3 11.3,79.61 10.88,79.19 7.07,79.19 JTYPC1.B6
  BOTTOM w0.076: 30.88,75.64 30.89,75.64 31.5,75.64 U2007.K7
  BOTTOM w0.097: 30.88,75.64 29.59,75.64 arc(29.36,75.66) 29.14,75.71 arc(28.77,75.87) 28.45,76.11 27.43,77.14 arc(27.15,77.33) 26.82,77.39 arc(26.45,77.46) 26.14,77.67 arc(25.27,78.25) 24.24,78.46 21.28,78.46 arc(19.91,78.19) 18.74,77.41 16.68,75.34 arc(16.47,75.21) 16.23,75.16 13.37,75.16 arc(12.48,75.33) 11.72,75.84 11.71,75.85 11.32,76.8 11.32,76.79 11.32,77.98 11.53,78.18 11.53,79.2 11.19,79.53 D2006.1 11.19,79.99 11.15,80.02 11.15,80.16 v2(11.44,80.44)
TBTA_USB2_P_T: length 26.8
  TOP w0.097: v2(20.11,79.78) 19.87,79.54 arc(19.75,79.46) 19.61,79.43 15.76,79.43 arc(15.65,79.45) 15.55,79.52 arc(15.31,79.68) 15.03,79.74 14.21,79.74 arc(14.13,79.72) 14.07,79.68 D2005.2 13.53,79.48 13.5,79.44 13.31,79.44 13.29,79.46 8.74,79.46 arc(8.71,79.46) 8.67,79.49 8.62,79.54 arc(8.59,79.56) 8.55,79.57 8.01,79.57 JTYPC1.A6
  IN05 w0.102: v1(26.59,75.89) 26.57,75.87 arc(26.28,75.72) 25.95,75.77 arc(25.87,75.82) 25.8,75.88 arc(25.65,76.12) 25.59,76.39 arc(24.7,78.56) 22.53,79.45 20.42,79.45 20.13,79.74 arc(20.12,79.76) v2(20.11,79.78)
  BOTTOM w0.076: U2007.K6 31.59,75.04 arc(31.49,75.11) 31.38,75.13 30.67,75.13 arc(30.51,75.1) 30.36,75.01 30.14,75.01 30.14,75.02 30.12,75.02
  BOTTOM w0.097: 30.12,75.02 30.02,75.02 28.72,75.02 arc(28.31,75.1) 27.96,75.33 arc(27.62,75.56) 27.21,75.64 27.18,75.64 arc(26.86,75.71) v1(26.59,75.89)
TBTA_VBUS: length 13.7
  TOP w0.305: JTYPC1.A9 6.85,78.07 JTYPC1.B4 ; JTYPC1.B9 6.85,80.57 JTYPC1.A4
  IN05 w0.508: v1(29.69,78.44) 29.69,79.33 30.32,79.96 31.72,79.96 34,77.68 36.04,77.68 v1(37.05,76.66)
  BOTTOM w0.254: U2007.B10 U2007.A10 36.42,76.88 36.64,76.66 v1(37.05,76.66)
  vias: v1(28.42,78.44) v1(28.42,77.8) v1(29.05,78.44) v1(29.05,77.8) v1(29.69,77.8) v2(13.08,80.6) v2(13.35,78.29) v2(15.28,80.47) v2(16.05,80.47) v2(16.1,78.06) v2(16.63,77.58) v2(16.81,80.47) v2(16.94,78.13)
TBTB_HPD: length 5.8
  TOP w0.097: R2050.1 47.59,94.44 v3(48.1,94.95)
  BOTTOM w0.076: 48.83,91.39 48.83,90.89 U2005.G2
  BOTTOM w0.102: 48.83,91.39 48.83,92.45 48.61,92.66 48.61,93.48 48.1,93.98 v3(48.1,94.95)
TBTB_LSRX: length 3
  BOTTOM w0.076: U2005.B5 46.07,89.05 45.71,89.05 45.56,88.9 45.56,88.6 45.31,88.34 44.9,88.34
  BOTTOM w0.097: R2052.1 44.37,88.34 44.9,88.34
TBTB_LSTX: length 4
  TOP w0.097: v3(44.29,89.61) 43.22,90.68 R2051.1
  BOTTOM w0.076: 44.9,89.23 45.18,89.23 45.46,89.51 46.07,89.51 U2005.B4
  BOTTOM w0.097: 44.9,89.23 44.67,89.23 v3(44.29,89.61)
TBTB_RX0_N: length 45
  TOP w0.097: CM13.2 22.69,57.44 arc(22.87,57.56) 23.08,57.6 23.32,57.6 arc(23.52,57.52) v2(23.6,57.32)
  IN05 w0.102: v2(23.6,57.32) 23.65,57.37 arc(23.91,57.55) 24.23,57.61 24.43,57.61 arc(24.59,57.64) 24.73,57.74 arc(24.94,57.87) 25.18,57.92 26.9,57.92 arc(27.7,58.26) 28.04,59.06 28.04,59.39 arc(28.08,59.62) 28.22,59.82 31.59,63.2 arc(32.01,63.48) 32.51,63.58 33.23,63.58 arc(33.71,63.67) 34.13,63.91 34.16,63.91 40.52,70.27 40.52,70.31 arc(40.59,70.46) 40.61,70.61 40.61,71.95 arc(40.77,72.78) 41.24,73.49 arc(42.18,74.89) 42.51,76.55 42.51,79.93 arc(42.41,80.43) 42.13,80.85 41.73,81.25 arc(41.46,81.65) 41.37,82.12 41.37,83.39 arc(41.6,84.54) 42.24,85.51 arc(42.25,85.53) 42.26,85.54 arc(42.5,85.82) 42.85,85.92 43.11,85.92 arc(43.32,85.84) v2(43.4,85.63)
  BOTTOM w0.076: 45.66,85.37 45.9,85.37 arc(46.13,85.43) U2005.B13
  BOTTOM w0.097: v2(43.4,85.63) 43.4,85.68 arc(43.47,85.84) 43.63,85.91 44.11,85.91 arc(44.17,85.9) 44.22,85.86 44.35,85.74 arc(44.67,85.52) 45.05,85.45 45.28,85.45 arc(45.35,85.44) 45.41,85.43 arc(45.53,85.39) 45.66,85.37
TBTB_RX0_N_R: length 11.5
  TOP w0.104: CM13.1 20.73,57.45 arc(20.55,57.57) 20.34,57.61 20.25,57.61 arc(20.12,57.64) 20,57.72 19.83,57.89 arc(19.59,57.99) 19.36,57.89 D54.6 D54.5 arc(18.46,57.96) 18.32,57.99 arc(18.03,57.93) 17.78,57.77 arc(17.14,56.81) 16.91,55.68 16.91,55.26 arc(16.74,54.37) 16.24,53.63 15.03,52.42 arc(14.75,52.24) 14.43,52.17 14.19,52.17 arc(14.12,52.14) 14.09,52.07 JUSB1.5
TBTB_RX0_P: length 45
  TOP w0.097: CM13.3 22.66,58.07 arc(22.87,57.93) 23.12,57.88 23.32,57.88 arc(23.52,57.96) v2(23.6,58.16)
  IN05 w0.102: v2(23.6,58.16) 23.77,57.98 arc(23.91,57.9) 24.06,57.86 24.43,57.86 arc(24.49,57.88) 24.55,57.91 24.55,57.92 arc(24.84,58.11) 25.18,58.18 26.9,58.18 arc(27.52,58.43) 27.78,59.06 27.78,59.39 arc(27.85,59.72) 28.04,60 31.41,63.38 arc(31.92,63.72) 32.51,63.83 33.23,63.83 arc(33.62,63.9) 33.97,64.11 arc(34,64.13) 34.03,64.17 34.06,64.17 40.27,70.37 40.27,70.4 arc(40.29,70.42) 40.31,70.45 arc(40.34,70.53) 40.35,70.61 40.35,71.95 arc(40.54,72.88) 41.06,73.67 arc(41.95,74.99) 42.26,76.55 42.26,79.93 arc(42.18,80.33) 41.95,80.67 41.55,81.07 arc(41.23,81.56) 41.12,82.12 41.12,83.39 arc(41.36,84.63) 42.05,85.69 arc(42.13,85.81) 42.22,85.91 arc(42.51,86.11) 42.85,86.18 43.11,86.18 arc(43.32,86.26) v2(43.4,86.47)
  BOTTOM w0.076: 45.67,85.83 45.95,85.83 arc(46.03,85.8) 46.06,85.71 arc(46.03,85.63) 45.95,85.6 U2005.A13
  BOTTOM w0.097: v2(43.4,86.47) 43.51,86.36 arc(43.7,86.23) 43.92,86.19 44.11,86.19 arc(44.28,86.15) 44.42,86.06 44.54,85.93 arc(44.78,85.78) 45.05,85.72 45.32,85.72 arc(45.4,85.73) 45.46,85.77 arc(45.56,85.82) 45.67,85.83
TBTB_RX0_P_R: length 11.5
  TOP w0.104: JUSB1.6 14.09,52.53 arc(14.12,52.46) 14.19,52.43 14.43,52.43 arc(14.66,52.47) 14.85,52.6 14.92,52.67 16.05,53.81 arc(16.5,54.47) 16.65,55.26 16.65,55.68 arc(16.9,56.9) 17.59,57.95 arc(17.91,58.16) 18.28,58.25 arc(18.44,58.29) D54.4 D54.7 arc(19.67,58.32) 19.94,58.14 20.18,57.9 arc(20.21,57.88) 20.25,57.87 20.29,57.87 arc(20.54,57.92) 20.76,58.06 CM13.4
TBTB_TX0_N: length 42.6
  TOP w0.097: v2(25.58,59.48) arc(25.5,59.68) 25.3,59.76 25.08,59.76 arc(24.82,59.65) C621.1
  IN05 w0.102: v2(25.58,59.48) 25.84,59.74 arc(25.88,59.77) 25.92,59.77 26.02,59.77 arc(26.57,59.88) 27.05,60.2 33.13,66.26 arc(33.82,66.72) 34.63,66.88 35.27,66.88 arc(35.63,66.95) 35.92,67.15 38.58,69.8 arc(38.67,69.94) 38.7,70.11 38.7,83.09 arc(38.81,84.16) 39.12,85.19 39.58,86.29 arc(39.58,86.3) 39.59,86.31 39.75,86.47 arc(40.55,87) 41.5,87.19 41.84,87.19 arc(42.05,87.11) v2(42.13,86.9)
  BOTTOM w0.076: U2005.B11 46.13,86.35 arc(46.06,86.31) 45.98,86.29 45.71,86.29
  BOTTOM w0.097: 45.71,86.29 45.71,86.29 45.43,86.29 arc(44.98,86.38) 44.59,86.64 44.39,86.84 arc(44.01,87.09) 43.57,87.18 42.81,87.18 arc(42.44,87.11) v2(42.13,86.9)
TBTB_TX0_N_R: length 8.2
  TOP w0.097: CM14.1 20.72,59.61 arc(20.57,59.71) 20.39,59.75 20.29,59.75 arc(20.13,59.72) 19.99,59.62 arc(19.85,59.53) 19.68,59.5 19.63,59.5 arc(19.48,59.47) D54.9 D54.2 arc(18.46,59.47) 18.31,59.5 17.93,59.5 arc(17.54,59.42) 17.2,59.19 17.2,59.19 arc(16.86,58.96) 16.46,58.89 16.37,58.89 arc(15.93,58.8) 15.56,58.55 15.51,58.51 arc(15.13,58.25) 14.68,58.16 14.19,58.16 arc(14.12,58.13) 14.09,58.07 JUSB1.8
TBTB_TX0_P: length 42.5
  TOP w0.097: v2(25.58,60.32) arc(25.5,60.12) 25.3,60.04 25.08,60.04 arc(24.82,60.15) C648.1
  IN05 w0.102: v2(25.58,60.32) 25.84,60.06 arc(25.88,60.03) 25.92,60.03 26.02,60.03 arc(26.48,60.12) 26.87,60.38 32.95,66.44 arc(33.72,66.96) 34.63,67.14 35.28,67.14 arc(35.53,67.19) 35.75,67.33 38.4,69.98 arc(38.44,70.04) 38.45,70.11 38.45,83.09 arc(38.56,84.21) 38.89,85.29 39.34,86.39 arc(39.37,86.44) 39.41,86.49 39.57,86.65 arc(40.45,87.24) 41.5,87.45 41.84,87.45 arc(42.05,87.53) v2(42.13,87.74)
  BOTTOM w0.076: U2005.A11 45.89,86.52 arc(45.97,86.55) 46,86.64 46,86.67 arc(45.98,86.73) 45.93,86.75 45.73,86.75
  BOTTOM w0.097: 45.73,86.75 arc(45.63,86.73) 45.55,86.67 arc(45.43,86.59) 45.3,86.58 arc(45.02,86.67) 44.78,86.84 44.58,87.04 arc(44.12,87.35) 43.57,87.46 42.81,87.46 arc(42.44,87.53) v2(42.13,87.74)
TBTB_TX0_P_R: length 8.2
  TOP w0.097: CM14.4 20.73,60.2 arc(20.54,60.07) 20.31,60.02 20.29,60.02 arc(20.02,59.97) 19.8,59.82 arc(19.74,59.78) 19.68,59.77 19.63,59.77 arc(19.48,59.8) D54.10 D54.1 18.58,59.88 arc(18.46,59.8) 18.31,59.77 17.93,59.77 arc(17.43,59.67) 17,59.39 17,59.38 arc(16.75,59.22) 16.46,59.16 16.37,59.16 arc(15.82,59.05) 15.36,58.74 15.32,58.7 arc(15.03,58.51) 14.68,58.44 14.19,58.44 arc(14.12,58.47) 14.09,58.53 JUSB1.9
TBTB_USB2_D_N: length 56.9
  IN03 w0.102: v1(47.32,82.49) 46.99,82.82 46.18,82.82 42.39,79.02 42.39,78.33 40.74,76.68 40.74,71.98 36.9,68.15 34.51,68.15 31.34,71.33 31.34,72.34 29.56,74.12 25.62,74.12 23.97,72.47 23.97,61.82 22.05,59.9 18.41,59.9 18.13,60.17 18.13,60.57 v2(17.91,60.79)
  BOTTOM w0.097: v2(17.91,60.79) 18.2,60.5 18.2,60.31 17.94,60.05 17.94,59.85 17.65,59.56 CM15.2 ; v1(47.32,82.49) 47,82.81 U2005.D19
TBTB_USB2_D_N_R: length 9.2
  BOTTOM w0.097: CM15.1 17.65,57.19 17.94,56.9 17.94,56.59 17.99,56.54 17.99,56.27 17.95,56.24 D33.2 17.75,55.9 17.68,55.83 17.24,55.83 v2(16.73,55.32) 15.97,54.56 13.79,54.56 13,55.35 12.55,55.35 12.31,55.58 12.31,56.02 JUSB1.2
TBTB_USB2_D_P: length 56.9
  IN03 w0.102: v2(18.76,60.79) 18.49,60.79 18.38,60.68 18.38,60.28 18.51,60.15 21.94,60.15 23.72,61.93 23.72,72.58 25.52,74.37 29.67,74.37 31.59,72.45 31.59,71.43 34.62,68.41 36.8,68.41 40.48,72.09 40.48,76.79 42.13,78.44 42.13,79.13 46.07,83.07 46.87,83.07 46.93,83.13 46.93,83.25 47.02,83.34 47.22,83.34 47.32,83.24 v1(47.32,83.13)
  BOTTOM w0.097: v2(18.76,60.79) 18.48,60.5 18.48,60.19 18.22,59.93 18.22,59.8 18.5,59.51 CM15.3 ; v1(47.32,83.13) 47.64,82.81 U2005.E19
TBTB_USB2_D_P_R: length 9.3
  BOTTOM w0.097: JUSB1.3 12.59,54.99 12.67,55.07 12.89,55.07 13.67,54.29 v2(15.58,54.29) 16.08,54.29 17.35,55.56 18.06,55.56 18.3,55.8 D33.1 18.3,56.24 18.27,56.27 18.27,56.65 18.22,56.7 18.22,56.9 18.5,57.19 CM15.4
TGR_1.2V: length 2.1
  BOTTOM w0.508: PQ401.2 107.84,82.76 v2(107.8,82.8) v2(107.16,82.8) ; v2(112.87,87.58) v2(112.24,87.58)
TGR_3V: length 19.2
  TOP w0.203: v2(47.09,13.8) 46.83,13.8 46.58,14.05 PU301.8
  TOP w0.508: v2(53.21,26.54) 53.21,26.37 PQ301.2 ; PC310.1 v2(47.09,13.8)
  IN05 w0.508: v2(47.09,13.8) 48.77,15.48 48.77,24 50.29,25.53 52.2,25.53 v2(53.21,26.54)
TGR_5V: length 15.6
  TOP w0.203: PU301.18 42.45,14.05 42.29,13.89
  TOP w0.381: v2(41.15,12.32) 41.33,12.5 PC309.2 41.81,13.41 42.29,13.89
  TOP w0.508: PQ302.2 v2(36.54,21.08)
  IN03 w0.508: v2(41.15,12.32) 41.53,12.7 41.53,17.4 38.61,20.32 37.31,20.32 v2(36.54,21.08)
THERM_ALERT_N: length 10.3
  TOP w0.097: Q93.1 244.52,108.57 R982.2 244.52,109.55 244.04,110.03 243.54,110.03 241.73,111.84 239.87,111.84 238.86,112.86 238.86,113.74 238.33,114.27 v3(238.29,114.27)
  BOTTOM w0.097: G2.BJ3 v3(238.29,114.27)
THERMDA: length 0.5
  BOTTOM w0.178: U2005.AC23 U2005.AB23
TP_PS2_CLK: length 282.8
  TOP w0.097: v2(275.08,19.3) 275.59,19.81 R576.1
  IN03 w0.091: v2(275.08,19.3) 274.68,19.3 273.32,17.95 268.05,17.95 267.21,18.8 266.57,18.8 266.17,19.2 266.17,24.12 265.65,24.64 265.65,25 266.17,25.52 266.17,38.66 262.84,41.99 259.71,41.99 256.58,38.87 214.53,38.87 209.75,43.64 159.62,43.64 152.15,51.1 118.69,51.1 108.34,40.76 107.33,40.76 106.4,41.69 83.03,41.69 82.56,41.23 75.87,41.23 74.3,42.8 72.9,42.8 71.75,41.66 69.39,41.66 65.76,45.29 54.96,45.29 52.17,42.5 46.2,42.5 45.82,42.88 40.48,42.88 v2(39.97,43.39)
  BOTTOM w0.097: U5.A11 37.28,47.99 38.58,46.69 39.29,46.69 R241.1 40.64,45.11 40.35,44.83 40.35,43.77 v2(39.97,43.39)
TP_PS2_CLK_R: length 4.6
  TOP w0.097: R576.2 C643.1 276.81,21.21 276.87,21.27 D40.2 276.87,22.26 v2(276.32,22.81)
  BOTTOM w0.097: JTP1.2 275.85,23.28 v2(276.32,22.81)
TP_PS2_DAT: length 279
  TOP w0.097: v2(272.41,19.3) 273.76,19.3 R575.1
  IN03 w0.091: v2(272.41,19.3) 271.96,18.85 267.54,18.85 267.33,19.05 266.83,19.05 266.42,19.46 266.42,20.93 266.57,21.08 266.57,25.32 266.39,25.5 266.39,38.97 262.99,42.37 259.55,42.37 256.26,39.08 214.85,39.08 209.91,44.02 159.6,44.02 152.3,51.32 118.6,51.32 108.25,40.97 107.42,40.97 106.41,41.99 91.15,41.99 90.49,42.65 83.56,42.65 82.39,41.48 76.02,41.48 74.37,43.13 71.42,43.13 71.11,42.82 68.6,42.82 65.88,45.55 54.71,45.55 52.67,43.51 46.58,43.51 46.28,43.81 42.31,43.81 v2(41.88,43.39)
  BOTTOM w0.076: 37.52,49.61 37.52,50.16 U5.B11
  BOTTOM w0.097: 37.52,49.61 37.52,48.15 38.6,47.07 39.47,47.07 40.99,45.55 41.32,45.55 R242.1 42.26,44.61 42.26,43.77 v2(41.88,43.39)
TP_PS2_DAT_R: length 5.2
  TOP w0.097: v2(274.54,22.81) 273.89,22.81 273.29,22.21 D41.2 273.29,21.09 273.35,21.03 C644.1 R575.2
  BOTTOM w0.097: JTP1.3 274.85,23.12 v2(274.54,22.81)
TP_SKL_BJ13: length 3.5
  TOP w0.097: TP14.1 155.16,140.36 v2(155.29,140.24)
  BOTTOM w0.097: U1.BJ13 153.82,139.24 153.55,139.52 153.55,139.91 153.67,140.03 154.3,140.03 154.5,140.24 v2(155.29,140.24)
TP_SKL_BJ14: length 1.4
  TOP w0.097: TP13.1 154.49,139.65 v2(154.62,139.78)
  BOTTOM w0.097: U1.BJ14 154.5,139.67 v2(154.62,139.78)
TP_SKL_BJ16: length 2
  TOP w0.097: v2(155.11,141.51) 155.09,141.48 TP20.1
  BOTTOM w0.097: v2(155.11,141.51) 154.91,141.3 154.22,141.3 154.12,141.2 U1.BJ16
TP_SKL_BJ24: length 3
  TOP w0.097: TP27.1 155.82,146.18 v2(155.32,146.18)
  BOTTOM w0.097: U1.BJ24 154.2,147.5 154.3,147.4 154.93,147.4 155.32,147.02 v2(155.32,146.18)
TP_SKL_BJ33: length 2.7
  TOP w0.097: v2(153.88,153.87) 154.03,153.87 154.27,153.62 154.27,152.1 TP37.1
  BOTTOM w0.097: v2(153.88,153.87) 153.55,154.19 U1.BJ33
TP_SKL_BJ34: length 2
  TOP w0.097: v2(153.88,154.52) 153.5,154.14 153.5,153.25 v1(153.51,153.24)
  BOTTOM w0.097: U1.BJ34 153.55,154.84 v2(153.88,154.52)
TP_SKL_BK16: length 2.1
  TOP w0.097: TP22.1 153.77,140.54 153.4,140.54 153.13,140.81 v3(152.88,140.81)
  BOTTOM w0.097: U1.BK16 152.88,140.86 v3(152.88,140.81)
TP_SKL_BK24: length 2.6
  TOP w0.097: v2(154.66,147.83) 154.15,148.35 v1(154.15,148.57)
  BOTTOM w0.102: v2(154.66,147.83) 154.59,147.91 153.62,147.91 U1.BK24
TP_SKL_BL33: length 1.3
  TOP w0.097: v2(153.09,154.52) 152.96,154.38 TP8.1
  BOTTOM w0.097: U1.BL33 152.77,154.19 v2(153.09,154.52)
TP_SKL_BM33: length 2.1
  TOP w0.097: TP6.1 150.67,153.8 151.2,153.8 v2(151.59,154.2)
  BOTTOM w0.097: U1.BM33 151.92,153.87 v2(151.59,154.2)
TP_SKL_BR1: length 3.3
  BOTTOM w0.097: TP11.1 148.56,129.49 149.88,130.82 U1.BR1
TP_SKL_BT2: length 3.1
  BOTTOM w0.097: TP12.1 147.16,131.02 147.67,130.51 148.44,130.51 U1.BT2
TP_SKL_D1: length 6.4
  BOTTOM w0.097: U1.D1 187.96,130.74 188.39,130.31 190.16,130.31 190.85,129.62 193.64,129.62 TP5.1
TP_SKL_E1: length 9.9
  BOTTOM w0.097: TP7.1 195.42,130.89 193.9,129.37 190.6,129.37 189.83,130.13 188.18,130.13 187.49,130.82 U1.E1
TP_SKL_E2: length 5.1
  BOTTOM w0.097: TP10.1 191.1,130.76 190.83,130.49 188.46,130.49 188.31,130.64 188.31,131.02 187.86,131.47 U1.E2
TP_SKL_E3: length 6.5
  BOTTOM w0.097: TP9.1 191.26,131.65 190.62,131.02 189.12,131.02 188.97,131.17 188.41,131.17 187.47,132.11 U1.E3
TP_SMB_CLK: length 2.4
  TOP w0.097: v2(272.38,22.81) 272.38,21.89 R573.2
  BOTTOM w0.097: JTP1.5 272.85,23.28 v2(272.38,22.81)
TP_SMB_DAT: length 3.6
  TOP w0.097: v2(270.51,22.86) 270.51,22.73 271.4,21.84 R572.2
  BOTTOM w0.097: JTP1.6 271.85,23.96 270.99,23.96 270.51,23.48 v2(270.51,22.86)
TSENSE_1PH_A: length 5.4
  TOP w0.203: PU1101.11 122.57,190 121.71,189.13 v2(121.71,188.5)
  TOP w0.254: PC1163.1 121.03,187.4 121.71,188.09 v2(121.71,188.5)
  BOTTOM w0.254: v2(121.71,188.5) 121.53,188.32 PR1182.2
TSENSE_3PH_A: length 4.7
  TOP w0.203: v2(131.59,194.14) 131.29,194.14 130.35,193.2 PU1101.37
  BOTTOM w0.254: v2(131.59,194.14) 131.41,193.96 PR1180.2 130.45,193.88 PC1162.1
TURBO_BTN_N: length 38.8
  IN10 w0.091: v3(69.8,17.98) 70.33,18.51 70.33,20.15 69.18,21.29 58.21,21.29 v2(56.13,23.37)
  BOTTOM w0.097: JKB1.49 67.59,16.41 68.71,17.53 69.34,17.53 v3(69.8,17.98) ; v2(56.13,23.37) 55.21,24.29 55.21,29.8 55.47,30.05 v1(55.47,32.31) 55.47,37.42 54.96,37.93 R830.2 R832.2
TURBO_GPIO1: length 27.3
  IN08 w0.091: v2(45.1,36.96) 45.05,37.01 45.05,41.86 44.8,42.12 44.8,49.61 43.4,51.01 v2(43.28,51.01)
  BOTTOM w0.097: v2(45.1,36.96) 45.97,36.09 51.48,36.09 54.07,38.69 R833.2 ; R546.1 v2(43.28,51.01)
UG_3V: length 18.1
  TOP w0.508: PQ301.1 55.14,25.86 v2(55.7,25.3)
  IN03 w0.508: v2(46.86,15.37) 46.23,16 46.23,17.27 48.77,19.81 48.77,23.62 50.44,25.3 v2(55.7,25.3)
UG_5V: length 8.2
  TOP w0.508: PQ302.1 v2(37.81,21.08)
  BOTTOM w0.762: v2(37.81,21.08) 38.02,21.08 42.29,16.81 v2(42.29,15.62)
USB2_CHG_PN: length 6.3
  TOP w0.104: CM12.2 17.28,41.35 17.16,41.48 16.99,41.48 16.86,41.61 16.86,41.76 16.96,41.86 17.87,41.86 18,41.74 18,40.59 18.39,40.21 v2(18.89,40.21) 19.37,40.21 19.53,40.05 19.53,39.83 19.65,39.71 U21.11
USB2_CHG_PN_R: length 22.5
  TOP w0.104: CM12.1 17.28,38.27 16.82,37.8 16.35,37.8 16.07,37.52 15.68,37.52 D49.2 15.6,37.44 15.6,37.25 15.31,36.96 14.09,36.96 13.12,37.93 v2(12.29,37.93) 9.24,37.93 8.23,36.91 8.23,29.63 8.8,29.06 10.45,29.06 10.68,29.29 10.68,30.07 JUSB2.2
USB2_CHG_PP: length 6.3
  TOP w0.104: CM12.3 16.43,41.18 16.61,41.35 16.61,41.87 16.86,42.12 v2(17.37,42.12) 17.98,42.12 18.26,41.84 18.26,40.7 18.49,40.47 19.47,40.47 19.73,40.21 U21.10
USB2_CHG_PP_R: length 22.5
  TOP w0.104: JUSB2.3 9.95,28.8 8.7,28.8 7.97,29.53 7.97,37.02 9.13,38.18 v2(9.49,38.18) 13.23,38.18 14.19,37.21 15.2,37.21 15.35,37.36 15.35,37.65 15.54,37.85 D49.1 15.75,37.85 15.83,37.77 15.96,37.77 16.25,38.05 16.71,38.05 16.99,38.33 16.99,38.49 16.88,38.59 16.57,38.59 16.43,38.72 CM12.4
USB2_COMP: length 1.7
  TOP w0.097: v3(246.35,59.9) 246.81,60.35 R130.1
  BOTTOM w0.097: v3(246.35,59.9) 246.46,60 U2.AG3
USB2_D_N3: length 7.6
  BOTTOM w0.104: JCAM1.2 160.71,197.35 160.88,197.18 160.88,196.8 160.68,196.6 160.37,196.6 159.71,195.94 157.7,195.94 157.38,195.61 157.38,194.41 157.62,194.16 158.24,194.16 158.26,194.14 CM16.4 158.84,194.14 R2349.2
USB2_D_P3: length 7.5
  BOTTOM w0.104: R2350.2 158.84,194.99 CM16.1 158.29,194.99 158.14,194.84 158.14,194.69 157.86,194.41 157.73,194.41 157.63,194.51 157.63,195.5 157.81,195.68 159.81,195.68 160.48,196.34 160.78,196.34 161.14,196.7 161.14,197.18 161.31,197.36 JCAM1.3
USB2_DN1: length 100.7
  IN05 w0.114: v3(245.59,59.9) 245.44,59.9 245.32,59.77 245.32,59.53 245.44,59.41 246.75,59.41 247.49,60.15 247.49,62.31 248.25,63.07 253.34,63.07 255.89,65.62 256.91,65.62 258.23,66.95 260.09,66.95 260.54,66.5 274.17,66.5 276.58,68.91 279.36,68.91 280.51,67.77 280.51,62.18 280.88,61.81 289.14,61.81 297.82,53.13 297.82,40.04 300.96,36.9 303.46,36.9 304.81,35.54 304.81,35.16 305.58,34.39 305.81,34.39 306.17,34.75 v2(306.17,34.89)
  BOTTOM w0.104: JIO1.32 301.02,31.58 301.09,31.51 302.04,31.51 302.64,32.11 302.64,32.52 304.75,34.64 305.91,34.64 v2(306.17,34.89) ; U2.AF5 245.58,59.95 245.58,59.9 v3(245.59,59.9)
USB2_DN2: length 257.1
  TOP w0.104: v2(24.61,39.58) 24.61,39.78 24.48,39.91 23.98,39.91 23.79,39.71 U21.2
  IN03 w0.076: v3(245.97,60.91) 245.77,60.72 245.77,60.57 245.57,60.37 243.35,60.37 243.2,60.22 243.2,60.14 243.19,60.13
  IN03 w0.114: v2(24.61,39.58) 24.61,39.74 24.7,39.83 25.09,39.83 25.51,40.26 25.51,41.59 24.75,42.36 24.75,47.84 28.21,51.31 28.72,51.31 29.19,51.78 29.19,52.67 30.05,53.53 31.17,53.53 34.36,56.72 37.43,56.72 37.56,56.85 46.83,56.85 47.97,57.99 53.56,57.99 54.71,56.85 58.27,56.85 60.05,58.63 68.93,58.63 69.43,59.12 75.28,59.12 75.8,59.64 90.06,59.64 94.76,64.34 99.03,64.34 99.92,63.45 107.79,63.45 109.3,64.96 115.3,64.96 116.81,63.45 125.95,63.45 127.48,61.93 132.81,61.93 134.86,59.88 191.72,59.88 192.1,60.27 194.68,60.27 197.46,57.48 215.74,57.48 217.9,55.32 218.92,55.32 221.08,53.17 221.84,53.17 223.23,51.77 223.23,51.01 224.12,50.12 230.26,50.12 231.64,51.5 234.52,51.5 235.79,52.77 236.33,52.77 236.74,52.37 237.98,52.37 238.36,52.75 238.72,52.75 239.24,52.23 239.82,52.23 240.37,52.78 240.37,56.97 241.13,57.73 241.51,57.73 242.27,58.49 242.27,59.21 243.19,60.13
  BOTTOM w0.104: U2.AD5 246.14,61.09 v3(245.97,60.91)
USB2_DN3: length 237.9
  IN05 w0.076: 246.5,60.51 246.49,60.5 246.41,60.5 246.2,60.29 244.43,60.29 244.32,60.18 v3(244.32,59.9)
  IN05 w0.114: 246.5,60.51 246.73,60.74 246.73,62.82 249.52,65.61 250.92,65.61 252.32,67.01 252.32,69.04 250.92,70.44 250.92,79.58 248.62,81.88 245.93,81.88 242.7,85.11 242.7,87.29 241.78,88.22 241.78,99.4 245.33,102.95 245.33,109.05 245.46,109.17 245.46,120.86 244.82,121.49 244.82,132.41 243.92,133.32 233.38,133.32 232.11,134.59 225.89,134.59 221.82,138.65 217.63,138.65 214.48,141.8 214.48,150.43 211.68,153.24 211.68,156.55 209.79,158.44 209.79,167.22 211.3,168.74 211.3,172.55 211.8,173.05 211.8,184.61 212.33,185.14 212.33,189.87 209.72,192.48 209.72,193.81 206.21,197.31 200.64,197.31 199.36,198.59 186.42,198.59 184.77,196.94 178.26,196.94 177.63,197.58 168.48,197.58 167.08,198.97 161.53,198.97 159.7,197.15 159.7,195.33 160.11,194.92 160.88,194.92 161.34,195.37 161.34,195.64 v2(161.51,195.81)
  BOTTOM w0.104: U2.AG8 244.32,60.11 v3(244.32,59.9) ; R2349.1 159.93,194.14 CM16.3 160.51,194.14 160.81,194.44 161.04,194.44 161.34,194.74 161.34,195.64 v2(161.51,195.81)
USB2_DN4: length 236.1
  IN03 w0.114: v3(249.82,62.17) 249.63,61.98 249.63,61.42 250.01,61.04 250.67,61.04 251.31,60.39 251.31,50.38 250.16,49.23 248.38,49.23 247.36,48.21 244.57,48.21 244.32,47.96 242.92,47.96 242.28,47.32 242.28,46.31 242.54,46.05 242.54,43.13 240.54,41.14 215.96,41.14 210.17,46.93 201.79,46.93 200.9,47.82 175.5,47.82 174.73,48.58 159.75,48.58 154.01,54.32 126.61,54.32 125.09,55.83 106.65,55.83 105.12,54.31 100.81,54.31 99.03,52.53 95.1,52.53 94.46,53.17 90.9,53.17 89.36,51.63 82.12,51.63 81.61,51.12 79.58,51.12 77.8,49.34 75.9,49.34 72.99,46.43 69.95,46.43 69.31,45.8 69.31,45.55 v2(69.56,45.29)
  BOTTOM w0.104: v3(249.82,62.17) 249.6,62.17 249.51,62.07 249.51,61.73 249.28,61.51 248.39,61.51 U2.AE1 ; v2(69.56,45.29) 69.34,45.07 69.34,44.02 v2(69.34,44.02) 69.34,36.32 66.77,33.76 66.77,26.14 R917.1
USB2_DN4_R: length 15.2
  BOTTOM w0.104: R917.2 66.95,24.95 66.67,24.66 66.67,21.62 66.85,21.44 v2(67.13,21.44) 67.42,21.44 67.53,21.55 67.53,21.81 67.69,21.97 68.11,21.97 D48.2 68.45,21.78 68.65,21.59 69.98,21.59 71.7,19.87 71.88,19.68 71.88,17.8 71.23,17.14 70.64,17.14 70.09,16.59 JKB1.44
USB2_DN5: length 45.7
  IN10 w0.114: v2(273.65,70.47) 273.65,70.26 273.44,70.05 271.61,70.05 271.46,70.2 265.8,70.2 264.26,68.66 258.67,68.66 258.3,68.29 255.98,68.29 255.79,68.48 255.79,68.82 255.91,68.93 v2(256.13,68.93)
  BOTTOM w0.076: 248.21,62.7 248.2,62.69 248.13,62.69 247.72,62.28 U2.AC2
  BOTTOM w0.104: v2(273.65,70.47) 273.58,70.39 273.58,70.22 273.68,70.12 274.44,70.12 274.78,70.46 274.78,72.3 275.18,72.7 276.6,72.7 279.99,76.1 279.99,77.88 279.75,78.13 JWLAN1.5 ; v2(256.13,68.93) 255.96,68.93 255.72,68.69 255.72,68.31 255.43,68.02 253.15,68.02 251.91,66.78 251.91,66.11 250.54,64.74 250.54,63.58 249.83,62.87 248.39,62.87 248.29,62.77 248.21,62.7
USB2_DN6: length 84.8
  IN10 w0.114: v2(295.76,43.27) 295.76,43.01 295.64,42.9 294.46,42.9 292.96,44.4 292.96,45.41 292.34,46.04 292.34,47.18 291.81,47.7 291.43,47.7 290.67,48.47 290.67,56.08 289.89,56.86 288.88,56.86 288.39,57.36 287.24,57.36 286.08,58.51 284.81,58.51 284.43,58.89 280.75,58.89 275.8,63.85 274.03,63.85 273.91,63.96 273.91,64.92 273.64,65.19 272.97,65.19 272.7,64.92 272.7,63.96 272.58,63.85 272.12,63.85 272.01,63.96 272.01,64.92 271.74,65.19 271.06,65.19 270.79,64.92 270.79,63.96 270.68,63.85 270.21,63.85 268.81,65.24 264.78,65.24 263.87,64.34 258.16,64.34 257.52,63.71 257.52,62.96 256.32,61.75 251.04,61.75 250.92,61.87 250.92,62.05 251.04,62.17 v3(251.29,62.17)
  BOTTOM w0.104: U2.AF2 247.65,60.57 248.26,60.57 248.6,60.91 249.65,60.91 250.08,61.34 250.69,61.34 250.97,61.62 250.97,62.05 251.09,62.17 v3(251.29,62.17) ; JIO1.29 300.27,32.78 300.1,32.95 300.1,34.41 298.49,36.02 298.49,36.66 297.63,37.53 297.63,41.95 297.34,42.24 296.65,42.93 296.09,42.93 v2(295.76,43.27)
USB2_DP1: length 100.7
  IN05 w0.114: v2(306.16,34.13) 305.47,34.13 304.55,35.05 304.55,35.43 303.35,36.63 300.85,36.63 297.55,39.93 297.55,53.02 289.02,61.55 280.77,61.55 280.25,62.07 280.25,67.66 279.25,68.65 276.69,68.65 274.28,66.23 260.43,66.23 259.98,66.68 258.34,66.68 257.02,65.36 256,65.36 253.45,62.81 248.36,62.81 247.76,62.2 247.76,60.04 246.86,59.14 245.32,59.14 245.05,59.42 245.05,59.8 v3(244.95,59.9)
  BOTTOM w0.104: U2.AG7 245.24,60.41 244.95,60.12 v3(244.95,59.9) ; v2(306.17,34.13) 305.91,34.38 304.86,34.38 302.89,32.42 302.89,32 302.14,31.25 301.09,31.25 301.02,31.18 JIO1.33
USB2_DP2: length 257.1
  TOP w0.104: v2(24.61,40.59) 24.61,40.35 24.42,40.16 23.86,40.16 23.82,40.21 U21.3
  IN03 w0.076: 243.01,60.32 243.01,60.33 243.09,60.33 243.29,60.52 245.5,60.52 245.62,60.63 245.62,60.8 245.5,60.91 v3(245.33,60.91)
  IN03 w0.114: v2(24.61,40.59) 24.61,40.24 24.75,40.1 24.98,40.1 25.25,40.37 25.25,41.48 24.48,42.25 24.48,47.95 28.1,51.58 28.61,51.58 28.92,51.89 28.92,52.78 29.94,53.8 31.06,53.8 34.25,56.99 37.32,56.99 37.45,57.12 46.72,57.12 47.86,58.26 53.67,58.26 54.82,57.12 58.16,57.12 59.94,58.89 68.82,58.89 69.31,59.39 75.17,59.39 75.69,59.91 89.95,59.91 94.65,64.61 99.14,64.61 100.03,63.72 107.68,63.72 109.19,65.23 115.41,65.23 116.92,63.72 126.06,63.72 127.59,62.2 132.92,62.2 134.97,60.15 191.61,60.15 191.99,60.53 194.79,60.53 197.57,57.75 215.85,57.75 218.01,55.59 219.03,55.59 221.19,53.43 221.95,53.43 223.5,51.88 223.5,51.12 224.23,50.39 230.15,50.39 231.53,51.77 234.41,51.77 235.68,53.04 236.44,53.04 236.85,52.63 237.87,52.63 238.25,53.01 238.83,53.01 239.35,52.49 239.71,52.49 240.1,52.89 240.1,57.08 241.01,57.99 241.4,57.99 242.01,58.6 242.01,59.32 243.01,60.32
  BOTTOM w0.104: v3(245.33,60.91) 245.45,61.03 245.45,61.44 U2.AD7
USB2_DP3: length 237.9
  IN05 w0.076: 246.31,60.7 246.3,60.69 246.3,60.68 246.33,60.64 246.13,60.44 244.36,60.44 244.21,60.29 243.7,60.29 243.59,60.17 243.59,59.99 v2(243.68,59.9)
  IN05 w0.114: v2(160.56,195.81) 160.56,196.16 160.71,196.3 160.92,196.3 161.07,196.16 161.07,195.48 160.77,195.19 160.22,195.19 159.97,195.44 159.97,197.04 161.64,198.71 166.97,198.71 168.37,197.31 177.51,197.31 178.15,196.68 184.88,196.68 186.53,198.33 199.25,198.33 200.53,197.04 206.1,197.04 209.45,193.7 209.45,192.37 212.06,189.76 212.06,185.25 211.54,184.73 211.54,173.16 211.03,172.66 211.03,168.85 209.52,167.33 209.52,158.33 211.41,156.44 211.41,153.13 214.22,150.32 214.22,141.68 217.52,138.38 221.71,138.38 225.77,134.32 232,134.32 233.27,133.05 243.81,133.05 244.56,132.3 244.56,121.38 245.19,120.75 245.19,109.28 245.07,109.16 245.07,103.06 241.51,99.51 241.51,88.11 242.44,87.18 242.44,85 245.82,81.61 248.51,81.61 250.65,79.47 250.65,70.33 252.05,68.93 252.05,67.12 250.81,65.88 249.41,65.88 246.46,62.93 246.46,60.85 246.31,60.7
  BOTTOM w0.104: v2(243.68,59.9) 243.94,60.16 243.94,60.32 U2.AG10 ; R2350.1 159.93,194.99 CM16.2 160.48,194.99 160.78,194.69 160.93,194.69 161.09,194.85 161.09,195.71 160.99,195.81 v2(160.56,195.81)
USB2_DP4: length 236.1
  IN03 w0.114: v3(249.08,62.17) 249.37,61.88 249.37,61.31 249.9,60.77 250.56,60.77 251.05,60.28 251.05,50.49 250.05,49.5 248.27,49.5 247.25,48.48 244.46,48.48 244.21,48.23 242.81,48.23 242.02,47.43 242.02,46.2 242.27,45.94 242.27,43.24 240.43,41.4 216.07,41.4 210.28,47.2 201.9,47.2 201.01,48.09 175.61,48.09 174.84,48.85 159.86,48.85 154.12,54.59 126.72,54.59 125.2,56.1 106.54,56.1 105.01,54.58 100.7,54.58 98.92,52.8 95.21,52.8 94.57,53.43 90.79,53.43 89.25,51.9 82.01,51.9 81.5,51.39 79.47,51.39 77.69,49.61 75.79,49.61 72.88,46.7 69.84,46.7 69.04,45.91 69.04,45.46 v2(68.88,45.29)
  BOTTOM w0.104: v2(68.88,45.29) 69.08,45.09 v2(69.08,42.5) 69.08,36.43 66.52,33.86 66.52,26.22 R918.1 ; U2.AE2 247.84,61.46 247.98,61.46 248.29,61.77 249.18,61.77 249.25,61.84 249.25,62 v3(249.08,62.17)
USB2_DP4_R: length 15.1
  BOTTOM w0.104: JKB1.45 69.59,16.14 69.84,16.38 69.84,16.7 70.54,17.4 71.12,17.4 71.63,17.91 71.63,19.58 70.42,20.78 70.33,20.78 70.25,20.78 70.09,20.95 70.09,21.03 70.09,21.03 70.09,21.12 69.87,21.33 69.53,21.33 69.38,21.18 69.1,21.18 68.95,21.33 68.71,21.33 D37.2 68.09,20.92 67.82,21.19 66.74,21.19 66.41,21.52 v2(66.41,23.91) 66.41,24.7 R918.2
USB2_DP5: length 45.7
  IN10 w0.114: v2(255.33,68.91) 255.6,68.65 255.6,68.3 255.87,68.02 258.41,68.02 258.78,68.39 264.37,68.39 265.91,69.93 271.35,69.93 271.5,69.78 273.52,69.78 v2(273.65,69.65)
  BOTTOM w0.076: 248.03,62.88 248.02,62.87 248.02,62.8 247.77,62.54 247.19,62.54 U2.AC3
  BOTTOM w0.104: v2(273.65,69.65) 273.86,69.86 274.54,69.86 275.03,70.35 275.03,72.19 275.29,72.45 276.7,72.45 280.25,75.99 JWLAN1.3 ; v2(255.33,68.91) 255.33,68.82 255.46,68.69 255.46,68.41 255.32,68.28 253.05,68.28 251.66,66.89 251.66,66.22 250.28,64.85 250.28,63.69 249.72,63.13 248.28,63.13 248.1,62.95 248.03,62.88
USB2_DP6: length 84.9
  IN10 w0.114: v2(295.76,42.37) 295.76,42.39 295.51,42.63 294.35,42.63 292.69,44.29 292.69,45.3 292.07,45.93 292.07,47.07 291.7,47.44 291.32,47.44 290.41,48.36 290.41,55.97 289.78,56.59 288.77,56.59 288.28,57.09 287.13,57.09 285.97,58.25 284.7,58.25 284.32,58.63 280.64,58.63 275.69,63.58 273.92,63.58 273.65,63.85 273.65,64.81 273.53,64.92 273.08,64.92 272.96,64.81 272.96,63.85 272.69,63.58 272.01,63.58 271.74,63.85 271.74,64.81 271.63,64.92 271.17,64.92 271.06,64.81 271.06,63.85 270.79,63.58 270.1,63.58 268.7,64.98 264.89,64.98 263.99,64.08 258.27,64.08 257.79,63.6 257.79,62.85 256.43,61.48 250.93,61.48 250.65,61.76 250.65,62.07 v1(250.55,62.17)
  BOTTOM w0.104: U2.AF3 247.4,60.82 248.15,60.82 248.49,61.17 249.54,61.17 249.97,61.6 250.58,61.6 250.72,61.73 250.72,62 v1(250.55,62.17) ; JIO1.30 300.31,32.38 299.84,32.85 299.84,34.2 298.23,35.81 298.23,36.56 297.37,37.42 297.37,41.85 296.54,42.67 296.06,42.67 v2(295.76,42.37)
USB2_OTG_ID: length 4.2
  BOTTOM w0.097: R63.2 250.74,60.56 v1(250.16,60.56) 248.74,60.56 248.46,60.28 247.87,60.28 247.6,60 U2.AG2
USB3_RX_DN1: length 106.4
  IN10 w0.114: v2(303.98,31.01) 304.16,31.01 304.36,31.21 304.36,31.73 304.21,31.88 304.21,32.17 304.36,32.31 304.36,32.65 304.21,32.79 304.21,33.08 304.36,33.23 304.36,33.56 304.21,33.71 304.21,34 304.36,34.14 304.36,35.5 304.79,35.92 304.79,48.4 299.99,53.2 298.77,53.2 290.28,61.69 290.28,68.04 288.25,70.07 288.25,72.61 287.5,73.36 284.96,73.36 283.81,72.22 275.67,72.22 275.17,72.72 270.86,72.72 270.47,73.12 270.47,74.39 269.72,75.14 267.81,75.14 266.67,73.99 264.64,73.99 262.48,71.83 258.93,71.83 258.54,72.22 258.54,73.36 257.54,74.36 253.32,74.36 252.44,73.49 250.27,73.49 249.54,74.22 246.03,74.22 245.5,73.76 245.48,73.52 v2(245.54,73.46)
  BOTTOM w0.104: v2(303.98,31.01) 304.08,31.11 304.24,31.11 304.34,31.01 304.34,29.9 303.53,29.08 301.14,29.08 301.05,29.18 JIO1.38 ; U2.B7 245.15,72.54 245.36,72.75 245.36,73.28 v2(245.54,73.46)
USB3_RX_DN3: length 282.3
  TOP w0.104: R530.1 18.29,27.47 CM10.2 18.94,27.47 19.23,27.76 19.68,27.76 19.91,27.54 v2(19.91,27.46)
  IN03 w0.114: v2(19.91,27.46) 20.1,27.46 20.23,27.59 20.23,27.84 20.1,27.96 19.73,27.96 19.55,28.13 19.28,28.13 19.07,27.92 19.07,27.33 19.64,26.76 21.83,26.76 24.09,29.02 24.09,34.16 23.92,34.32 23.26,34.32 22.83,34.75 22.83,38.81 23.07,39.06 23.07,47.82 25.36,50.1 25.36,52.39 26.78,53.81 27.42,53.81 28.28,54.67 28.28,56.45 28.94,57.12 33.01,57.12 34.01,58.12 45.31,58.12 46.59,59.4 54.31,59.4 55.24,58.47 57.85,58.47 60.69,61.31 68.57,61.31 68.69,61.43 85.08,61.43 90.54,66.89 101.93,66.89 102.82,66.01 105.02,66.01 105.91,66.89 109.43,66.89 110.06,66.26 115.65,66.26 116.94,64.98 126.21,64.98 127.98,63.2 136.75,63.2 137.76,62.18 195.79,62.18 199.33,58.64 216.36,58.64 218.39,56.61 220.71,56.61 222.27,58.17 236.03,58.17 236.79,58.93 236.79,61.18 237.5,61.89 240.45,61.89 241.9,63.35 241.9,65.87 243.45,67.42 243.45,68.05 243.92,68.52 243.92,72.07 244.38,72.53 244.38,73.17 244.25,73.29 244.11,73.29 243.99,73.42 v3(243.99,73.54)
  BOTTOM w0.104: U2.B10 243.93,72.71 243.8,72.84 243.8,73.13 243.99,73.32 v3(243.99,73.54)
USB3_RX_DN3_R: length 7.9
  TOP w0.104: JUSB2.5 12.05,25.83 12.29,26.07 13.39,26.07 v2(13.56,26.24) 13.71,26.39 13.71,27.91 13.83,28.03 14.02,28.03 14.14,27.91 D53.5 D53.6 16.12,27.91 16.56,27.47 CM10.1 17.21,27.47 R530.2
USB3_RX_DN6: length 99
  IN10 w0.114: v3(240.73,68.36) 241.1,67.99 241.1,67.88 241.1,67.47 241.87,66.7 241.87,63.08 242.3,62.65 246.9,62.65 248.51,61.04 250.03,61.04 250.49,60.58 255.13,60.58 255.42,60.29 257.03,60.29 259.29,62.55 263.99,62.55 265.51,64.08 267.96,64.08 271.37,60.66 276.96,60.66 279.88,57.74 283.69,57.74 284.63,56.8 284.63,54.13 286.61,52.15 288.39,52.15 289.15,51.39 289.15,46.18 290.05,45.28 291.2,45.28 291.8,44.67 291.8,43.02 294.47,40.36 294.47,39.85 295.77,38.55 296.71,38.55 300.03,35.23 300.03,30.12 301.32,28.83 302.51,28.83 303.28,28.06 303.28,27.62 v2(302.99,27.33)
  BOTTOM w0.104: v3(240.73,68.36) 241.11,68.73 U2.K15 ; v2(302.99,27.33) 303.09,27.43 303.28,27.43 303.39,27.32 303.39,26.83 303.25,26.69 301.12,26.69 301.02,26.78 JIO1.44
USB3_RX_DP1: length 106.4
  IN10 w0.114: v2(304.8,31.01) 304.62,31.19 304.62,35.39 305.05,35.81 305.05,48.51 300.1,53.47 298.88,53.47 290.54,61.8 290.54,68.15 288.51,70.18 288.51,72.72 287.61,73.63 284.85,73.63 283.7,72.48 275.78,72.48 275.28,72.99 270.97,72.99 270.73,73.23 270.73,74.5 269.83,75.4 267.7,75.4 266.56,74.26 264.53,74.26 262.37,72.1 259.04,72.1 258.81,72.33 258.81,73.47 257.65,74.63 253.21,74.63 252.33,73.75 250.38,73.75 249.65,74.49 245.93,74.49 245.33,73.96 245.33,73.96 v2(245.1,73.97)
  BOTTOM w0.104: JIO1.39 301.05,28.78 301.09,28.83 303.64,28.83 304.6,29.79 304.6,30.82 v2(304.8,31.01) ; v2(245.1,73.97) 245.1,73.48 245,73.38 245,73.09 U2.A7
USB3_RX_DP3: length 282.3
  TOP w0.104: R528.1 18.29,28.32 CM10.3 18.94,28.32 19.23,28.02 19.56,28.02 19.91,28.36 v2(19.91,28.4)
  IN03 w0.114: v2(19.91,28.4) 19.17,28.4 18.8,28.03 18.8,27.22 19.53,26.5 21.94,26.5 24.35,28.91 24.35,34.27 24.04,34.59 23.37,34.59 23.1,34.86 23.1,38.7 23.34,38.95 23.34,47.7 25.62,49.99 25.62,52.28 26.89,53.55 27.53,53.55 28.54,54.56 28.54,56.34 29.05,56.85 33.12,56.85 34.12,57.85 45.42,57.85 46.71,59.13 54.2,59.13 55.13,58.2 57.96,58.2 60.8,61.04 68.68,61.04 68.8,61.17 85.19,61.17 90.65,66.63 101.82,66.63 102.71,65.74 105.13,65.74 106.02,66.63 109.32,66.63 109.95,65.99 115.54,65.99 116.83,64.71 126.1,64.71 127.87,62.93 136.64,62.93 137.65,61.92 195.68,61.92 199.22,58.37 216.25,58.37 218.28,56.34 220.82,56.34 222.38,57.9 236.14,57.9 237.05,58.82 237.05,61.07 237.61,61.62 240.56,61.62 242.17,63.24 242.17,65.76 243.72,67.3 243.72,67.94 244.19,68.41 244.19,71.96 244.65,72.42 v3(244.65,73.54)
  BOTTOM w0.104: U2.A9 244.13,72.92 244.49,72.92 244.75,73.18 244.75,73.44 v3(244.65,73.54)
USB3_RX_DP3_R: length 7.9
  TOP w0.104: R528.2 17.21,28.32 CM10.4 16.3,28.32 16.15,28.17 15.83,28.17 15.58,28.41 D53.7 D53.4 14.14,28.41 14.02,28.29 13.72,28.29 v2(13.58,28.15) 13.45,28.02 13.45,26.49 13.29,26.33 12.29,26.33 12.05,26.56 JUSB2.6
USB3_RX_DP6: length 99
  IN10 w0.114: v3(241.74,68.37) 241.37,67.99 241.37,67.88 241.37,67.58 242.13,66.81 242.13,63.19 242.41,62.91 247.01,62.91 248.62,61.31 250.14,61.31 250.6,60.85 255.24,60.85 255.53,60.56 256.92,60.56 259.18,62.82 263.88,62.82 265.4,64.34 268.07,64.34 271.48,60.93 277.07,60.93 279.99,58 283.8,58 284.89,56.91 284.89,54.24 286.72,52.42 288.5,52.42 289.41,51.5 289.41,46.29 290.16,45.55 291.31,45.55 292.07,44.78 292.07,43.13 294.74,40.47 294.74,39.96 295.88,38.81 296.82,38.81 300.3,35.34 300.3,30.23 301.43,29.1 302.62,29.1 303.54,28.17 303.54,27.61 v2(303.82,27.33)
  BOTTOM w0.104: v2(303.82,27.33) 303.64,27.15 303.64,26.72 303.35,26.43 301.09,26.43 301.04,26.38 JIO1.45 ; U2.K13 242.14,68.73 241.98,68.73 241.74,68.48 v3(241.74,68.37)
USB3_TX_DN1: length 112.4
  IN10 w0.114: v3(243.53,74.84) 243.81,74.84 244.49,75.52 258.66,75.52 259.03,75.15 262.49,75.15 263.76,76.42 270.08,76.42 271.11,75.39 273.91,75.39 274.54,76.03 276.7,76.03 277.34,75.39 280.77,75.39 282.05,76.67 285.83,76.67 290.18,72.33 290.18,70.29 292.34,68.14 292.34,61.28 299,54.61 300.74,54.61 307.58,47.77 307.58,31.3 v2(307.86,31.01)
  BOTTOM w0.104: U2.C11 243.31,72.07 243.12,72.26 243.12,73.09 243.33,73.3 243.33,74.49 243.53,74.7 v3(243.53,74.84) ; JIO1.35 301.02,30.38 301.07,30.33 302.22,30.33 304.05,32.16 307.18,32.16 307.67,31.67 307.67,31.2 v2(307.86,31.01)
USB3_TX_DN3: length 279.5
  TOP w0.104: v2(21.98,29.58) 21.71,29.85 21.43,29.85 C504.1
  IN03 w0.114: v3(242.95,74.2) 243.05,74.09 243.33,74.09 243.6,73.82 243.6,72.9 242.65,71.95 242.65,67.66 242.05,67.06 241.4,67.06 241.29,67.17 240.84,67.17 240.27,66.59 240.27,65.75 239.76,65.24 237.34,65.24 236.96,64.87 236.96,62.45 236.36,61.85 232.07,61.85 231.42,62.5 227.87,62.5 226.71,61.34 224.05,61.34 222.22,59.52 220.06,59.52 219.42,58.88 217.52,58.88 217.14,59.26 214.22,59.26 210.66,62.82 139.16,62.82 138.16,63.82 128.26,63.82 126.35,65.73 117.08,65.73 115.92,66.88 110.84,66.88 109.39,68.34 106.83,68.34 106.39,67.9 90.65,67.9 84.8,62.06 70.71,62.06 70.2,62.56 60.93,62.56 57.49,59.12 55.86,59.12 54.45,60.53 38.32,60.53 37.29,59.5 33.99,59.5 32.48,57.99 29.94,57.99 29.69,57.74 28.42,57.74 27.4,56.72 26.64,56.72 24.86,54.94 22.7,54.94 20.16,52.41 20.16,42.34 19.16,41.33 19.16,33.6 19.7,33.05 22.37,33.05 23.1,32.33 23.1,29.81 22.87,29.58 v2(21.98,29.58)
  BOTTOM w0.076: v3(242.95,74.2) 242.95,73.99 242.85,73.89 242.58,73.89 242.43,73.74 242.43,72.12 242.38,72.07 242.28,72.07 U2.C13
USB3_TX_DN3_C: length 1.6
  TOP w0.104: C504.2 20,29.5 CM11.2 18.9,29.42 R531.1
USB3_TX_DN3_R: length 8.9
  TOP w0.104: JUSB2.8 12.05,31.96 12.16,32.07 12.93,32.07 13.43,31.58 13.43,29.8 13.7,29.53 14.02,29.53 14.14,29.41 D53.2 D53.9 15.51,29.41 15.64,29.53 16.07,29.53 16.25,29.71 v2(16.25,29.72) 16.26,29.72 16.38,29.85 16.63,29.85 16.98,29.5 CM11.1 17.59,29.5 R531.2
USB3_TX_DN6: length 115
  IN10 w0.114: v3(241.86,74.12) 241.86,74.03 241.39,73.56 241.39,73.4 241.39,73.39 241.39,72.21 242.11,71.5 242.17,71.44 242.17,70.57 245.23,67.5 246.24,67.5 247.48,66.26 247.48,63.98 248.78,62.68 252.11,62.68 252.19,62.6 254.51,62.6 256.01,64.1 256.01,64.99 256.37,65.35 263.99,65.35 266.41,67.77 278.74,67.77 279.37,67.14 279.37,62.82 281.02,61.17 285.6,61.17 289.28,57.48 290.29,57.48 291.31,56.47 291.31,49.36 292.96,47.7 292.96,46.82 295.5,44.28 296.13,44.28 297.64,42.76 297.64,39.06 300.92,35.79 300.92,30.49 301.68,29.73 306.69,29.73 306.89,29.53 306.89,29.07 v2(306.72,28.9)
  BOTTOM w0.076: U2.B15 241.17,72.58 241.37,72.78 241.37,73.63 v3(241.86,74.12)
  BOTTOM w0.104: JIO1.41 301.06,27.98 301.2,27.84 301.72,27.84 302.1,28.22 305.4,28.22 305.72,27.91 306.74,27.91 307.12,28.29 307.12,28.81 306.95,28.98 306.81,28.98 v2(306.72,28.9)
USB3_TX_DN6_C: length 1.5
  TOP w0.104: CM14.2 22.65,59.56 arc(22.88,59.72) 23.15,59.77 23.41,59.77 arc(23.68,59.66) C621.2
USB3_TX_DP1: length 112.3
  IN10 w0.114: v2(307.03,31.01) 307.19,31.01 307.31,31.13 307.31,31.43 307.17,31.56 307.17,31.88 307.31,32.02 307.31,32.34 307.17,32.48 307.17,32.8 307.31,32.93 307.31,33.42 307.19,33.54 307.19,33.93 307.31,34.05 307.31,47.66 300.63,54.34 298.89,54.34 292.07,61.17 292.07,68.02 289.91,70.18 289.91,72.22 285.72,76.41 282.16,76.41 280.88,75.12 277.23,75.12 276.59,75.76 274.65,75.76 274.02,75.12 271,75.12 269.97,76.15 263.87,76.15 262.6,74.88 258.92,74.88 258.55,75.25 244.6,75.25 243.71,74.36 v3(243.71,74.29)
  BOTTOM w0.104: v2(307.03,31.01) 307.14,30.9 307.27,30.9 307.42,31.04 307.42,31.56 307.08,31.9 304.16,31.9 302.32,30.07 301.11,30.07 301.02,29.98 JIO1.36 ; v3(243.71,74.29) 243.71,74.47 243.87,74.63 244.06,74.63 244.17,74.52 244.17,74.23 243.87,73.92 243.71,73.92 243.59,73.8 243.59,73.03 243.42,72.85 U2.B11
