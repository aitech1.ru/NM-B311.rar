# Allegro board NM-B311.BRD (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PC704  -  [C_0402NEW]  302.1 100.33 90 bottom
PC706  -  [C_B2]  278.95 104.19 0 bottom
PC707  -  [C_B2]  285.61 95.33 180 top
PC709  -  [C_0402NEW]  212.57 168.18 270 bottom
PC710  -  [C_0805NEW]  211.17 168.57 270 top
PC711  -  [C_0805NEW]  211.17 168.55 270 bottom
PC712  -  [C_0603NEW]  215.35 165.37 270 top
PC713  -  [C_0805NEW]  212.02 157.43 180 bottom
PC714  -  [C_0805NEW]  218.08 155.49 0 bottom
PC715  -  [C_0805NEW]  218.08 157.27 0 bottom
PC716  -  [C_0805NEW]  211.77 155.22 180 bottom
PC717  -  [C_0402NEW]  218.21 164.29 0 top
PC718  -  [C_0603NEW]  218.19 168.25 90 bottom
PC719  -  [C_0603NEW]  215.04 169.84 0 top
PC720  -  [C_0402NEW]  211.55 160.18 270 bottom
PC721  -  [C_0402NEW]  219.12 166.07 180 bottom
PC722  -  [C_0805NEW]  296.38 101.22 180 top
PC723  -  [C_0805NEW]  296.38 93.09 180 top
PC724  -  [C_B2]  276.85 83.65 180 top
PC725  -  [C_B2]  272.79 107.65 180 bottom
PC726  -  [C_0805NEW]  282.35 125.3 0 top
PC727  -  [C_0805NEW]  282.35 127.21 0 top
PC728  -  [C_0805NEW]  277.63 86.82 0 top
PC729  -  [C_0805NEW]  277.63 88.73 0 top
PC730  -  [C_B2]  287.04 101.93 180 top
PC731  -  [C_B2]  284.22 98.63 180 bottom
PC801  -  [C_0402NEW]  295.7 185.5 180 bottom
PC803  -  [C_0402NEW]  289.07 178.9 0 top
PC809  -  [C_0402NEW]  293.59 188.6 90 top
PC820  -  [C_0402NEW]  105.05 94.06 0 top
PC901  -  [C_0402NEW]  254.6 203.97 90 top
PC902  -  [C_0805NEW]  253.59 203.19 90 bottom
PC903  -  [C_0805NEW]  252.15 202.39 180 bottom
PC904  -  [C_0805NEW]  252.15 204.17 180 bottom
PC905  -  [C_0805NEW]  251.77 202.39 180 top
PC906  0.1U_0603_16V7K  [C_0603]  256.13 202.58 90 bottom
PC907  -  [C_0402]  259.2 197.51 270 bottom
PC908  -  [C_0805NEW]  253.21 203.19 90 top
PC909  -  [C_0402NEW]  254.98 203.58 90 bottom
PC910  -  [C_D2]  257.04 186.54 90 top
PC911  -  [C_0402NEW]  249.27 197.11 90 bottom
PC912  -  [C_0805NEW]  259.21 181.31 0 bottom
PC913  -  [C_0805NEW]  251.64 181.31 180 top
PC914  -  [C_0805NEW]  251.26 181.31 180 bottom
PC915  -  [C_0805NEW]  259.21 181.31 0 top
PC916  -  [C_0805NEW]  272.42 179.28 0 top
PC917  -  [C_0402NEW]  267.05 203.58 90 top
PC918  -  [C_0805NEW]  264.22 202.39 180 bottom
PC919  -  [C_0805NEW]  265.65 203.19 90 bottom
PC920  -  [C_0805NEW]  264.22 204.17 180 bottom
PC921  -  [C_0805NEW]  264.22 202.39 180 top
PC922  -  [C_0805NEW]  251.77 204.17 180 top
PC923  -  [C_0402NEW]  267.05 203.58 90 bottom
PC924  -  [C_D2]  260.47 126.83 180 top
PC925  -  [C_0805NEW]  265.36 181.31 180 top
PC926  -  [C_0805NEW]  265.36 179.28 180 top
PC927  -  [C_0402NEW]  261.46 196.98 90 bottom
PC928  -  [C_0805NEW]  265.36 180.55 180 bottom
PC929  -  [C_0805NEW]  251.64 179.4 180 top
PC930  -  [C_1206]  258.35 179.28 0 top
PC931  -  [C_1206]  272.07 181.31 0 top
PC932  -  [C_0805NEW]  272.04 181.31 0 bottom
PC933  -  [C_D2]  251.96 186.54 90 top
PC934  -  [C_0805NEW]  265.65 203.19 90 top
PC935  -  [C_D2]  264.15 186.54 90 top
PC936  -  [C_0805NEW]  264.22 204.17 180 top
PC937  -  [C_D2]  239.77 186.54 90 top
PC938  -  [C_B2]  216.1 177.88 0 bottom
PC939  -  [C_B2]  219.7 177.88 180 bottom
PC940  -  [C_B2]  228.42 177.88 0 bottom
PC972  -  [C_0402NEW]  259.25 195.66 180 bottom
PC973  -  [C_0402NEW]  271.44 195.28 180 bottom
PC1001  -  [C_0402NEW]  218.41 203.58 90 top
PC1002  -  [C_0805NEW]  215.32 202.39 180 top
PC1003  -  [C_0805NEW]  215.32 204.17 180 top
PC1004  -  [C_0805NEW]  217.01 203.19 90 top
PC1005  -  [C_0805NEW]  215.3 202.39 180 bottom
PC1006  0.1U_0603_16V7K  [C_0603]  219.55 202.58 90 bottom
PC1007  0.1U_0603_16V7K  [C_0603]  231.74 202.58 90 bottom
PC1008  -  [C_D2]  220.47 186.54 90 top
PC1009  -  [C_D2]  246.83 135.21 0 top
PC1010  -  [C_D2]  227.58 186.54 90 top
PC1011  -  [C_0402NEW]  212.8 197.23 90 bottom
PC1012  -  [C_0805NEW]  214.81 180.42 180 top
PC1013  -  [C_0805NEW]  221.11 181.44 0 bottom
PC1014  -  [C_0805NEW]  214.81 180.42 180 bottom
PC1015  -  [C_0805NEW]  221.11 179.4 0 top
PC1016  -  [C_0805NEW]  233.18 181.31 0 bottom
PC1017  -  [C_0402NEW]  230.47 203.58 90 top
PC1018  -  [C_0805NEW]  227.64 202.39 180 bottom
PC1019  -  [C_0805NEW]  227.64 204.17 180 bottom
PC1020  -  [C_0805NEW]  229.08 203.19 90 top
PC1021  -  [C_0805NEW]  229.08 203.19 90 bottom
PC1022  -  [C_0402NEW]  218.41 203.58 90 bottom
PC1023  -  [C_0805NEW]  221.11 181.44 0 top
PC1024  -  [C_D2]  232.66 186.54 90 top
PC1025  -  [C_0805NEW]  226.88 181.31 180 bottom
PC1026  -  [C_0805NEW]  233.18 181.31 0 top
PC1027  -  [C_0402NEW]  225.01 196.98 90 bottom
PC1028  -  [C_0805NEW]  226.88 181.31 180 top
PC1029  -  [C_1206]  219.74 177.24 0 top
PC1030  -  [C_0805NEW]  233.18 179.4 0 top
PC1031  -  [C_1206]  228.12 179.4 180 top
PC1032  -  [C_0805NEW]  227.64 204.17 180 top
PC1033  -  [C_0805NEW]  227.64 202.39 180 top
PC1034  -  [C_0805NEW]  215.3 204.17 180 bottom
PC1035  -  [C_0805NEW]  217.01 203.19 90 bottom
PC1036  -  [C_0402NEW]  230.47 203.58 90 bottom
PC1072  -  [C_0402]  222.6 197.51 270 bottom
PC1074  -  [C_0402NEW]  222.68 195.66 180 bottom
PC1081  -  [C_0402NEW]  234.84 195.66 180 bottom
PC1082  -  [C_0402]  234.79 197.51 270 bottom
PC1120  -  [C_0402]  122.19 199.55 270 bottom
PC1130  -  [C_0402NEW]  124.5 198.38 0 top
PC1133  -  [C_0402]  121.25 197.77 0 bottom
PC1137  -  [C_0402]  116.83 196.5 90 top
PC1139  -  [C_0402]  117.75 196.52 90 top
PC1140  -  [C_0402NEW]  124.48 199.32 0 top
PC1141  -  [C_0402]  121.91 185.17 0 top
PC1142  -  [C_0402]  127.73 185.17 90 top
PC1143  -  [C_0402]  121.91 184.28 0 top
PC1145  -  [C_0402NEW]  128.57 196.17 180 top
PC1147  -  [C_0402NEW]  130.35 196.17 180 top
PC1148  -  [C_0402NEW]  132.48 194.92 90 top
PC1149  -  [C_0402]  124.58 184.31 90 bottom
PC1150  -  [C_0402]  123.67 186.08 0 bottom
PC1151  -  [C_0402]  124.81 184.31 90 top
PC1152  -  [C_0402NEW]  119.73 189.18 0 top
PC1153  -  [C_0402]  119.7 185.91 0 top
PC1154  -  [C_0402NEW]  125.8 185.17 0 bottom
PC1155  -  [C_0402NEW]  125.8 184.31 0 bottom
PC1156  -  [C_0603NEW]  119.13 191.47 0 bottom
PC1157  -  [C_0402NEW]  118.03 194.52 180 top
PC1158  -  [C_0402]  122.22 200.13 270 top
PC1159  -  [C_0402NEW]  119.65 194.5 0 bottom
PC1160  -  [C_0402]  119.65 195.41 0 top
PC1161  -  [C_0402]  126.59 200.18 270 bottom
PC1162  -  [C_0402NEW]  129.58 193.88 180 bottom
PC1163  -  [C_0402NEW]  120.62 187.4 180 top
PC1166  -  [C_0402NEW]  129.71 186.01 180 top
PC1167  -  [C_0402NEW]  132.38 186.26 180 top
PC1221  22U_0805_25V  [C_0805]  127.22 155.24 270 top
PC1222  -  [C_0402]  134.54 157.74 270 bottom
PC1225  -  [C_0402NEW]  136.09 152.28 0 bottom
PC1226  -  [C_0402]  190.72 127.92 0 top
PC1227  -  [C_0402]  207.36 153.47 270 top
PC1251  -  [C_0402NEW]  205.66 153.5 180 top
PC1253  -  [C_0603NEW]  207 157.42 90 top
PC1254  -  [C_0402NEW]  204.69 155.25 270 top
PC1255  -  [C_0402NEW]  203.88 157.18 180 top
PC1256  -  [C_0402NEW]  201.21 150.96 180 top
PC1257  -  [C_0402NEW]  189.91 127.71 180 top
PC1258  -  [C_0402NEW]  190.85 130.94 90 top
PC1259  -  [C_0402NEW]  187.5 128.98 180 top
PC1260  -  [C_0402NEW]  187.5 129.87 180 top
PC1264  -  [C_0603NEW]  264.57 73.87 0 top
PC1265  -  [C_0603NEW]  265.21 64.34 0 top
PC1269  -  [C_0402NEW]  219.93 45.62 270 bottom
PC1270  0.1U_0603_16V7K  [C_0603]  134.92 140.91 270 bottom
PC1271  -  [C_0402]  134.51 147.45 270 bottom
PC1272  -  [C_0402]  137 153.22 0 bottom
PC1273  -  [C_0402]  128.26 144.58 180 bottom
PC1274  0.1U_0603_16V7K  [C_0603]  132.48 140.88 270 bottom
PC1275  -  [C_0402]  128.24 150.42 90 bottom
PC1276  0.1U_0603_16V7K  [C_0603]  136.16 140.91 270 bottom
PC1277  -  [C_0402]  128.59 155.3 270 bottom
PC1278  22U_0805_25V  [C_0805]  127.22 155.24 270 bottom
PC1279  0.1U_0603_16V7K  [C_0603]  133.73 140.91 270 bottom
PC1280  -  [C_0402NEW]  131.67 156.77 0 bottom
PC1281  0.1U_0603_16V7K  [C_0603]  128.86 142.6 180 bottom
PC1282  0.1U_0603_16V7K  [C_0603]  128.84 141.35 180 bottom
PC1301  -  [C_0603NEW]  62.14 38.81 0 bottom
PC1302  -  [C_0402NEW]  62.38 39.96 0 bottom
PC1304  -  [C_0805NEW]  65.75 41.39 90 bottom
PC1305  -  [C_0603NEW]  22.83 16.91 90 top
PC1306  -  [C_0402NEW]  18.84 14.3 180 top
PC1307  -  [C_0402NEW]  152.43 200.21 180 bottom
PC1308  -  [C_0805NEW]  15.84 17.39 90 top
PC1310  -  [C_0402NEW]  180.89 194.14 180 bottom
PC1311  -  [C_0402NEW]  198.16 193.4 90 top
PC1312  -  [C_0402NEW]  178.48 196.42 180 bottom
PC1313  -  [C_0402NEW]  196.59 193.4 90 top
PC1314  -  [C_0402NEW]  197.99 194.21 270 bottom
PC1315  -  [C_0603NEW]  202.91 153.94 90 top
PC1316  -  [C_0402]  202.79 152.17 270 top
PC1317  -  [C_0402]  149.44 197.83 0 bottom
PC1319  -  [C_0402NEW]  153.96 198.64 270 bottom
PC1323  -  [C_0402NEW]  150.35 198.77 180 bottom
PC1325  -  [C_0402NEW]  195.73 192.87 0 bottom
PC1326  -  [C_0805NEW]  190.89 197.06 0 bottom
PC1327  -  [C_0402NEW]  198.98 152.66 90 top
PC1328  -  [C_0402NEW]  187.85 197.56 0 bottom
PC1329  -  [C_0402]  201.21 151.84 180 top
PC1417  22U_0805_25V  [C_0805]  238.98 109.64 270 bottom
PC1418  22U_0805_25V  [C_0805]  241.48 104.09 180 bottom
PC1419  22U_0805_25V  [C_0805]  218.28 109.64 270 bottom
PC1420  22U_0805_25V  [C_0805]  233.62 109.13 270 top
PC1422  -  [C_0402NEW]  286.56 189.44 180 top
PC1423  -  [C_0402NEW]  286.56 186.77 180 top
PC1424  -  [C_0402NEW]  286.56 184.1 180 top
PC1425  -  [C_0402NEW]  286.56 181.44 180 top
PC1426  -  [C_0402NEW]  286.56 178.77 180 top
PC1427  -  [C_0402]  288.13 179.86 270 top
PC1429  -  [C_0402]  294.56 177.88 180 top
PC1430  -  [C_0402]  296.51 179.73 270 top
PC1431  -  [C_0402]  297.4 179.73 270 top
PC1432  -  [C_0402]  297.1 182.83 180 top
PC1501  22U_0805_25V  [C_0805]  181.58 190.74 90 bottom
PC1502  22U_0805_25V  [C_0805]  174.8 190.74 270 top
PC1503  22U_0805_25V  [C_0805]  170.78 190.74 90 bottom
PC1504  22U_0805_25V  [C_0805]  169.62 190.74 270 top
PC1505  22U_0805_25V  [C_0805]  173.07 190.74 270 top
PC1506  22U_0805_25V  [C_0805]  172.56 190.74 90 bottom
PC1508  -  [C_EEEFK1E680P]  153.38 188.71 90 bottom
PC1510  0.1U_0603_16V7K  [C_0603]  163.24 191.08 90 bottom
PC1511  -  [C_0402]  165.91 186.26 180 top
PC1512  -  [C_0402NEW]  162.58 183.47 0 bottom
PC1513  -  [C_D2]  195.8 177.6 90 top
PC1514  -  [C_D2]  190.98 177.6 90 top
PC1515  -  [C_D2]  168.12 177.6 90 top
PC1516  22U_0805_25V  [C_0805]  165.79 169.12 180 bottom
PC1517  22U_0805_25V  [C_0805]  165.79 170.89 180 bottom
PC1518  22U_0805_25V  [C_0805]  160.28 171.91 0 top
PC1519  22U_0805_25V  [C_0805]  154.11 171.91 180 top
PC1520  -  [C_0402NEW]  154.05 186.33 0 bottom
PC1521  -  [C_D2]  159.23 177.6 90 top
PC1522  -  [C_D2]  179.93 177.6 90 top
PC1523  22U_0805_25V  [C_0805]  203.42 190.74 90 bottom
PC1524  22U_0805_25V  [C_0805]  194.28 190.74 270 top
PC1525  22U_0805_25V  [C_0805]  161.77 190.74 270 top
PC1526  22U_0805_25V  [C_0805]  159.99 190.74 270 top
PC1527  22U_0805_25V  [C_0805]  158.21 190.74 90 bottom
PC1529  22U_0805_25V  [C_0805]  185.72 190.74 270 top
PC1530  0.1U_0603_16V7K  [C_0603]  174.09 191.15 90 bottom
PC1531  -  [C_0402]  176.7 186.39 180 top
PC1532  -  [C_0402NEW]  175.18 183.34 180 bottom
PC1533  0.1U_0603_16V7K  [C_0603]  173.26 173.56 0 top
PC1534  0.1U_0603_16V7K  [C_0603]  173.26 172.29 0 top
PC1535  0.1U_0603_16V7K  [C_0603]  166.28 171.02 180 top
PC1536  0.1U_0603_16V7K  [C_0603]  170.47 142.07 180 top
PC1537  0.1U_0603_16V7K  [C_0603]  166.28 173.56 180 top
PC1538  0.1U_0603_16V7K  [C_0603]  173.26 171.02 0 top
PC1539  0.1U_0603_16V7K  [C_0603]  170.59 144.48 180 top
PC1540  0.1U_0603_16V7K  [C_0603]  166.28 172.29 180 top
PC1541  -  [C_0402NEW]  166.34 184.15 90 bottom
PC1542  -  [C_0402]  271.37 197.51 270 bottom
PC1543  -  [C_D2]  172.94 177.6 90 top
PC1544  -  [C_D2]  184.75 177.6 90 top
PC1545  -  [C_0402NEW]  197.35 190.07 270 top
PC1546  -  [C_0402NEW]  190.85 191.52 90 bottom
PC1547  -  [C_0402NEW]  199.61 190.15 270 top
PC1548  -  [C_0402NEW]  198.72 190.15 270 top
PC1549  -  [C_EEEFK1E680P]  168.41 197.06 0 bottom
PC1602  22U_0805_25V  [C_0805]  201.52 190.74 270 top
PC1603  22U_0805_25V  [C_0805]  161.77 190.74 90 bottom
PC1604  22U_0805_25V  [C_0805]  203.3 190.74 270 top
PC1605  22U_0805_25V  [C_0805]  201.64 190.74 90 bottom
PC1606  22U_0805_25V  [C_0805]  192.5 190.74 270 top
PC1607  22U_0805_25V  [C_0805]  183.36 190.74 90 bottom
PC1608  0.1U_0603_16V7K  [C_0603]  196.44 190.52 90 bottom
PC1609  -  [C_0402]  198.77 186.26 0 bottom
PC1610  -  [C_0402NEW]  197.91 183.98 180 bottom
PC1611  0.1U_0603_16V7K  [C_0603]  196.5 172.29 0 top
PC1612  0.1U_0603_16V7K  [C_0603]  189.14 172.29 180 top
PC1613  0.1U_0603_16V7K  [C_0603]  171.23 155.4 180 top
PC1614  0.1U_0603_16V7K  [C_0603]  196.5 173.56 0 top
PC1615  0.1U_0603_16V7K  [C_0603]  170.59 146.13 180 top
PC1616  0.1U_0603_16V7K  [C_0603]  196.5 171.02 0 top
PC1617  0.1U_0603_16V7K  [C_0603]  189.14 171.02 180 top
PC1618  0.1U_0603_16V7K  [C_0603]  189.14 173.56 180 top
PC1619  -  [C_0402NEW]  188.84 184.36 180 bottom
PC1620  22U_0805_25V  [C_0805]  163.54 190.74 270 top
PC1621  22U_0805_25V  [C_0805]  196.06 190.74 270 top
PC1622  22U_0805_25V  [C_0805]  182.26 190.74 270 top
PC1623  22U_0805_25V  [C_0805]  180.54 190.74 270 top
PC1624  22U_0805_25V  [C_0805]  171.34 190.74 270 top
PC1625  22U_0805_25V  [C_0805]  206.85 190.74 270 top
PC1626  22U_0805_25V  [C_0805]  183.99 190.74 270 top
PC1627  0.1U_0603_16V7K  [C_0603]  184.88 191.15 90 bottom
PC1628  -  [C_0402]  187.04 186.19 90 top
PC1629  -  [C_0402NEW]  187.12 183.98 180 bottom
PC1630  0.1U_0603_16V7K  [C_0603]  170.47 150.07 180 top
PC1631  0.1U_0603_16V7K  [C_0603]  178.34 173.56 180 top
PC1632  0.1U_0603_16V7K  [C_0603]  170.49 140.34 180 top
PC1633  0.1U_0603_16V7K  [C_0603]  184.44 171.02 0 top
PC1634  0.1U_0603_16V7K  [C_0603]  178.34 171.02 180 top
PC1635  0.1U_0603_16V7K  [C_0603]  178.34 172.29 180 top
PC1636  0.1U_0603_16V7K  [C_0603]  184.44 173.56 0 top
PC1637  0.1U_0603_16V7K  [C_0603]  184.44 172.29 0 top
PC1638  -  [C_0402NEW]  177.18 185.37 0 bottom
PC1639  22U_0805_25V  [C_0805]  205.2 190.74 90 bottom
PC1640  22U_0805_25V  [C_0805]  192.37 190.74 90 bottom
PC1641  22U_0805_25V  [C_0805]  205.07 190.74 270 top
PC1642  22U_0805_25V  [C_0805]  190.72 190.74 270 top
PC1643  22U_0805_25V  [C_0805]  194.15 190.74 90 bottom
PC1644  22U_0805_25V  [C_0805]  159.99 190.74 90 bottom
PC1645  22U_0805_25V  [C_0805]  158.21 190.74 270 top
PC1646  -  [C_0402NEW]  169.26 191.27 90 bottom
PC1647  -  [C_0402]  209.7 186.26 0 bottom
PC1648  -  [C_0402NEW]  208.83 183.98 180 bottom
PC1649  0.1U_0603_16V7K  [C_0603]  207.55 174.83 0 top
PC1650  0.1U_0603_16V7K  [C_0603]  207.36 190.52 90 bottom
PC1651  -  [C_0402NEW]  179.22 190.17 270 top
PC1652  0.1U_0603_16V7K  [C_0603]  201.2 174.83 180 top
PC1653  0.1U_0603_16V7K  [C_0603]  207.55 172.29 0 top
PC1654  0.1U_0603_16V7K  [C_0603]  207.55 173.56 0 top
PC1655  0.1U_0603_16V7K  [C_0603]  201.2 173.56 180 top
PC1656  -  [C_D2]  206.72 177.6 90 top
PC1657  -  [C_D2]  201.9 177.6 90 top
PC1658  0.1U_0603_16V7K  [C_0603]  201.2 172.29 180 top
PC1659  -  [C_0402NEW]  201.06 185.68 90 bottom
PC1660  22U_0805_25V  [C_0805]  200.97 172.29 180 bottom
PC1661  22U_0805_25V  [C_0805]  207.27 169.5 0 top
PC1662  0.1U_0603_16V7K  [C_0603]  201.2 171.02 180 top
PC1663  0.1U_0603_16V7K  [C_0603]  207.55 171.02 0 top
PC1664  -  [C_0402NEW]  180.05 191.39 90 bottom
PC1665  -  [C_0402NEW]  168.04 190.66 270 top
PC1666  -  [C_0402NEW]  164.87 190.12 270 top
PC1667  -  [C_0402NEW]  157.7 189.54 270 bottom
PC1799  -  [C_D2]  234.44 103.23 270 top
PC1800  -  [C_D2]  229.71 103.23 270 top
PC1801  -  [C_D2]  239.14 103.23 270 top
PC1802  -  [C_0603NEW]  258.29 130.32 90 top
PC1803  -  [C_0603NEW]  251.94 130.32 90 top
PC1804  -  [C_0603NEW]  219.83 107.81 90 top
PC1805  -  [C_0603NEW]  221.1 107.81 90 top
PC1806  -  [C_0603NEW]  222.37 107.81 90 top
PC1807  -  [C_0603NEW]  236.39 107.81 90 top
PC1808  -  [C_0603NEW]  237.66 107.81 90 top
PC1809  -  [C_0603NEW]  223.62 107.81 90 top
PC1810  -  [C_0603NEW]  235.12 107.81 90 top
PC1811  -  [C_0603NEW]  245.59 131.72 270 top
PC1812  -  [C_0402NEW]  232.25 108.21 90 top
PC1813  -  [C_0402NEW]  240.43 106.89 0 bottom
PC1814  -  [C_0402NEW]  240.43 105.87 0 bottom
PC1815  -  [C_0402NEW]  232.25 108.21 90 bottom
PC1939  -  [C_D2]  215.39 186.54 90 top
PC2264  22U_0805_25V  [C_0805]  237.2 109.64 270 bottom
PC2268  -  [C_D2]  225.01 103.23 270 top
PC3401  -  [C_0402]  295.48 96.65 180 top
PC3407  -  [C_0402]  299.87 97.36 0 top
PC3409  0.1U_0603_16V7K  [C_0603]  299.05 101.49 270 bottom
PC3416  -  [C_0402NEW]  292.12 106.38 0 top
PC3424  -  [C_0402]  304.21 100.33 90 bottom
PC3425  0.1U_0603_16V7K  [C_0603]  298.8 93.11 90 bottom
PC3426  -  [C_0402]  297.94 98.12 270 bottom
PC3433  -  [C_0402NEW]  291.48 92.03 0 top
PC3434  -  [C_0402NEW]  305 97.49 0 bottom
PC3435  -  [C_0402]  304.95 98.63 0 bottom
PC3436  -  [C_0402]  306.04 95.71 270 bottom
PC3438  -  [C_0402NEW]  308.38 92.79 0 bottom
PC3439  -  [C_0402NEW]  304.77 92.56 90 bottom
PC3501  -  [C_0805NEW]  295.62 99.44 180 top
PC3502  -  [C_0805NEW]  295.62 99.44 180 bottom
PC3503  -  [C_0805NEW]  298.74 94.11 0 top
PC3504  -  [C_0805NEW]  296.38 94.87 180 top
PC3505  -  [C_0402NEW]  214.22 95.15 270 bottom
PC3506  -  [C_0402]  210.66 100.71 90 bottom
PC3507  -  [C_0402NEW]  211.63 98.63 180 bottom
PC3508  -  [C_0402NEW]  239.49 94.39 270 bottom
PC3509  -  [C_0402]  217.32 98.5 0 bottom
PC3510  -  [C_0402]  211.3 95.15 270 bottom
PC3511  -  [C_0402]  228.47 90.22 90 bottom
PC3512  -  [C_0402]  224.03 86.18 270 bottom
PC3513  -  [C_0402NEW]  226.99 93.55 180 bottom
PC3514  -  [C_0402NEW]  211.63 103.46 180 bottom
PC3515  0.1U_0603_16V7K  [C_0603]  217.52 94.25 90 bottom
PC3516  -  [C_0402]  213.79 101.68 180 bottom
PC3518  -  [C_0402]  209.26 95.15 270 bottom
PC3519  0.1U_0603_16V7K  [C_0603]  218.73 100.77 180 bottom
PC3520  -  [C_0805NEW]  225.52 86.66 270 top
PC3521  -  [C_0805NEW]  226.89 89.32 90 bottom
PC3522  -  [C_0805NEW]  229.95 89.32 90 bottom
PC3523  -  [C_0805NEW]  233.59 86.74 0 bottom
PC3524  -  [C_0805NEW]  233.59 88.01 0 top
PC3525  -  [C_0805NEW]  229.95 89.32 90 top
PC3526  -  [C_0805NEW]  225.52 86.66 270 bottom
PC3527  -  [C_0805NEW]  226.89 89.32 90 top
PC3528  -  [C_0402NEW]  126.12 133.78 180 bottom
PC3529  -  [C_0805NEW]  124.17 120.56 270 bottom
PC3530  -  [C_0805NEW]  122.4 120.56 270 bottom
PC3531  -  [C_0805NEW]  120.7 137.81 90 bottom
PC3532  -  [C_0603NEW]  124.79 135.71 0 bottom
PC3533  -  [C_0603NEW]  121.7 133.74 270 top
PC3534  -  [C_0805NEW]  118.84 135.8 270 top
PC3535  -  [C_0402NEW]  119.05 135.28 270 bottom
PC3536  -  [C_0805NEW]  125.95 120.56 270 bottom
PC3537  -  [C_0805NEW]  118.84 120.56 270 bottom
PC3538  -  [C_0402NEW]  119.37 125.8 180 bottom
PC3539  -  [C_0603NEW]  123.86 136.92 90 bottom
PC3540  -  [C_0805NEW]  120.62 120.56 270 bottom
PC3541  -  [C_0402]  123.94 131.14 180 bottom
PC3542  -  [C_0402]  297.22 189.44 180 top
PC3543  -  [C_0402]  295.37 188.6 90 top
PC3544  -  [C_0805NEW]  239.07 181.31 180 top
PC3546  -  [C_0805NEW]  245.37 179.4 0 top
PC3547  0.1U_0603_16V7K  [C_0603]  243.94 202.58 90 bottom
PC3548  -  [C_0805NEW]  239.96 204.17 180 top
PC3550  -  [C_0805NEW]  239.96 204.17 180 bottom
PC3551  -  [C_0402NEW]  237.08 196.85 90 bottom
PC3552  -  [C_0402NEW]  242.79 203.58 90 bottom
PC3553  -  [C_0805NEW]  245.37 181.31 0 top
PC3554  -  [C_0805NEW]  239.96 202.39 180 top
PC3555  -  [C_0805NEW]  241.4 203.19 90 top
PC3556  -  [C_0402NEW]  246.81 195.66 180 bottom
PC3557  -  [C_0805NEW]  239.96 202.39 180 bottom
PC3558  -  [C_0402]  246.98 197.51 270 bottom
PC3559  -  [C_0805NEW]  239.07 181.31 180 bottom
PC3560  -  [C_0805NEW]  241.4 203.19 90 bottom
PC3561  -  [C_0402NEW]  242.79 203.58 90 top
PC3562  -  [C_1206]  244.63 180.17 0 bottom
PC3563  -  [C_0805NEW]  239.07 179.4 180 top
PC3564  -  [C_D2]  228.67 103.86 270 bottom
PC3565  -  [C_D2]  220.31 103.23 270 top
PC3566  VAL  [1005_BGA]  209.52 124.37 90 top
PC3567  -  [C_0402NEW]  212.44 123.7 90 top
PC3568  -  [C_0805NEW]  233.65 107.94 90 bottom
PC3569  -  [C_0805NEW]  235.43 107.94 90 bottom
PC3570  -  [C_0402]  211.63 97.49 180 bottom
PC3571  -  [C_0402NEW]  212.69 103.53 270 bottom
PC3572  -  [C_0402]  298.22 188.8 0 top
PC3575  -  [C_0402]  296.59 181.08 90 top
PC3576  -  [C_0402]  289.07 179.78 0 top
PC3577  -  [C_0402NEW]  210.59 120.65 90 bottom
PC3578  -  [C_0402NEW]  211.47 120.65 90 bottom
PC3579  -  [C_0402NEW]  207.61 121.06 270 bottom
PC3580  -  [C_0603NEW]  306.92 198.87 90 bottom
PC3588  -  [C_D2]  244.95 186.54 90 top
PC3589  -  [C_D2]  269.23 186.54 90 top
PC3590  -  [C_0402]  291.81 178.95 90 top
PC3591  0.1U_0603_16V7K  [C_0603]  271.21 12.19 0 top
PC3592  -  [C_0402]  283.72 11.25 270 top
PC3593  -  [C_0402NEW]  286.69 10.34 90 top
PC3594  22U_0805_25V  [C_0805]  275.84 12.03 270 top
PC3595  -  [C_0402]  282.07 11.99 270 top
PC3596  -  [C_0402]  279.78 12.06 270 top
PC3597  22U_0805_25V  [C_0805]  288.26 18.67 0 top
PC3598  22U_0805_25V  [C_0805]  274.07 12.03 270 top
PC3599  0.1U_0603_16V7K  [C_0603]  270.57 17.78 180 top
PC3600  22U_0805_25V  [C_0805]  287.57 16.43 0 top
PC3601  -  [C_0402NEW]  279.7 21.21 0 top
PC3602  22U_0805_25V  [C_0805]  281.81 18.33 90 top
PC3603  -  [C_0402NEW]  266.06 20.75 90 top
PD101  -  [AZ5425-01F_DFN1006P2E2]  31.55 24.08 0 bottom
PD201  -  [RB751V-40_SOD323-2]  95.6 6.1 270 top
PD202  -  [RB751V-40_SOD323-2]  95.6 9.35 270 bottom
PD401  -  [SDM10U45LP-7_DFN1006-2-2]  208.83 109.43 90 bottom
PD601  -  [B140HW-7_SOD123-2]  276.09 58.4 270 top
PD602  -  [B140HW-7_SOD123-2]  286.16 16.23 180 top
PD801  -  [RB751V-40_SOD323-2]  298.67 184.92 270 bottom
PF101  -  [F3_2X1_6-2_95]  93.69 19.64 0 bottom
PF102  -  [F3_2X1_6-2_95]  27.53 20.91 90 top
PH201  -  [R_0402NEW]  98.52 4.7 90 top
PH1103  -  [R_0402]  150.29 177.3 90 bottom
PH1105  -  [R_0402]  150.34 175.52 90 bottom
PH1106  -  [R_0402]  208.63 178.46 270 bottom
PH1107  -  [R_0402]  208.63 176.56 270 bottom
PH1108  -  [R_0402NEW]  272.51 191.67 270 bottom
PJ4  -  [JUMP_43X79_7]  267.31 39.82 135 bottom
PJ7  -  [JUMP_43X79_7]  285.25 56.98 180 top
PJ8  -  [JUMP_43X79_7]  285.97 77.13 90 bottom
PJ9  -  [JUMP_43X79_7]  287.24 81.02 270 bottom
PJ10  -  [JUMP_43X79_7]  91.41 61.63 90 bottom
PJ11  -  [JUMP_43X79_7]  91.28 65.27 270 bottom
PJ12  -  [JUMP_43X79_7]  41.75 73.78 270 top
PJ15  -  [JUMP_43X118]  172.69 118.05 90 top
PJ16  -  [JUMP_43X118]  266.46 69.93 180 top
PJ17  -  [JUMP_43X79_7]  253.21 77 90 top
PJ18  -  [JUMP_43X79_7]  222.05 45.67 0 bottom
PJ301  -  [JUMP_43X118]  58.77 23.64 270 top
PJ302  -  [JUMP_43X118]  23.17 9.6 0 top
PJ303  -  [JUMP_43X118]  52.93 28.87 90 top
PJ401  -  [JUMP_43X79]  105.21 80.34 0 top
PJ402  -  [JUMP_43X118]  120.24 71.03 90 bottom
PJ403  -  [JUMP_43X118]  125.36 74.12 180 bottom
PJ404  -  [JUMP_43X79]  118.59 85.47 270 top
PJ405  -  [JUMP_43X39]  216.5 113.82 270 top
PJ501  -  [JUMP_43X39]  259.12 44.66 180 top
PJ502  -  [JUMP_43X79_7]  262.4 64.05 270 top
PJ602  -  [JUMP_43X39]  86.33 44.99 270 top
PJ610  -  [JUMP_43X39]  70.28 47.83 180 top
PJ611  -  [JUMP_43X39]  86.2 57.05 270 top
PJ701  -  [JUMP_43X118]  283.05 102.74 270 top
PJ702  -  [JUMP_43X118]  278.82 96.85 0 top
PJ703  -  [JUMP_43X79]  214.25 154.14 90 bottom
PJ704  -  [JUMP_43X79]  212.5 170.24 90 bottom
PJ1201  JUMPER  [J_0202]  133.37 158.74 90 top
PJ1206  -  [JUMP_43X79_7]  129.89 138.98 90 bottom
PJ1207  -  [JUMP_43X39]  125.65 155.27 180 bottom
PJ1252  -  [JUMP_43X79_7]  237.97 79.67 90 top
PJ1253  -  [JUMP_43X79_7]  203.25 159.52 0 top
PJ1255  -  [JUMP_43X79_7]  129.42 126.7 180 top
PJ1501  -  [JUMP_43X118]  157.7 196.46 270 top
PJ1502  -  [JUMP_43X118]  152.33 189.44 0 top
PJ1503  -  [JUMP_43X118]  152.33 193.5 0 top
PJ1504  -  [JUMP_43X118]  278.82 93.04 0 top
PJ1505  -  [JUMP_43X39]  118.15 137.62 180 bottom
PJ1506  -  [JUMP_43X79_7]  211.59 123.9 180 bottom
PJ1507  -  [JUMP_43X79_7]  218.66 128.69 90 bottom
PJ1508  -  [JUMP_43X79_7]  44.04 72.77 270 bottom
PJ1509  -  [JUMP_43X79_7]  285.75 18.96 270 top
PL101  -  [TAI-T_C8BBPH403025-1TAPING_2P]  85.31 23.9 270 bottom
PL102  -  [TAI-T_C8BBPH403025-1TAPING_2P]  88.87 23.9 270 bottom
PL103  -  [TAI-T_C8BBPH403025-1TAPING_2P]  24.53 25.71 90 top
PL104  -  [TAI-T_C8BBPH403025-1TAPING_2P]  27.96 25.71 90 top
PL201  -  [L11_15X10-3_8H]  108.05 13.03 90 top
PL301  -  [CYNTE_PCMC065T-2R2MN_2P]  57.98 16.08 180 top
PL302  -  [CYNTE_PCMC065T-2R2MN_2P]  33.94 10.52 180 top
PL401  -  [CYNTE_PCMC065T-2R2MN_2P]  116.88 82.88 0 bottom
PL410  -  [CYNTE_PCMB053T-1R0MS_2P]  212.82 111.29 270 top
PL501  -  [CYNTE_PCMB053T-1R0MS_2P]  261.97 52.19 90 top
PL602  -  [CYNTE_PCMB053T-1R0MS_2P]  268.36 55.58 0 top
PL603  -  [CYNTE_PCMB053T-1R0MS_2P]  274.87 15.14 0 top
PL701  -  [CYNTE_PCMC065T-2R2MN_2P]  288.29 103.84 180 bottom
PL702  -  [CYNTE_PCMB053T-1R0MS_2P]  215.02 163.06 270 bottom
PL711  -  [CYNTE_PCMC065T-2R2MN_2P]  287.35 93.42 180 bottom
PL901  -  [L11_15X10-3_8H]  254.39 188.72 270 bottom
PL902  -  [L11_15X10-3_8H]  266.58 188.72 270 bottom
PL1001  -  [L11_15X10-3_8H]  217.82 188.72 270 bottom
PL1201  -  [CYNTE_PCMB053T-1R0MS_2P]  131.36 148.35 270 bottom
PL1202  -  [MURAT_BLM15PX121SN1D_2P]  188.56 130.72 90 top
PL1203  -  [MURAT_BLM15PX121SN1D_2P]  189.83 130.72 90 top
PL1301  -  [MURAT_BLM15PX121SN1D_2P]  184.25 195.57 0 bottom
PL1501  -  [TOKO_FDUE0640J-H_4P]  156.11 183.81 270 bottom
PL1502  -  [TOKO_FDUE0640J-H_4P]  169.34 182.53 270 bottom
PL1601  -  [TOKO_FDUE0640J-H_4P]  193.47 182.53 270 bottom
PL1602  -  [TOKO_FDUE0640J-H_4P]  181.4 182.53 270 bottom
PL1603  -  [TOKO_FDUE0640J-H_4P]  204.39 182.53 270 bottom
PL1807  -  [CYNTE_PCMB053T-1R0MS_2P]  124.21 128 270 bottom
PL1808  -  [CYNTE_PCMC065T-2R2MN_2P]  234.64 98.18 90 bottom
PL1809  -  [CYNTE_PCMC065T-2R2MN_2P]  222.73 98.11 90 bottom
PL1810  -  [L11_15X10-3_8H]  242.2 188.72 270 bottom
PL1811  -  [L11_15X10-3_8H]  230.01 188.72 270 bottom
PL2001  -  [MAGLA_SPS-04AEN2R2M-M1_2P]  45.69 97.11 180 bottom
PQ101  -  [2N7002KDWH_SOT363-6]  80.32 94.07 270 top
PQ201  -  [FDMS7678_POWER56-8-5]  35.91 28.02 90 top
PQ202  -  [FDMS7678_POWER56-8-5]  40.48 32.46 270 top
PQ203  -  [FDMS7678_POWER56-8-5]  101.57 15.57 90 top
PQ204  -  [AOE6930_DFN8-10]  99.16 11.66 270 top
PQ205  -  [FDMS7678_POWER56-8-5]  35.91 33.48 90 top
PQ206  -  [2N7002KW_SOT323-3]  273.81 40.81 180 top
PQ207  -  [2N7002KW_SOT323-3]  267.97 20.15 0 top
PQ301  -  [AOE6930_DFN8-10]  53.09 23.11 180 top
PQ302  -  [AOE6930_DFN8-10]  35.91 17.61 180 top
PQ401  -  [AOE6930_DFN8-10]  111.35 83.39 90 bottom
PQ701  -  [AOE6930_DFN8-10]  293.72 103.33 270 bottom
PQ702  -  [AOE6930_DFN8-10]  293.72 95.5 270 bottom
PQ904  -  [AON7405_DFN8-5]  271.14 50.03 90 top
PQ905  -  [AON7405_DFN8-5]  272.25 16.41 180 top
PQ1401  -  [AO5804EL_SC89-6]  108.69 67.38 270 top
PQ1402  -  [AO5804EL_SC89-6]  55.33 8.98 90 top
PQ1403  -  [AO5804EL_SC89-6]  111.47 69.79 180 top
PQ1404  -  [AO5804EL_SC89-6]  118.7 67.4 90 top
PQ1405  -  [AO5804EL_SC89-6]  208.39 193.38 90 bottom
PQ1409  -  [AO5804EL_SC89-6]  306.79 107.79 180 bottom
PQ1411  -  [AOE6930_DFN8-10]  234.03 92.79 180 bottom
PQ1412  -  [AOE6930_DFN8-10]  221.86 92.71 180 bottom
PR22  -  [R_0402NEW]  307.68 196.95 90 bottom
PR23  -  [R_0402NEW]  303.11 194.28 90 bottom
PR24  -  [R_0402NEW]  299.52 203.65 0 bottom
PR25  -  [R_0402NEW]  299.12 195.76 180 bottom
PR26  -  [R_0402NEW]  296.94 198.8 0 bottom
PR27  -  [R_0402NEW]  299.12 196.64 180 bottom
PR28  -  [R_0402NEW]  305.4 195.2 270 bottom
PR29  -  [R_0402NEW]  296.94 199.69 0 bottom
PR30  -  [R_0402NEW]  299.12 197.53 180 bottom
PR31  -  [R_0402NEW]  302.02 194.14 180 bottom
PR32  -  [R_0402NEW]  302.02 195.03 180 bottom
PR34  -  [R_0402NEW]  304.51 195.2 270 bottom
PR35  -  [R_0402NEW]  299.12 194.87 180 bottom
PR36  -  [R_0402NEW]  299.52 202.77 0 bottom
PR38  -  [R_0402NEW]  209.72 119.46 180 bottom
PR39  -  [R_0603NEW]  274.29 76.47 270 top
PR101  -  [R_0402NEW]  95.02 16.59 0 bottom
PR102  -  [R_0402NEW]  94.96 14.76 270 bottom
PR103  -  [R_0402NEW]  95.14 11.97 270 bottom
PR104  -  [R_0402NEW]  96.03 11.05 90 bottom
PR105  -  [R_0603NEW]  83.92 93.36 90 top
PR106  -  [R_0402NEW]  79.09 94.64 270 top
PR107  -  [R_0402NEW]  81.17 95.2 0 top
PR108  -  [R_0402NEW]  79.17 92.79 180 top
PR116  -  [R_0805NEW]  30.83 26.58 270 top
PR201  -  [R_1632NEW]  48.48 32.21 90 top
PR202  3.65K_0603_1%  [R_0603]  83.28 14.75 270 top
PR203  -  [R_0402NEW]  77.57 12.47 270 top
PR204  3.65K_0603_1%  [R_0603]  84.55 14.75 270 top
PR205  -  [R_0603NEW]  88.17 14.56 180 top
PR206  -  [R_0402NEW]  78.45 11.56 90 top
PR207  -  [R_1632NEW]  108.17 22.05 180 top
PR208  -  [R_0402]  83.71 3.25 0 top
PR209  -  [R_0603NEW]  90.33 11.38 180 top
PR210  -  [R_0603NEW]  88.93 12.65 0 top
PR211  -  [R_0603NEW]  88.14 5.22 270 top
PR212  3.65K_0603_1%  [R_0603]  86.87 5.22 270 top
PR213  -  [R_0402NEW]  80.41 8.72 0 top
PR214  -  [R_0603NEW]  90.9 7.89 90 top
PR215  -  [R_0402NEW]  80.41 7.83 0 top
PR216  -  [R_0402NEW]  80.41 6.81 0 top
PR217  -  [R_0402NEW]  91.15 4.32 90 top
PR218  -  [R_0805NEW]  92.34 4.78 0 top
PR219  -  [R_0402NEW]  80.28 5.92 0 top
PR220  -  [R_0402NEW]  84.8 4.7 90 top
PR221  -  [R_0402NEW]  81.17 4.91 0 top
PR222  -  [R_0402NEW]  83.86 4.91 180 top
PR223  -  [R_0402NEW]  90.14 5.24 270 top
PR224  -  [R_0402NEW]  82.95 5.92 0 top
PR225  -  [R_0402NEW]  88.54 6.18 0 top
PR226  -  [R_0402NEW]  79.55 6.81 180 top
PR227  -  [R_0402NEW]  80.41 10.62 0 top
PR228  -  [R_0402NEW]  80.41 9.73 0 top
PR229  -  [R_0402NEW]  78.63 9.73 0 top
PR230  -  [R_0402]  275.94 50.93 90 top
PR231  -  [R_0402NEW]  100.73 20.65 0 top
PR232  -  [R_0603NEW]  80.82 16.15 90 top
PR233  3.65K_0603_1%  [R_0603]  79.55 16.15 90 top
PR234  -  [R_0402]  272.49 51.07 90 top
PR235  -  [R_0402NEW]  40.61 26.42 90 top
PR236  -  [R_0402NEW]  39.67 26.5 180 top
PR237  -  [R_0603NEW]  39.02 38.18 180 top
PR301  -  [R_0402NEW]  46.32 8.89 90 top
PR302  -  [R_0402NEW]  41.88 8.77 90 top
PR303  -  [R_0402NEW]  47.21 8.89 90 top
PR304  -  [R_0603NEW]  45.18 10.3 270 top
PR305  -  [R_0402NEW]  42.77 9.68 270 top
PR306  -  [R_0402NEW]  48.1 9.81 270 top
PR307  -  [R_0402NEW]  40.99 9.68 270 top
PR308  -  [R_0603NEW]  41.33 14.68 180 top
PR309  -  [R_0603NEW]  49.31 15.07 180 top
PR310  -  [R_1206NEW]  52.48 11.51 0 top
PR311  -  [R_1206NEW]  34.45 6.05 0 top
PR312  -  [R_0603NEW]  43.09 19.26 0 top
PR313  -  [R_0402NEW]  48.81 10.87 180 top
PR314  -  [R_0402NEW]  47.9 11.76 0 top
PR315  -  [R_0603NEW]  44.45 21.91 270 top
PR316  -  [R_1206NEW]  204.31 167.21 270 bottom
PR317  -  [R_1206NEW]  200.12 158.77 90 top
PR355  -  [R_0402NEW]  48.36 11.2 270 bottom
PR401  3.65K_0603_1%  [R_0603]  114.4 87.77 270 top
PR402  -  [R_0402]  107.84 87.2 0 bottom
PR403  -  [R_0805NEW]  117.19 87.49 90 bottom
PR404  -  [R_0402]  110.43 86.77 270 top
PR405  3.65K_0603_1%  [R_0603]  108.53 85.23 90 top
PR406  -  [R_0402]  107.06 86.19 180 top
PR407  -  [R_0402]  107.11 87.07 180 top
PR408  -  [R_0402]  105.76 91.72 270 top
PR409  -  [R_0402]  102.33 85.25 270 top
PR410  -  [R_0402]  103.91 90.88 0 top
PR411  -  [R_0402]  107.11 87.96 180 top
PR412  -  [R_0402]  106.19 88.85 0 top
PR413  -  [R_0402NEW]  107.54 90.81 90 top
PR414  -  [R_0402NEW]  304.97 105.79 90 bottom
PR415  -  [R_0402]  308.25 97.49 0 bottom
PR416  -  [R_0402NEW]  304.77 107.57 90 bottom
PR417  -  [R_0805NEW]  273.62 57.48 0 bottom
PR418  -  [R_0805NEW]  211.68 111.08 0 bottom
PR423  -  [R_0402NEW]  208.83 113.82 0 top
PR425  -  [R_0402NEW]  209.75 111.18 180 top
PR426  -  [R_0402NEW]  104.36 84.33 90 top
PR427  -  [R_0402NEW]  208.83 115.6 0 top
PR428  -  [R_0603NEW]  211.7 116.25 270 bottom
PR429  -  [R_0402NEW]  208.91 112.3 90 bottom
PR430  -  [R_0402NEW]  105.25 84.33 90 top
PR431  -  [R_0402NEW]  209.75 114.71 180 top
PR433  -  [R_0402]  103.35 84.33 90 top
PR438  -  [R_0402]  209.8 113.21 270 bottom
PR439  -  [R_0402]  208.83 115.04 0 bottom
PR440  -  [R_0402]  105.96 93.17 180 top
PR441  -  [R_0402]  104.82 91.77 180 top
PR451  -  [R_0402NEW]  209.75 112.93 180 top
PR501  -  [R_0402NEW]  263.49 48.52 90 bottom
PR502  -  [R_0603NEW]  266.41 48.4 90 top
PR503  -  [R_0402NEW]  261.64 48.47 0 bottom
PR504  -  [R_0805NEW]  265.65 52.31 90 top
PR505  -  [R_0402NEW]  265.96 52.51 180 bottom
PR506  -  [R_0402NEW]  266.59 49.89 270 bottom
PR507  -  [R_0402NEW]  265.04 51.62 0 bottom
PR508  -  [R_0402]  265.68 49.89 270 bottom
PR509  -  [R_0402NEW]  265.27 49.69 270 top
PR511  -  [R_0402]  266.62 47.2 180 bottom
PR605  -  [R_0402NEW]  79.04 56.77 0 top
PR608  3.65K_0603_1%  [R_0603]  270.8 60.96 180 bottom
PR609  -  [R_0402]  272.69 66.5 0 top
PR610  -  [R_0402NEW]  276.61 40.46 270 top
PR611  -  [R_0402NEW]  274.54 65.54 90 top
PR612  -  [R_0402]  273.6 65.48 180 top
PR621  3.65K_0603_1%  [R_0603]  78.26 55.45 180 top
PR622  3.65K_0603_1%  [R_0603]  79.33 57.81 180 top
PR623  -  [R_0402NEW]  76.09 44.28 0 top
PR624  -  [R_0402]  79.72 46.74 90 top
PR626  -  [R_0603NEW]  72.42 44.02 0 top
PR647  -  [R_0402NEW]  78.71 47.65 270 top
PR648  -  [R_0402NEW]  77.95 45.24 270 top
PR649  -  [R_0402NEW]  80.74 46.74 90 top
PR701  -  [R_1632NEW_4P]  170.78 201.88 180 top
PR703  -  [R_0402NEW]  301.21 92.97 90 bottom
PR704  -  [R_0402NEW]  302.1 93.88 270 bottom
PR712  -  [R_0402NEW]  308.65 109.3 180 bottom
PR714  -  [R_0603NEW]  215.35 167.73 270 top
PR715  -  [R_0402NEW]  218.21 162.51 0 top
PR716  -  [R_0805NEW]  211.55 162.98 270 bottom
PR717  -  [R_0402NEW]  219.17 164.21 90 bottom
PR718  -  [R_0402NEW]  218.21 163.4 0 top
PR719  -  [R_0402]  218.28 165.13 270 bottom
PR720  -  [R_0402NEW]  219.12 166.07 180 top
PR721  -  [R_0402NEW]  218.21 166.96 0 bottom
PR722  -  [R_0402NEW]  219.12 165.18 180 top
PR723  -  [R_0402NEW]  219.12 167.85 180 top
PR724  -  [R_0402NEW]  218.21 166.96 0 top
PR801  -  [R_0402NEW]  299.99 183.72 0 bottom
PR803  -  [R_0402NEW]  299.99 182.83 0 bottom
PR804  -  [R_0402NEW]  297.28 184.43 270 bottom
PR818  -  [R_0402NEW]  294.48 188.6 90 top
PR820  -  [R_0402NEW]  299.89 185.37 180 top
PR901  -  [R_1632NEW_4P]  203.42 203.79 180 top
PR902  -  [R_0603NEW]  257.4 203.98 270 bottom
PR903  -  [R_0603NEW]  260.29 196.36 90 bottom
PR904  -  [R_0603NEW]  260.45 194.2 270 bottom
PR905  -  [R_0805NEW]  250.98 195.53 180 bottom
PR906  -  [R_0402]  259.3 201.58 270 bottom
PR907  -  [R_0402NEW]  284.78 181.05 180 top
PR908  -  [R_0402NEW]  259.23 198.83 0 bottom
PR909  -  [R_0402NEW]  259.23 199.72 0 bottom
PR910  -  [R_0402]  258.54 203.74 270 bottom
PR911  -  [R_0603NEW]  272.64 195.6 90 bottom
PR912  -  [R_0805NEW]  263.18 195.66 180 bottom
PR914  -  [R_0402NEW]  284.78 178.51 180 top
PR915  -  [R_0402]  270.61 203.74 270 bottom
PR918  -  [R_0603NEW]  272.64 194.58 270 bottom
PR919  -  [R_0603NEW]  269.46 203.98 270 bottom
PR920  -  [R_0402NEW]  271.55 199.34 0 bottom
PR922  -  [R_0402]  272.46 200.23 180 bottom
PR992  -  [R_0402NEW]  271.55 198.45 0 bottom
PR1001  -  [R_0603NEW]  220.82 203.98 270 bottom
PR1002  -  [R_0603NEW]  223.69 196.49 90 bottom
PR1004  -  [R_0805NEW]  214.36 195.91 180 bottom
PR1005  -  [R_0402NEW]  222.65 198.83 0 bottom
PR1006  -  [R_0402NEW]  284.65 188.93 180 top
PR1007  -  [R_0402]  222.6 201.58 270 bottom
PR1008  -  [R_0603NEW]  233.01 203.98 270 bottom
PR1009  -  [R_0402NEW]  222.65 199.72 0 bottom
PR1011  -  [R_0805NEW]  226.6 195.66 180 bottom
PR1013  -  [R_0402NEW]  284.78 186.26 180 top
PR1014  -  [R_0402NEW]  235.1 199.6 0 bottom
PR1020  -  [R_0402]  221.96 203.74 270 bottom
PR1021  -  [R_0603NEW]  235.86 196.36 90 bottom
PR1022  -  [R_0603NEW]  236.06 194.07 270 bottom
PR1023  -  [R_0402]  234.16 203.74 270 bottom
PR1024  -  [R_0402]  234.92 201.45 270 bottom
PR1025  -  [R_0402NEW]  235.1 198.71 0 bottom
PR1053  -  [R_0603NEW]  223.87 194.07 270 bottom
PR1121  -  [R_0402]  115.08 197.41 0 top
PR1145  -  [R_0603NEW]  124.56 200.55 90 top
PR1146  -  [R_0402NEW]  124.56 200.05 270 bottom
PR1147  -  [R_0603NEW]  123.29 200.55 90 top
PR1148  -  [R_0402NEW]  123.67 199.14 90 bottom
PR1149  -  [R_0603NEW]  132.05 201.31 270 bottom
PR1151  -  [R_0603NEW]  129.89 201.31 270 bottom
PR1152  -  [R_0402]  119.65 196.29 0 top
PR1154  -  [R_0603NEW]  128.81 184.23 0 bottom
PR1155  -  [R_0402NEW]  125.62 196.42 0 bottom
PR1157  -  [R_0402]  122.22 198.35 180 top
PR1158  -  [R_0402NEW]  125.62 197.31 0 bottom
PR1159  -  [R_0402]  124.81 186.08 180 top
PR1161  -  [R_0402NEW]  125.62 198.2 0 bottom
PR1162  -  [R_0402]  121.3 199.55 270 bottom
PR1163  -  [R_0402]  169.26 162.59 270 bottom
PR1164  -  [R_0402]  170.28 162.59 270 bottom
PR1165  -  [R_0402]  115.08 196.52 0 top
PR1166  -  [R_0402]  118.64 196.52 90 top
PR1169  -  [R_0402]  121.86 182.43 90 top
PR1172  -  [R_0402]  182.59 161.5 180 bottom
PR1173  -  [R_0402]  183.05 162.51 180 bottom
PR1175  -  [R_0402]  122.75 182.43 90 top
PR1176  -  [R_0402NEW]  128.8 184.23 0 top
PR1177  -  [R_0402]  121.91 186.06 0 top
PR1179  -  [R_0402NEW]  128.67 192.87 0 bottom
PR1180  -  [R_0402]  130.52 193.04 90 bottom
PR1181  -  [R_0402NEW]  119.76 188.32 270 bottom
PR1182  -  [R_0402]  120.64 187.4 90 bottom
PR1183  -  [R_0402NEW]  129.89 198.66 270 bottom
PR1184  -  [R_0402NEW]  132.05 198.66 270 bottom
PR1185  -  [R_0402NEW]  133.39 194.9 90 top
PR1186  -  [R_0402]  129.71 186.64 180 bottom
PR1187  -  [R_0402]  119.7 188.29 0 top
PR1188  -  [R_0402]  119.7 190.91 0 top
PR1189  -  [R_0402NEW]  132.63 188.42 180 top
PR1190  -  [R_0402]  131.72 187.53 0 top
PR1191  -  [R_0402]  133.57 193.58 180 top
PR1192  -  [R_0402NEW]  131.72 189.31 0 top
PR1193  -  [R_0402]  130.09 190.58 180 bottom
PR1194  -  [R_0402]  123.69 184.31 90 bottom
PR1195  -  [R_0402NEW]  123.92 184.31 90 top
PR1196  -  [R_0402NEW]  119.7 190.05 0 top
PR1197  -  [R_0402]  119.73 185.02 0 top
PR1198  -  [R_0402NEW]  126.71 185.12 90 top
PR1199  -  [R_0402NEW]  125.83 186.06 270 top
PR1200  -  [R_0603NEW]  119.13 190.27 0 bottom
PR1201  -  [R_0402]  135.43 156.82 90 bottom
PR1202  -  [R_0402]  136.9 154.99 180 bottom
PR1205  -  [R_0402NEW]  129.71 185.12 180 top
PR1206  -  [R_0402NEW]  125.62 195.53 0 bottom
PR1208  -  [R_0402NEW]  123.64 198.43 90 top
PR1209  -  [R_0402]  124.56 194.95 90 bottom
PR1210  -  [R_0402]  124.81 189.03 270 bottom
PR1211  -  [R_0402NEW]  126.71 186.06 180 bottom
PR1212  -  [R_0402NEW]  131.54 184.41 90 top
PR1220  -  [R_0402]  134.39 151.51 270 top
PR1221  -  [R_0402]  136.62 150.55 180 top
PR1222  3.65K_0603_1%  [R_0603]  128.19 148.1 90 bottom
PR1224  -  [R_0402]  133.65 156.82 90 bottom
PR1225  3.65K_0603_1%  [R_0603]  134.51 149.72 270 bottom
PR1226  -  [R_0402]  131.67 157.66 0 bottom
PR1227  -  [R_0402]  136.32 157.74 270 bottom
PR1229  -  [R_0402]  136.9 155.88 180 bottom
PR1231  -  [R_0402NEW]  136.04 153.14 90 bottom
PR1232  -  [R_0402NEW]  137.92 154.11 180 bottom
PR1233  -  [R_0402NEW]  116.73 186.64 0 top
PR1234  -  [R_0402NEW]  118.03 192.74 180 top
PR1235  -  [R_0402NEW]  117.11 193.63 0 top
PR1237  -  [R_0402NEW]  120.57 194.52 180 top
PR1238  -  [R_0402NEW]  119.65 192.74 0 top
PR1239  -  [R_0402]  120.57 193.63 180 top
PR1240  -  [R_0402NEW]  117.11 192.23 0 bottom
PR1241  -  [R_0402NEW]  119.65 191.85 0 top
PR1242  -  [R_0402NEW]  120.57 195.41 180 bottom
PR1243  -  [R_0402NEW]  121.33 200.13 270 top
PR1251  -  [R_0402NEW]  204.74 152.61 0 top
PR1253  -  [R_0402NEW]  206.5 153.5 270 top
PR1257  -  [R_0603NEW]  187.29 130.83 90 top
PR1258  -  [R_0402NEW]  190.72 128.78 0 top
PR1302  -  [R_0402NEW]  59.86 44.4 180 bottom
PR1304  -  [R_0603NEW]  153.34 199.68 0 bottom
PR1305  -  [R_0402NEW]  148.5 197.88 270 bottom
PR1306  -  [R_0402NEW]  21.99 19.38 0 top
PR1309  -  [R_0603NEW]  177.2 195.15 180 bottom
PR1310  -  [R_0402NEW]  185.11 196.6 180 bottom
PR1311  -  [R_0402NEW]  194.1 194.14 180 bottom
PR1312  -  [R_0402NEW]  175.79 197.56 0 bottom
PR1313  -  [R_0402NEW]  185.98 196.6 90 bottom
PR1314  -  [R_0402NEW]  177.57 197.56 0 bottom
PR1315  -  [R_0402NEW]  184.2 197.49 0 bottom
PR1317  -  [R_0402NEW]  203.68 151.26 90 top
PR1318  -  [R_0603NEW]  200.69 155.78 180 top
PR1321  -  [R_0603NEW]  199.3 157.18 0 top
PR1401  -  [R_0402NEW]  111.22 67.47 270 top
PR1403  -  [R_0402NEW]  53.13 8.72 180 top
PR1404  -  [R_0402NEW]  112.8 69.93 0 top
PR1405  -  [R_0402NEW]  107.41 65.92 90 top
PR1406  -  [R_0402NEW]  117.7 66.2 270 top
PR1407  -  [R_0402NEW]  118.97 69.47 90 top
PR1408  -  [R_0402NEW]  118.71 65.28 90 top
PR1409  -  [R_0402NEW]  210.53 193.2 270 bottom
PR1410  -  [R_0402NEW]  206.52 193.78 0 bottom
PR1411  -  [R_0402NEW]  207.44 194.67 180 bottom
PR1412  -  [R_0402NEW]  108.68 64.8 270 top
PR1413  -  [R_0603NEW]  112.43 67.01 0 top
PR1414  -  [R_0402NEW]  56.53 9.48 0 top
PR1415  -  [R_0402NEW]  52.22 9.6 0 top
PR1416  -  [R_0402]  290.06 190.25 90 top
PR1417  -  [R_0402]  289.17 190.25 90 top
PR1418  -  [R_0402]  288.28 190.25 90 top
PR1419  -  [R_0402]  287.4 190.25 90 top
PR1420  -  [R_0402]  290.21 186.9 0 bottom
PR1433  -  [R_0402]  286.56 187.66 180 top
PR1436  -  [R_0402]  286.56 184.99 180 top
PR1439  -  [R_0402]  286.56 182.32 180 top
PR1442  -  [R_0402]  286.56 179.66 180 top
PR1445  -  [R_0402]  286.56 176.99 180 top
PR1446  -  [R_0402]  291 178.01 180 top
PR1447  -  [R_0402]  290.93 179.86 270 top
PR1449  -  [R_0402]  289.22 178.01 180 top
PR1450  -  [R_0402]  283.86 179.53 0 top
PR1451  -  [R_0402]  283.86 181.94 0 top
PR1452  -  [R_0402]  283.86 184.99 0 top
PR1453  -  [R_0402]  283.86 187.66 0 top
PR1457  -  [R_0402]  283.86 176.99 0 top
PR1458  -  [R_0402]  292.7 179.86 270 top
PR1459  -  [R_0402]  292.7 179.23 270 bottom
PR1460  -  [R_0402]  293.59 179.73 270 top
PR1461  -  [R_0402NEW]  294.48 178.82 90 top
PR1462  -  [R_0402]  295.37 178.82 90 top
PR1463  -  [R_0402]  296.34 177.88 180 top
PR1467  -  [R_0402]  297.35 186.39 180 top
PR1469  -  [R_0402]  300.91 183.72 180 top
PR1470  -  [R_0402]  300.91 182.83 180 top
PR1471  -  [R_0603NEW]  296.96 183.98 0 top
PR1472  -  [R_0402]  297.45 181.97 0 top
PR1473  -  [R_0402]  297.45 181.11 0 top
PR1501  3.65K_0603_1%  [R_0603]  164.51 191.08 90 bottom
PR1502  -  [R_0603NEW]  164.69 182.64 90 top
PR1503  -  [R_0603NEW]  163.16 182.26 270 bottom
PR1504  -  [R_0402]  151.91 179.23 270 bottom
PR1505  -  [R_0402]  151.91 176.53 90 bottom
PR1506  -  [R_0402]  166.47 192.05 270 bottom
PR1507  -  [R_0805NEW]  152.68 183.98 90 bottom
PR1508  3.65K_0603_1%  [R_0603]  175.33 191.15 90 bottom
PR1509  -  [R_0603NEW]  176.88 183.4 90 top
PR1510  -  [R_0603NEW]  174.28 182.07 0 bottom
PR1511  -  [R_0402]  165.07 176.53 90 bottom
PR1512  -  [R_0402]  177.26 192.05 270 bottom
PR1513  -  [R_0402]  165.07 179.23 270 bottom
PR1514  -  [R_0805NEW]  166.17 182.83 180 bottom
PR1595  -  [R_0402NEW]  176.12 187.71 90 top
PR1596  -  [R_0402]  176.37 192.05 270 bottom
PR1597  -  [R_0402NEW]  166.57 188.83 90 top
PR1598  -  [R_0402]  165.58 192.05 270 bottom
PR1599  -  [R_0402NEW]  166.47 189.23 90 bottom
PR1601  3.65K_0603_1%  [R_0603]  197.71 190.52 90 bottom
PR1602  -  [R_0603NEW]  198.98 183.91 90 bottom
PR1603  -  [R_0603NEW]  197.01 182.71 0 bottom
PR1604  -  [R_0402]  189.2 179.23 270 bottom
PR1605  -  [R_0402]  189.2 176.53 90 bottom
PR1606  -  [R_0402]  199.69 188.93 180 bottom
PR1607  -  [R_0805NEW]  190.11 182.57 90 bottom
PR1608  3.65K_0603_1%  [R_0603]  186.15 191.15 90 bottom
PR1609  -  [R_0603NEW]  187.88 183.66 90 top
PR1610  -  [R_0603NEW]  186.21 182.71 0 bottom
PR1611  -  [R_0402]  188.08 192.05 270 bottom
PR1612  -  [R_0402]  177.13 179.23 270 bottom
PR1613  -  [R_0402]  177.13 176.53 90 bottom
PR1614  -  [R_0805NEW]  178.02 182.62 90 bottom
PR1615  3.65K_0603_1%  [R_0603]  208.63 190.52 90 bottom
PR1616  -  [R_0603NEW]  209.9 183.91 90 bottom
PR1617  -  [R_0603NEW]  207.93 182.71 0 bottom
PR1618  -  [R_0402]  200.12 179.23 270 bottom
PR1619  -  [R_0402]  200.12 176.53 90 bottom
PR1620  -  [R_0402]  210.61 188.93 180 bottom
PR1621  -  [R_0805NEW]  201.01 182.87 90 bottom
PR1622  -  [R_0402NEW]  177.13 188.73 90 bottom
PR1623  -  [R_0402NEW]  198.77 187.15 0 bottom
PR1624  -  [R_0402NEW]  198.77 188.04 0 bottom
PR1625  -  [R_0402]  199.69 189.82 180 bottom
PR1628  -  [R_0402]  187.19 192.05 270 bottom
PR1629  -  [R_0402NEW]  188.06 188.85 90 bottom
PR1630  -  [R_0402]  210.61 189.82 180 bottom
PR1631  -  [R_0402NEW]  187.04 188.09 90 top
PR1632  -  [R_0402NEW]  209.7 187.15 0 bottom
PR1633  -  [R_0402NEW]  209.7 188.04 0 bottom
PR2187  -  [R_0402NEW]  208.5 125.5 270 top
PR2261  -  [R_0402NEW]  277.01 191.47 0 bottom
PR3401  3.65K_0603_1%  [R_0603]  303.56 95.58 180 top
PR3404  3.65K_0603_1%  [R_0603]  300.32 100.09 90 bottom
PR3405  -  [R_0805]  289.31 106.38 0 top
PR3408  -  [R_0402]  304.13 103.66 270 bottom
PR3409  3.65K_0603_1%  [R_0603]  300.07 94.5 270 bottom
PR3410  -  [R_0805]  288.55 92.28 0 top
PR3411  -  [R_0402]  307.31 97.56 270 bottom
PR3412  -  [R_0402]  305.02 95.71 270 bottom
PR3413  -  [R_0402]  305.99 99.9 180 bottom
PR3414  -  [R_0402]  306.98 95.71 0 bottom
PR3415  -  [R_0402]  308.25 96.6 0 bottom
PR3416  -  [R_0402]  305.91 96.6 180 bottom
PR3417  -  [R_0402NEW]  307.44 93.48 270 bottom
PR3418  -  [R_0402]  302.99 93.48 270 bottom
PR3419  -  [R_0402]  303.88 93.48 270 bottom
PR3420  -  [R_0402]  308.38 93.68 0 bottom
PR3421  -  [R_0402]  306.98 94.82 0 bottom
PR3422  -  [R_0402]  310.23 93.75 270 bottom
PR3423  -  [R_0402NEW]  303.32 100.33 90 bottom
PR3424  -  [R_0402NEW]  303.12 103.66 270 bottom
PR3426  -  [R_0402NEW]  216.25 102.62 90 bottom
PR3428  -  [R_0402NEW]  212.44 94.24 90 bottom
PR3431  -  [R_0402]  209.34 98.12 180 bottom
PR3432  -  [R_0402]  208.38 96.93 270 bottom
PR3433  -  [R_0402]  210.71 96.35 0 bottom
PR3434  3.65K_0603_1%  [R_0603]  216.25 95.65 270 bottom
PR3435  -  [R_0402]  210.74 104.4 180 bottom
PR3436  -  [R_0402]  209.77 100.71 90 bottom
PR3437  -  [R_0402]  209.77 103.41 270 bottom
PR3438  -  [R_0402]  211.63 102.57 180 bottom
PR3439  -  [R_0402NEW]  210.41 94.24 90 bottom
PR3440  -  [R_0402]  210.71 99.52 0 bottom
PR3441  -  [R_0402NEW]  212.52 104.4 180 bottom
PR3442  3.65K_0603_1%  [R_0603]  218.73 97.36 180 bottom
PR3443  -  [R_0805]  225.44 94.97 0 bottom
PR3444  -  [R_0402]  213.58 102.62 90 bottom
PR3445  3.65K_0603_1%  [R_0603]  217.33 102.01 0 bottom
PR3446  -  [R_0402]  214.47 102.62 90 bottom
PR3447  -  [R_0805]  237.75 95.84 0 bottom
PR3448  -  [R_0402]  211.55 100.71 90 bottom
PR3449  -  [R_0402NEW]  215.36 103.53 270 bottom
PR3454  -  [R_0402NEW]  213.33 94.24 90 bottom
PR3456  -  [R_0402NEW]  213.89 92.15 0 bottom
PR3457  -  [R_0402]  126.12 134.67 180 bottom
PR3458  -  [R_0402]  125.21 132.89 0 bottom
PR3459  -  [R_0402NEW]  127 132.79 90 bottom
PR3460  -  [R_0805NEW]  119.16 128.81 270 bottom
PR3461  -  [R_0402NEW]  125.21 132 0 bottom
PR3462  -  [R_0603NEW]  122.97 135.39 270 top
PR3463  -  [R_0402NEW]  126.12 131.11 180 bottom
PR3464  -  [R_0402NEW]  126.12 130.22 180 bottom
PR3465  -  [R_0402NEW]  123.03 130.25 0 bottom
PR3466  -  [R_0402]  299.13 187.02 180 top
PR3467  -  [R_0402]  296.31 188.55 0 top
PR3468  -  [R_0402]  300.07 187.84 90 top
PR3470  -  [R_0402]  292.73 190.25 90 top
PR3471  -  [R_0402]  291.84 190.25 90 top
PR3472  -  [R_0402]  290.95 190.25 90 top
PR3525  -  [R_0402]  301.67 185.37 180 top
PR3526  -  [R_0402]  288.64 183.26 90 bottom
PR3528  -  [R_0402]  298.11 185.37 180 top
PR3529  -  [R_0402]  277.72 180.6 90 bottom
PR3530  -  [R_0402]  277.72 183.29 270 bottom
PR3531  -  [R_0805NEW]  238.79 195.53 180 bottom
PR3532  -  [R_0402NEW]  284.78 183.59 180 top
PR3533  -  [R_0402]  246.98 201.58 270 bottom
PR3534  -  [R_0402]  246.35 203.74 270 bottom
PR3535  -  [R_0402NEW]  247.16 198.83 0 bottom
PR3536  -  [R_0402NEW]  247.16 199.72 0 bottom
PR3537  -  [R_0603NEW]  248.08 196.51 90 bottom
PR3538  -  [R_0603NEW]  245.21 203.98 270 bottom
PR3539  -  [R_0603NEW]  248.38 194.07 270 bottom
PR3540  -  [R_0402]  209.26 96.02 90 bottom
PR3541  -  [R_0402]  208.38 95.15 270 bottom
PR3542  -  [R_0402]  298.22 189.69 0 top
PR3547  -  [R_0402]  298.22 187.91 0 top
PR3549  -  [R_0603NEW]  218.09 122.13 0 top
PR3550  -  [R_0402NEW]  215.11 95.15 270 bottom
PR3551  -  [R_0402NEW]  308.65 108.41 180 bottom
PR3552  -  [R_1632NEW_4P]  230.73 83.9 270 bottom
PR3553  -  [R_0402NEW]  296.94 200.58 0 bottom
PR3554  -  [R_0402NEW]  299.52 204.54 0 bottom
PR3555  -  [R_0402NEW]  308.9 198.8 180 bottom
PR3556  -  [R_0402NEW]  277.84 193.32 270 bottom
PR3558  -  [R_0402NEW]  276.96 193.32 270 bottom
PR3560  -  [R_0402NEW]  281.86 193.63 180 bottom
PR3561  -  [R_0402NEW]  281.86 192.74 180 bottom
PR3562  -  [R_0402]  286.56 188.55 180 top
PR3563  -  [R_0402]  286.56 185.88 180 top
PR3564  -  [R_0402]  286.56 183.21 180 top
PR3565  -  [R_0402]  286.56 180.55 180 top
PR3566  -  [R_0402]  286.56 177.88 180 top
PR3567  -  [R_0402NEW]  302.1 102.75 90 bottom
PR3568  -  [R_0402NEW]  308.9 199.69 180 bottom
PR3569  -  [R_0402NEW]  308.9 200.58 180 bottom
PR3570  -  [R_0402NEW]  213.89 91.27 0 bottom
PR3571  -  [R_0402NEW]  293.64 176.99 0 top
PR3572  -  [R_0402NEW]  305.66 92.59 90 bottom
PR3573  -  [R_0402NEW]  214.42 104.85 180 bottom
PR3574  -  [R_0402]  306.55 92.59 90 bottom
PR3575  -  [R_0402NEW]  304.97 86.06 180 top
PR3576  -  [R_0402]  297.71 87.96 0 top
PR3577  -  [R_0402]  297.71 87.07 0 top
PR3578  -  [R_0402NEW]  297.71 86.19 0 top
PR3579  -  [R_0402]  211.6 105.29 0 bottom
PR3580  -  [R_0402NEW]  214.42 105.74 180 bottom
PR3581  -  [R_0402]  214.73 111.66 270 bottom
PR3582  -  [R_0402]  215.61 111.66 270 bottom
PR3583  -  [R_0402NEW]  216.25 106.43 90 bottom
PR3584  -  [R_0402NEW]  302.99 175.39 90 top
PR3585  -  [R_0402]  296.34 176.99 180 top
PR3586  -  [R_0402]  301.52 171.53 0 top
PR3587  -  [R_0402NEW]  302.99 173.89 270 top
PR3588  -  [R_0402]  300.27 171.78 180 top
PR3589  -  [R_0402NEW]  301.97 99.7 90 top
PR3590  -  [R_0402NEW]  300.32 185.3 90 bottom
PR3591  3.65K_0603_1%  [R_0603]  235.14 88.32 0 bottom
PR3592  3.65K_0603_1%  [R_0603]  222.95 88.32 0 bottom
PR3593  -  [R_0402]  267.26 18.92 0 top
PR3594  -  [R_0402NEW]  265.18 21.67 270 top
PR3595  -  [R_0402]  287.71 13.03 270 top
PR3596  3.65K_0603_1%  [R_0603]  280.92 11.85 270 top
PR3597  -  [R_0402]  287.71 14.81 270 top
PR3598  -  [R_0402]  269.95 18.92 180 top
PR3599  -  [R_0805NEW]  280.03 18.33 90 top
PR3600  -  [R_0402NEW]  285.75 11.25 270 top
PT602  -  [TPC12]  73.37 51.9 90 top
