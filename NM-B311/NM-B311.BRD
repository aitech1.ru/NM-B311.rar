# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP_TX3_OUT_DP: length 111.7
  TOP w0.097: v3(19.27,157.74) 19.2,157.81 18.89,157.81 18.59,157.51 C472.1
  IN05 w0.102: v2(65.12,88.03) 65.18,87.97 65.18,87.72 65.1,87.64 64.18,87.64 62.98,86.44 60.78,86.44 58.77,88.45 58.77,92.15 58.26,92.66 56.86,92.66 56.48,93.04 55.34,93.04 54.32,94.06 51.91,94.06 45.94,100.03 40.51,100.03 20.32,120.22 19.12,120.22 12.75,126.6 12.75,155.61 15.22,158.08 18.74,158.08 18.86,157.95 18.86,157.68 18.99,157.56 19.16,157.56 19.27,157.67 v3(19.27,157.74)
  BOTTOM w0.097: v2(65.12,88.03) 65.39,87.76 66.24,87.76 66.35,87.87 U2015.26
DPA_AUX_DN_C: length 4.1
  BOTTOM w0.097: C460.2 74.97,86.32 74.97,86.95 75.16,87.14 75.16,89.23 75.23,89.29 U2016.6
DPA_AUX_DP_C: length 4.1
  BOTTOM w0.097: U2016.7 74.83,89.29 74.89,89.23 74.89,87.25 74.7,87.06 74.7,86.32 C461.2
DPA_DDC_AUX_SEL: length 9.1
  BOTTOM w0.097: Q6.3 74.56,96.21 R387.1 ; R387.1 73.83,96.04 73.37,95.58 v1(73.37,95.33) 73.37,94.82 74.64,93.55 74.64,92.28 74.22,91.85 74.22,91.44 74.39,91.27 74.39,90.92 U2016.10 ; R387.1 74.72,95.71 Q6.2
DPA_DDC_EN: length 11.4
  BOTTOM w0.097: Q7.5 Q7.2 76.98,98 C599.2 77.11,99.06 77.44,99.39 78.2,99.39 78.58,99.01 78.58,96.09 v1(78.07,95.58) 77.69,95.2 76.67,95.2 ; R386.1 76.68,95.2 76.67,95.2 ; Q6.6 76.67,95.2
DPA_REP_ENI2C: length 2.6
  BOTTOM w0.097: R2144.1 R389.2 67.42,84.5 U2015.21
DPA_REP_EQ0: length 1
  BOTTOM w0.097: U2015.39 67.42,94.86 R394.2
DPA_REP_EQ1: length 1
  BOTTOM w0.097: U2015.40 67.92,95 R397.2
DPA_REP_EQ2: length 1.1
  BOTTOM w0.097: U2015.41 68.42,94.44 68.93,94.95 R398.2
DPA_REP_EQ3: length 1.5
  BOTTOM w0.097: U2015.42 69.28,94.57 69.56,94.57 69.82,94.82 R399.2
DPA_REP_FG0: length 1.5
  BOTTOM w0.097: R392.2 65.23,93.37 U2015.37
DPA_REP_FG1: length 1.5
  BOTTOM w0.097: U2015.38 66.45,93.87 66.26,94.06 R393.2
DPA_REP_I2C_DONE: length 1
  BOTTOM w0.097: TP96.1 65.69,85.87 U2015.22
DPA_REP_SCL: length 2.8
  TOP w0.097: R2242.2 v2(69.44,84.79)
  BOTTOM w0.097: R2242.2 v2(69.44,84.79) 68.93,84.79 68.42,85.3 U2015.19
DPA_REP_SDA: length 3.3
  TOP w0.097: R2243.2 v2(70.45,84.79)
  BOTTOM w0.097: R2243.2 v2(70.45,84.79) 69.95,85.3 69.06,85.3 68.92,85.44 U2015.18
DPA_REP_SW0: length 2.7
  BOTTOM w0.097: U2015.2 70.14,93.37 71.6,94.82 R390.2
DPA_REP_SW1: length 1.9
  BOTTOM w0.097: U2015.1 70.14,93.87 70.71,94.44 R391.2
DPA_TX0_DN_C: length 1.8
  BOTTOM w0.097: C451.2 70.96,92.33 70.76,92.33 70.4,91.98 70.09,91.98 69.98,91.87 U2015.5
DPA_TX0_DP_C: length 1.8
  BOTTOM w0.097: C448.2 70.96,92.61 70.64,92.61 70.29,92.26 70.09,92.26 69.98,92.37 U2015.4
DPA_TX1_DN_C: length 1.7
  BOTTOM w0.097: U2015.8 69.98,90.37 70.09,90.48 70.52,90.48 70.6,90.56 70.96,90.56 C453.2
DPA_TX1_DP_C: length 1.7
  BOTTOM w0.097: U2015.7 69.98,90.87 70.09,90.76 70.41,90.76 70.48,90.83 70.96,90.83 C452.2
DPA_TX2_DN_C: length 1.8
  BOTTOM w0.097: U2015.11 69.98,88.87 70.09,88.98 70.49,88.98 70.7,88.77 70.97,88.77 C455.2
DPA_TX2_DP_C: length 1.8
  BOTTOM w0.097: C454.2 70.95,89.04 70.82,89.04 70.6,89.26 70.09,89.26 69.98,89.37 U2015.10
DPA_TX3_DN_C: length 1.9
  BOTTOM w0.097: U2015.14 70.01,87.37 70.12,87.48 70.25,87.48 70.73,87 70.96,87 C457.2
DPA_TX3_DP_C: length 1.9
  BOTTOM w0.097: U2015.13 70.01,87.87 70.12,87.76 70.36,87.76 70.84,87.28 70.96,87.28 C456.2
DPE_AUX_DN_C: length 2.9
  BOTTOM w0.097: U2013.29 74.53,76.23 74.64,76.34 74.64,76.61 75.46,77.43 75.46,77.67 C530.2
DPE_AUX_DP_C: length 2.9
  BOTTOM w0.097: U2013.30 75.03,76.23 74.92,76.34 74.92,76.5 75.74,77.32 75.74,77.68 C531.2
DPE_CAD_SNK: length 2
  BOTTOM w0.097: U2013.10 73.53,67.87 73.37,67.71 R2104.1
DPE_CAD_SRC: length 1.1
  BOTTOM w0.097: U2013.8 74.53,67.58 TP186.1
DPE_CFG0: length 2.8
  BOTTOM w0.097: U2013.5 76.03,66.72 R541.2 R492.2
DPE_CFG1: length 3.5
  TOP w0.097: R454.2 R422.2 78.28,73.03 v2(77.82,73.49)
  BOTTOM w0.097: U2013.40 77.97,73.34 v2(77.82,73.49)
DPE_HPD_SNK: length 2.1
  BOTTOM w0.097: U2013.11 73.03,67.78 72.49,67.24 R420.1
DPE_PD: length 2.2
  BOTTOM w0.097: U2013.26 73.03,76.12 v1(72.36,76.79) 71.85,76.79 TP97.1
DPE_PEQ: length 3.3
  TOP w0.097: R518.2 v2(76.93,67.52)
  BOTTOM w0.097: U2013.4 76.53,67.92 v2(76.93,67.52) 77.74,66.7 R436.2
DPE_RST_N: length 3.9
  TOP w0.097: v2(77.95,76.53) 77.57,76.91 C2687.2 R2280.1
  BOTTOM w0.097: v1(78.2,77.3) 77.95,77.04 v2(77.95,76.53) 77.82,76.53 77.53,76.24 U2013.35
DPE_TX0_DN_C: length 2.3
  BOTTOM w0.097: U2013.39 79.13,73.84 79.24,73.95 79.63,73.95 79.85,74.17 79.85,74.34 79.97,74.46 80.2,74.46 C479.2
DPE_TX0_DP_C: length 2.3
  BOTTOM w0.097: U2013.38 79.13,74.34 79.24,74.23 79.52,74.23 79.58,74.29 79.58,74.46 79.85,74.73 80.26,74.73 C480.2
DPE_TX1_DN_C: length 2
  BOTTOM w0.097: U2013.42 79.1,72.34 79.22,72.46 79.59,72.46 79.76,72.63 80.24,72.63 80.29,72.58 80.3,72.58 C481.2
DPE_TX1_DP_C: length 2
  BOTTOM w0.097: U2013.41 79.09,72.84 79.2,72.73 79.47,72.73 79.65,72.91 80.21,72.91 C477.2
DPE_TX2_DN_C: length 2
  BOTTOM w0.097: C484.2 80.24,70.86 79.68,70.86 79.58,70.96 79.34,70.96 79.22,70.84 U2013.45
DPE_TX2_DP_C: length 2
  BOTTOM w0.097: C478.2 80.22,71.13 79.8,71.13 79.69,71.23 79.22,71.23 79.12,71.34 U2013.44
DPE_TX3_DN_C: length 2.1
  BOTTOM w0.097: C482.2 80.21,69.12 79.81,69.12 79.48,69.44 79.32,69.44 79.22,69.34 U2013.48
DPE_TX3_DP_C: length 2.1
  BOTTOM w0.097: U2013.47 79.22,69.84 79.34,69.72 79.59,69.72 79.92,69.39 80.25,69.39 C483.2
DPF_AUX_DN_C: length 2.8
  BOTTOM w0.097: C582.2 65.37,67.58 65.68,67.27 65.68,67.13 64.99,66.44 64.99,66.18 64.88,66.07 U2014.29
DPF_AUX_DP_C: length 2.8
  BOTTOM w0.097: U2014.30 65.38,66.07 65.27,66.18 65.27,66.33 65.96,67.02 65.96,67.21 66.26,67.52 C583.2
DPF_CAD_SNK: length 2.9
  BOTTOM w0.097: R2105.1 62.58,57.1 62.83,57.36 63.09,57.36 63.47,57.74 63.72,57.74 63.88,57.89 U2014.10
DPF_CAD_SRC: length 1.6
  BOTTOM w0.097: TP187.1 64.88,57.75 U2014.8
DPF_CFG0: length 3.1
  BOTTOM w0.097: U2014.5 66.38,57.6 65.88,57.1 R590.2 R595.2
DPF_CFG1: length 4.4
  TOP w0.097: v2(68.04,63.45) 68.17,63.58 R487.2 68.85,63.53 69.44,62.94 v1(69.44,62.44) 68.62,62.44 R425.2
  BOTTOM w0.254: U2014.40 68.31,63.18 v2(68.04,63.45)
DPF_HPD_SNK: length 4.7
  BOTTOM w0.097: U2014.11 63.38,58.03 63.09,57.74 61.06,57.74 v1(60.8,57.48) 60.8,57.31 R423.1
DPF_PD: length 3.2
  BOTTOM w0.097: TP185.1 v1(62.07,66.75) 62.58,66.25 63.09,66.25 63.38,65.96 U2014.26
DPF_PEQ: length 3.2
  BOTTOM w0.097: R591.2 R437.2 66.88,57.2 U2014.4
DPF_RST_N: length 3.2
  BOTTOM w0.097: U2014.35 67.88,66.59 v1(67.91,66.63) 68.04,66.75 R2281.1 C2688.2
DPF_TX0_DN_C: length 2.2
  BOTTOM w0.097: C487.2 70.58,64.27 70.37,64.27 69.89,63.79 69.57,63.79 69.46,63.68 U2014.39
DPF_TX0_DP_C: length 2.2
  BOTTOM w0.097: C488.2 70.58,64.54 70.25,64.54 69.78,64.07 69.57,64.07 69.46,64.18 U2014.38
DPF_TX1_DN_C: length 2
  BOTTOM w0.097: C489.2 70.6,62.35 69.72,62.35 69.55,62.18 U2014.42
DPF_TX1_DP_C: length 2
  BOTTOM w0.097: C485.2 70.89,62.88 70.62,62.62 69.61,62.62 69.55,62.68 U2014.41
DPF_TX2_DN_C: length 2
  BOTTOM w0.097: U2014.45 69.51,60.68 69.62,60.79 69.91,60.79 70.11,60.59 70.58,60.59 C492.2
DPF_TX2_DP_C: length 2
  BOTTOM w0.097: U2014.44 69.51,61.18 69.62,61.07 70.02,61.07 70.23,60.86 70.58,60.86 C486.2
DPF_TX3_DN_C: length 2.2
  BOTTOM w0.097: U2014.48 69.51,59.18 69.62,59.29 69.75,59.29 70.23,58.81 70.58,58.81 C490.2
DPF_TX3_DP_C: length 2.2
  BOTTOM w0.097: U2014.47 69.11,59.68 69.51,59.68 69.62,59.57 69.86,59.57 70.35,59.08 70.58,59.08 C491.2
DPSNK_RBIAS: length 1.1
  TOP w0.356: R2029.2 54.48,83.13 v1(54.47,83.13)
  BOTTOM w0.178: U2005.Y18 54.8,83.45 v1(54.47,83.13)
DQMA0: length 22.6
  IN05 w0.14: v3(260.51,166.75) 260.11,166.35 260.11,155.18 260.51,154.78 260.51,149.07 260.37,148.92 260.37,145.98 v3(260.69,145.67)
  BOTTOM w0.152: G2.U47 v3(260.69,145.67) ; U48.P2 v3(260.51,166.75)
DQMA1: length 26.1
  IN05 w0.14: v3(258.77,147.26) 258.5,147.53 258.5,149.57 257.78,150.3 257.78,155.57 258.29,156.08 258.29,162.46 254.4,166.35 252.11,166.35 v3(251.71,166.75)
  BOTTOM w0.102: v3(258.77,147.26) 258.61,147.1 258.61,146.66 258.28,146.33 G2.Y48
  BOTTOM w0.152: U48.P13 v3(251.71,166.75)
DQMA2: length 38.5
  IN05 w0.14: v3(252.51,175.55) 252.11,175.95 252.11,176.52 251.88,176.75 250.33,176.75 249.4,175.81 249.4,174.32 247.99,172.91 247.99,162.65 252.6,158.03 252.6,148.59 253.51,147.69 253.51,146.09 v3(253.09,145.67)
  BOTTOM w0.152: G2.AG47 v3(253.09,145.67) ; U48.D13 252.11,175.15 v3(252.51,175.55)
DQMA3: length 42.5
  IN05 w0.14: v3(261.31,174.75) U48.D2 260.91,175.75 260.71,175.95 259.43,175.95 259.31,175.83 259.31,173.76 259.09,173.55 257.88,173.55 257.39,173.06 257.39,172.46 254.47,169.55 250.7,169.55 250.51,169.35 250.51,163.6 254.93,159.17 254.93,150.52 256.58,148.87 v3(256.58,147.17)
  BOTTOM w0.152: U48.D2 v3(261.31,174.75) ; G2.AC48 256.19,146.29 256.52,146.62 256.52,147.1 v3(256.58,147.17)
DQMA4: length 25.8
  IN05 w0.14: v3(233.67,166.75) 233.27,166.35 233.27,154.97 240.07,148.17 242.89,148.17 v3(243.18,148.47)
  BOTTOM w0.152: G2.BB51 v3(243.18,148.47) ; U2022.D2 v3(233.67,166.75)
DQMA5: length 27.8
  IN05 w0.14: v3(241.07,151.35) 241.07,151.76 239.87,152.96 239.87,165.71 240.51,166.35 242.87,166.35 v3(243.27,166.75)
  BOTTOM w0.102: G2.AV50 246.04,147.82 246.04,148.32 246.28,148.56 246.28,149.83 245.4,150.7 241.51,150.7 241.39,150.82
  BOTTOM w0.152: U2022.D13 v3(243.27,166.75) ; v3(241.07,151.35) 241.07,151.14 241.39,150.82
DQMA6: length 35.4
  IN05 w0.14: v3(243.28,175.55) 243.68,175.95 244.66,175.95 246.56,174.04 246.56,161.42 251.01,156.98 251.01,149.21 249.97,148.18 249.97,147.48 v3(250.28,147.17)
  BOTTOM w0.102: G2.AM48 249.89,146.29 250.23,146.64 250.23,147.12 v3(250.28,147.17)
  BOTTOM w0.152: U2022.P13 v3(243.28,175.55)
DQMA7: length 38.7
  IN05 w0.14: v3(233.67,174.75) 234.07,174.35 234.07,172.54 234.67,171.95 235.51,171.95 240.31,167.15 243.46,167.15 243.8,166.81 243.8,163.94 242.08,162.23 242.08,153.97 246.03,150.02 v3(247,150.02)
  BOTTOM w0.102: G2.AR49 247.43,147.12 247.43,149.06 247.37,149.13 247.37,149.65 v3(247,150.02)
  BOTTOM w0.152: U2022.P2 v3(233.67,174.75)
DQMB0: length 25.8
  IN05 w0.14: v3(289.7,146.54) 289.3,146.14 289.3,145.52 288.93,145.14 286.03,145.14 276.19,135.31 274.91,135.31 v3(274.47,134.87)
  BOTTOM w0.102: G2.C32 270.52,134.54 270.96,134.54 271.27,134.23 273.83,134.23 273.91,134.31
  BOTTOM w0.152: U2023.P2 v3(289.7,146.54) ; 273.91,134.31 v3(274.47,134.87)
DQMB1: length 31.4
  IN05 w0.14: v3(269.09,135.97) 269.22,135.97 269.96,136.7 270.85,136.7 271.68,137.53 273.42,137.53 289.3,153.41 289.3,155.74 v3(289.7,156.14)
  BOTTOM w0.152: U2023.P13 v3(289.7,156.14) ; G2.E33 268.79,135.67 v3(269.09,135.97)
DQMB2: length 39.6
  IN05 w0.14: v3(298.5,156.14) 298.1,156.54 298.1,157.31 295.99,159.42 286.01,159.42 271.83,145.24 271.83,144.31 270.49,142.97 v3(269.09,142.97)
  BOTTOM w0.152: G2.E44 v3(269.09,142.97) ; U2023.D13 v3(298.5,156.14)
DQMB3: length 52
  IN05 w0.14: v3(267.57,140.7) 268.34,141.48 270.14,141.48 282.02,153.36 282.02,154.09 286.67,158.74 295.7,158.74 297.3,157.14 297.3,153.49 297.7,153.09 297.7,152 298.9,150.8 298.9,149.9 298.9,149.9 298.9,149.57 298.9,149.57 298.9,147.14 298.69,146.92 298.09,146.92 v3(297.7,146.54)
  BOTTOM w0.102: v3(267.57,140.7) 267.52,140.7 267.4,140.57 267.4,139.78 G2.G39
  BOTTOM w0.152: U2023.D2 v3(297.7,146.54)
DQMB4: length 24.2
  IN05 w0.14: v3(261.79,149.88) 262.77,150.87 262.77,151.77 269.13,158.12 269.13,166.35 v3(269.53,166.75)
  BOTTOM w0.102: G2.P49 262.15,147.1 262.15,149.03 262.21,149.09 262.21,149.55 261.88,149.88 v3(261.79,149.88)
  BOTTOM w0.152: U55.D2 v3(269.53,166.75)
DQMB5: length 29.4
  IN05 w0.14: v3(264.98,147.17) 264.68,147.47 264.68,148.27 265.4,148.99 266.24,148.99 267.51,150.26 268.07,150.26 273.9,156.09 273.9,156.92 275.19,158.21 275.19,165.99 275.55,166.35 277.93,166.35 v3(278.33,166.75)
  BOTTOM w0.102: G2.L48 264.59,146.31 264.91,146.64 264.91,147.1 v3(264.98,147.17)
  BOTTOM w0.152: U55.D13 v3(278.33,166.75)
DQMB6: length 38.7
  IN05 w0.14: v3(278.33,175.55) 278.73,175.15 279.45,175.15 281.17,173.42 281.17,163.99 278.74,161.56 278.74,155.66 273.44,150.36 269.71,150.36 269.08,149.72 269.08,149.1 268.59,148.62 268.59,147.62 269.05,147.17 v3(269.18,147.17)
  BOTTOM w0.152: G2.D50 v3(269.18,147.17) ; U55.P13 v3(278.33,175.55)
DQMB7: length 32.9
  IN05 w0.14: v3(268.73,174.75) 269.13,174.35 269.13,172.94 269.32,172.75 270.84,172.75 272.68,170.9 272.68,157.97 268.01,153.3 v3(268.01,151.87)
  BOTTOM w0.102: G2.H50 267.04,147.82 267.04,148.37 267.65,148.99 267.65,150.16 268.01,150.52 v3(268.01,151.87)
  BOTTOM w0.152: U55.P2 v3(268.73,174.75)
DQMC0: length 21.1
  IN05 w0.14: v3(271.88,115.67) 272.05,115.84 273.53,115.84 274.19,115.17 281.99,115.17 286.08,111.09 289.42,111.09 v3(289.83,111.49)
  BOTTOM w0.152: G2.A5 v3(271.88,115.67) ; U2025.P2 290.22,111.88 v3(289.83,111.49)
DQMC1: length 23.2
  IN03 w0.14: v3(289.83,121.09) 289.83,121.08 289.43,120.69 288.84,120.69 288.63,120.47 288.63,118.41 288.36,118.14 274.97,118.14 274.36,117.53 270.6,117.53 v3(270.44,117.7)
  BOTTOM w0.152: G2.C8 270.44,117.82 v3(270.44,117.7) ; U2025.P13 v3(289.83,121.09)
DQMC2: length 39.9
  IN05 w0.14: v3(298.62,120.29) 299.02,120.68 299.62,120.68 299.83,120.89 299.83,122.41 296.66,125.59 286.03,125.59 285.35,124.9 266.15,124.9 v3(265.69,125.37)
  BOTTOM w0.152: v3(298.62,120.29) 298.23,120.68 U2025.D13 ; G2.J18 v3(265.69,125.37)
DQMC3: length 42
  IN05 w0.076: v3(267.79,121.17) 268.15,120.8 270.49,120.8 270.62,120.93
  IN05 w0.14: v3(297.82,112.29) 298.22,112.69 298.22,113.43 298.39,113.6 298.39,115.39 295.82,117.95 295.82,122.06 294.38,123.5 286.88,123.5 285.51,122.13 271.82,122.13 270.62,120.93
  BOTTOM w0.152: U2025.D2 v3(297.82,112.29) ; G2.F12 v3(267.79,121.17)
DQMC4: length 23.9
  IN05 w0.14: v3(289.83,139.11) 289.43,139.52 283.58,139.52 279.22,135.15 278.26,135.15 v3(277.97,134.87)
  BOTTOM w0.102: 276.28,133.18 271.8,133.18 271.75,133.13 269.85,133.13 G2.D29
  BOTTOM w0.152: v3(289.83,139.11) 290.22,138.72 U2024.D2 ; 276.28,133.18 v3(277.97,134.87)
DQMC5: length 26.9
  IN10 w0.14: v3(289.83,129.52) 289.43,129.92 288.85,129.92 288.63,130.14 288.63,132.1 287.43,133.3 282.9,133.3 280,130.39 276.51,130.39 275.77,131.13 273.49,131.13 273.02,131.6 271.94,131.6 271.04,132.51 269.93,132.51 v3(269.09,131.67)
  BOTTOM w0.152: G2.E27 v3(269.09,131.67) ; U2024.D13 v3(289.83,129.52)
DQMC6: length 36.6
  IN05 w0.14: v3(298.63,130.32) 299.03,129.92 299.63,129.92 299.83,129.72 299.83,127.77 298.37,126.31 269.61,126.31 269.47,126.45 268.67,126.45 v3(268.39,126.17)
  BOTTOM w0.152: G2.F20 v3(268.39,126.17) ; U2024.P13 298.23,129.92 v3(298.63,130.32)
DQMC7: length 37.6
  IN05 w0.14: v3(297.83,139.11) 297.43,138.71 296.85,138.71 296.63,138.49 296.63,137.35 293.43,134.15 293.43,130.14 293.21,129.92 276.44,129.92 275.15,131.2 271.52,131.2 270.66,130.35 270.06,130.35 v3(269.93,130.21)
  BOTTOM w0.102: G2.E26 269.05,130.67 269.4,130.31 269.83,130.31 v3(269.93,130.21)
  BOTTOM w0.152: U2024.P2 298.22,138.72 v3(297.83,139.11)
DQMD0: length 21.1
  IN05 w0.14: v3(244.47,95.92) 244.87,96.32 244.87,98.78 249.67,103.58 249.67,109.5 251.04,110.87 v3(251.3,110.87)
  BOTTOM w0.152: U2026.P2 v3(244.47,95.92) ; v3(251.3,110.87) 251.99,111.56 G2.AJ1
DQMD1: length 19.2
  IN05 w0.14: v3(254.09,111.55) 255.38,110.26 255.38,101.72 254.47,100.81 254.47,96.32 v3(254.07,95.92)
  BOTTOM w0.152: U2026.P13 v3(254.07,95.92) ; v3(254.09,111.55) 253.39,112.25 G2.AG1
DQMD2: length 33.3
  IN05 w0.14: v3(257.28,117.07) 257.64,116.72 257.64,101.46 256.61,100.43 256.61,89.26 255.67,88.32 253.67,88.32 v3(253.27,87.92)
  BOTTOM w0.152: U2026.D13 v3(253.27,87.92) ; G2.AA7 v3(257.28,117.07)
DQMD3: length 35.4
  IN05 w0.14: v3(255.1,115.66) 255.36,115.4 255.36,114.17 254.85,113.67 254.34,113.67 253.61,112.93 253.61,109.08 253.07,108.55 253.07,107.68 253.67,107.08 253.67,102.01 251.12,99.46 251.12,94.01 247.03,89.92 245.81,89.92 245.67,89.78 245.67,87.52 v3(245.27,87.12)
  BOTTOM w0.152: U2026.D2 v3(245.27,87.12) ; G2.AD5 255.18,115.66 v3(255.1,115.66)
DQMD4: length 23.8
  IN05 w0.14: v3(272.23,95.92) 272.63,96.32 273.74,96.32 274.92,97.5 274.92,105.96 270.01,110.87 270.01,114.65 v3(269.79,114.87)
  BOTTOM w0.152: U60.D2 v3(272.23,95.92) ; G2.D3 v3(269.79,114.87)
DQMD5: length 23
  IN05 w0.14: v3(267.47,113.1) 267.9,112.66 267.9,98.02 266.2,96.32 263.83,96.32 v3(263.43,95.92)
  BOTTOM w0.102: v3(267.47,113.1) 267.47,113.29 267.01,113.74 267.01,114.04 266.69,114.37 G2.H3
  BOTTOM w0.152: U60.D13 263.03,95.52 v3(263.43,95.92)
DQMD6: length 32.8
  IN05 w0.14: v3(262.63,87.12) 262.23,87.52 261.66,87.52 259.1,90.08 259.1,99.3 261.24,101.44 261.24,112.67 260.37,113.54 260.37,115.3 v3(260.73,115.66)
  BOTTOM w0.152: v3(260.73,115.66) 260.69,115.66 G2.U5 ; U60.P13 v3(262.63,87.12)
DQMD7: length 41.8
  IN05 w0.14: v3(263.58,119.07) 264.31,118.34 264.31,114.52 265.4,113.44 265.4,98.86 264.46,97.92 262.38,97.92 262.08,97.62 262.08,95.84 262.41,95.52 265.38,95.52 270.18,90.72 270.8,90.72 271.83,89.69 271.83,88.32 v3(272.23,87.92)
  BOTTOM w0.152: G2.M9 v3(263.58,119.07) ; U60.P2 v3(272.23,87.92)
DQSA0: length 21.3
  IN05 w0.14: v3(261.31,165.95) 261.71,165.55 261.71,158.35 261.35,157.99 261.35,148.49 261.91,147.93 261.91,146.79 v3(261.49,146.37)
  BOTTOM w0.152: U48.R2 v3(261.31,165.95) ; v3(261.48,146.37) G2.R48
DQSA1: length 23.8
  IN05 w0.14: v3(252.51,165.95) 252.91,165.55 252.91,163.96 256.76,160.1 256.76,150.52 257.94,149.34 257.94,147.19 258.4,146.74 259,146.74 v3(259.37,146.37)
  BOTTOM w0.152: G2.V48 259.39,146.36 259.38,146.36 v3(259.37,146.37) ; v3(252.51,165.95) 252.11,166.35 U48.R13
DQSA2: length 37.9
  IN05 w0.14: v3(251.71,176.35) 251.31,175.95 250.59,175.95 250.03,175.39 250.03,174.07 248.66,172.7 248.66,162.93 253.29,158.29 253.29,149.87 253.18,149.75 253.18,149.01 253.94,148.26 253.94,144.02 v3(254.39,143.57)
  BOTTOM w0.152: U48.C13 v3(251.71,176.35) ; G2.AF44 v3(254.39,143.57)
DQSA3: length 38.9
  IN05 w0.14: v3(260.51,175.55) 260.11,175.15 260.11,172.96 259.9,172.75 259.22,172.75 254.42,167.95 251.48,167.95 251.31,167.77 251.31,163.98 255.61,159.68 255.61,150.7 257.62,148.68 257.62,146.76 v3(257.23,146.38)
  BOTTOM w0.152: G2.AA48 257.28,146.38 v3(257.23,146.38) ; U48.C2 v3(260.51,175.55)
DQSA4: length 23.1
  IN05 w0.14: v3(234.48,165.95) 234.07,165.55 234.07,155.27 240.57,148.78 241.82,148.78 v3(242.09,149.05)
  BOTTOM w0.152: v3(234.48,165.95) 234.07,166.35 U2022.C2 ; G2.BB52 242.75,149 242.13,149 v3(242.09,149.05)
DQSA5: length 24
  IN05 w0.14: v3(242.29,151.35) 242.29,151.87 240.98,153.18 240.98,162.83 242.07,163.92 242.07,165.55 v3(242.48,165.95)
  BOTTOM w0.102: G2.AT50 247.09,147.62 246.74,147.97 246.74,148.37 246.56,148.54 246.56,150.16 245.73,150.99 242.65,150.99 242.58,151.06
  BOTTOM w0.152: U2022.C13 v3(242.48,165.95) ; 242.58,151.06 v3(242.29,151.35)
DQSA6: length 37.1
  IN05 w0.14: v3(242.48,176.35) 242.88,176.75 244.96,176.75 247.24,174.47 247.24,161.76 251.7,157.3 251.7,147.16 v3(250.94,146.4)
  BOTTOM w0.152: U2022.R13 v3(242.48,176.35) ; G2.AK48 251.28,146.07 v3(250.94,146.4)
DQSA7: length 39
  IN05 w0.14: v3(247.79,150) 247.35,150.44 246.82,150.44 242.91,154.34 242.91,161.71 244.72,163.51 244.72,170.32 243.89,171.15 240.78,171.15 240.35,171.57 239.1,171.57 237.57,173.1 237.57,173.87 236.78,174.67 236.05,174.67 235.57,175.15 234.88,175.15 v3(234.48,175.55)
  BOTTOM w0.102: v3(247.79,150) 248.16,149.63 248.16,148.77 247.79,148.4 G2.AR51
  BOTTOM w0.152: U2022.R2 234.07,175.95 v3(234.48,175.55)
DQSB0: length 23.9
  IN05 w0.14: v3(273.99,135.72) 274.49,136.22 275.7,136.22 286.42,146.94 288.5,146.94 v3(288.9,147.34)
  BOTTOM w0.102: G2.B33 271.43,136.11 273.76,136.11 273.99,135.88 v3(273.99,135.72)
  BOTTOM w0.152: U2023.R2 v3(288.9,147.34)
DQSB1: length 30.3
  IN05 w0.14: v3(288.9,155.34) 288.5,154.94 287.08,154.94 285.55,153.41 285.55,151.46 272.45,138.36 271.92,138.36 270.67,137.11 268.93,137.11 v3(268.49,136.67)
  BOTTOM w0.152: G2.E35 v3(268.49,136.67) ; U2023.R13 v3(288.9,155.34)
DQSB2: length 45.1
  IN05 w0.14: v3(299.3,155.34) U2023.C13 298.9,157.64 296.45,160.09 285.69,160.09 271.13,145.53 271.13,144.38 270.49,143.75 267.59,143.75 267.07,143.23 266.65,143.23 v3(266.5,143.08)
  BOTTOM w0.152: U2023.C13 v3(299.3,155.34) ; v3(266.5,143.08) 266.69,143.27 G2.G44
DQSB3: length 50.1
  IN05 w0.14: v3(298.5,147.34) 298.1,147.74 298.1,148.35 297.91,148.54 295.78,148.54 292.5,151.81 292.5,156.32 292.29,156.54 287.1,156.54 284.73,154.16 284.73,151.92 270.21,137.41 267,137.41 266.62,137.79 266.62,138.41 266.39,138.64 v3(266.39,138.77)
  BOTTOM w0.152: v3(298.5,147.34) 298.9,146.94 U2023.C2 ; v3(266.39,138.77) G2.H38
DQSB4: length 23.9
  IN05 w0.14: v3(268.73,165.95) 268.33,166.35 267.54,166.35 267.17,165.98 267.17,157.13 v3(261.79,151.74)
  BOTTOM w0.102: G2.P50 262.84,147.82 262.84,148.45 263.01,148.62 263.01,150.51 262.47,151.05
  BOTTOM w0.152: 262.47,151.05 v3(261.79,151.74) ; U55.C2 v3(268.73,165.95)
DQSB5: length 26.2
  IN05 w0.14: v3(277.53,165.95) 277.13,165.55 277.13,163.34 276.4,162.61 276.4,157.16 270.95,151.71 269.92,151.71 268.18,149.97 267.94,149.97 266.21,148.24 266.21,147.72 265.98,147.49 265.98,146.66 v3(265.69,146.37)
  BOTTOM w0.152: U55.C13 v3(277.53,165.95) ; v3(265.69,146.37) G2.J48
DQSB6: length 39
  IN05 w0.14: v3(269.79,148.47) 269.83,148.47 270.98,149.62 273.67,149.62 279.43,155.38 279.43,161.16 281.93,163.67 281.93,174.16 279.34,176.75 277.93,176.75 v3(277.53,176.35)
  BOTTOM w0.152: G2.D51 v3(269.79,148.47) ; U55.R13 v3(277.53,176.35)
DQSB7: length 33.2
  IN05 w0.14: v3(268.91,151.97) 269.33,151.97 270.03,152.67 270.03,154.33 273.68,157.97 273.68,171.63 272.78,172.52 272.78,173.93 272.06,174.66 271.12,174.66 270.63,175.15 269.93,175.15 v3(269.53,175.55)
  BOTTOM w0.102: G2.F51 268.45,148.53 268.45,149.33 268.57,149.45 268.57,150.12 268.91,150.45 268.91,150.62
  BOTTOM w0.152: 268.91,150.62 v3(268.91,151.97) ; U55.R2 v3(269.53,175.55)
DQSC0: length 23
  IN05 w0.14: v3(289.03,112.29) 288.63,111.89 286.24,111.89 282.27,115.86 274.44,115.86 274.13,116.16 269.68,116.16 v3(269.18,115.67)
  BOTTOM w0.152: v3(289.03,112.29) 289.03,112.29 U2025.R2 ; G2.D5 v3(269.18,115.67)
DQSC1: length 32.8
  IN05 w0.14: v3(289.03,120.29) 288.63,119.89 288.63,116.5 290.23,114.9 290.23,112.91 290.01,112.69 286.39,112.69 282.55,116.53 269.74,116.53 269.49,116.79 269.49,117.46 v3(269.18,117.77)
  BOTTOM w0.152: G2.D8 v3(269.18,117.77) ; U2025.R13 v3(289.03,120.29)
DQSC2: length 33.7
  IN05 w0.14: v3(299.43,121.08) 299.42,121.08 299.03,121.48 299.03,122.17 296.3,124.9 286.34,124.9 285.68,124.23 269.25,124.23 v3(269.09,124.07)
  BOTTOM w0.152: v3(269.09,124.07) G2.E17 ; U2025.C13 v3(299.43,121.08)
DQSC3: length 42.9
  IN05 w0.14: v3(298.62,111.49) 299.02,111.89 299.02,113.49 298.93,113.58 298.93,116.33 297.83,117.43 297.83,118 297.42,118.4 297.42,122.1 295.3,124.22 286.65,124.22 285.38,122.96 270.88,122.96 v3(269.09,121.17)
  BOTTOM w0.152: v3(298.62,111.49) 299.02,111.88 U2025.C2 ; G2.E12 v3(269.09,121.17)
DQSC4: length 23.1
  IN05 w0.14: v3(289.03,138.31) 288.63,137.92 283.83,137.92 280.22,134.31 271.43,134.31 270.58,133.46 269.39,133.46 v3(269.09,133.77)
  BOTTOM w0.152: U2024.C2 289.43,138.71 v3(289.03,138.31) ; G2.E30 v3(269.09,133.77)
DQSC5: length 20.4
  IN05 w0.14: v3(272.64,132.77) 273.25,132.15 287.03,132.15 287.67,131.52 288.41,131.52 288.63,131.3 288.63,130.72 v3(289.03,130.32)
  BOTTOM w0.102: G2.B29 271.29,132.37 272.24,132.37
  BOTTOM w0.152: U2024.C13 v3(289.03,130.32) ; 272.24,132.37 v3(272.64,132.77)
DQSC6: length 35
  IN05 w0.14: v3(267.09,127.47) 267.57,126.99 297.58,126.99 299.03,128.43 299.03,129.12 v3(299.43,129.52)
  BOTTOM w0.152: U2024.R13 299.03,129.92 v3(299.43,129.52) ; G2.G21 v3(267.09,127.47)
DQSC7: length 37.3
  IN05 w0.14: v3(298.63,138.31) 298.23,137.91 298.23,137.27 297.47,136.51 297.47,135.59 294.23,132.35 294.23,129.33 294.01,129.12 286.36,129.12 286.26,129.22 269.48,129.22 v3(269.09,129.62)
  BOTTOM w0.152: U2024.R2 299.03,138.71 v3(298.63,138.31) ; G2.E24 268.79,129.32 v3(269.09,129.62)
DQSD0: length 21.8
  IN05 w0.14: v3(245.27,96.72) 245.67,97.12 245.67,98.51 250.35,103.2 250.35,108.9 251.16,109.71 v3(251.3,109.71)
  BOTTOM w0.102: 252.54,113.34 252.54,113.49 252.32,113.71 252.32,114.24 G2.AJ3
  BOTTOM w0.152: U2026.R2 v3(245.27,96.72) ; 252.54,113.34 252.54,110.79 251.45,109.71 v3(251.3,109.71)
DQSD1: length 19.1
  IN05 w0.14: v3(253.27,96.72) 253.67,97.12 253.67,100.96 254.58,101.87 254.58,109.89 v3(254.09,110.38)
  BOTTOM w0.152: G2.AG2 252.96,113.44 252.96,111.5 v3(254.09,110.38) ; U2026.R13 v3(253.27,96.72)
DQSD2: length 36
  IN05 w0.14: v3(254.07,87.12) 254.47,87.52 255.87,87.52 257.29,88.94 257.29,100.15 258.44,101.3 258.44,114.41 258.18,114.66 258.18,118.17 v3(257.28,119.07)
  BOTTOM w0.152: U2026.C13 v3(254.07,87.12) ; G2.AA9 v3(257.28,119.07)
DQSD3: length 34.7
  IN05 w0.14: v3(254.39,114.97) 252.9,113.48 252.9,108.96 252.39,108.45 252.39,107.23 252.9,106.73 252.9,102.23 250.38,99.71 250.38,94.66 246.44,90.72 245.53,90.72 244.87,90.06 U2026.C2 v3(244.47,86.32)
  BOTTOM w0.152: G2.AF4 v3(254.39,114.97) ; U2026.C2 v3(244.47,86.32)
DQSD4: length 22.6
  IN05 w0.14: v3(271.43,96.72) 271.83,97.12 273.39,97.12 274.08,97.8 274.08,105.61 269.54,110.15 269.54,113.81 v3(269.09,114.27)
  BOTTOM w0.152: G2.E3 v3(269.09,114.27) ; U60.C2 v3(271.43,96.72)
DQSD5: length 21.6
  IN05 w0.14: v3(267.47,111.93) 267.01,111.47 267.01,98.39 265.74,97.12 263.03,97.12 v3(262.63,96.72)
  BOTTOM w0.102: v3(267.47,111.93) 267.04,112.35 267.04,113.31 266.69,113.67 G2.H2
  BOTTOM w0.152: U60.C13 v3(262.63,96.72)
DQSD6: length 36.8
  IN05 w0.14: v3(263.43,86.32) 263.03,85.92 261.67,85.92 258.43,89.16 258.43,99.68 260.49,101.75 260.49,112.11 259.78,112.83 259.78,116.06 v3(260.68,116.96)
  BOTTOM w0.152: G2.U6 v3(260.68,116.96) ; U60.R13 v3(263.43,86.32)
DQSD7: length 38.4
  IN05 w0.14: v3(271.43,87.12) 271.43,87.12 271.03,87.52 270.38,87.52 269.66,88.24 268.85,88.24 268.5,88.59 268.5,90.63 265.22,93.92 262.45,93.92 262.05,94.32 261.44,94.32 261.19,94.58 261.19,98.19 263.61,100.61 263.61,115.09 263.84,115.33 263.84,115.91 v3(263.54,116.22)
  BOTTOM w0.152: G2.M5 263.79,115.97 v3(263.54,116.22) ; U60.R2 v3(271.43,87.12)
DRAM_CRESET_N: length 97.5
  TOP w0.097: v2(161.39,55.96) 162.15,55.2 162.15,52.4 v2(166.47,48.09)
  IN10 w0.091: v2(166.47,48.09) 169.64,48.09 170.66,49.1 200.95,49.1 202.22,50.37 214.47,50.37 215.7,49.15 215.7,47.88 216.5,47.07 223.36,47.07 223.87,46.56 234.66,46.56 237.59,49.48 237.59,49.74 239.36,51.51 240.63,51.51 241.9,52.78 v3(241.9,53.17)
  BOTTOM w0.097: R86.1 160.8,59.01 C170.2 R84.1 161.77,56.34 v2(161.39,55.96) ; v3(241.9,53.17) 241.9,52.51 U2.BC14
DRON: length 119.5
  TOP w0.203: PU1101.35 130.61,192.4
  TOP w0.254: v2(132.96,192.84) 132.91,192.84 132.51,192.43 130.65,192.43 130.61,192.4
  IN03 w0.254: v2(211.42,188.67) 211.04,189.06 211.04,191.93 211.47,192.36 211.8,192.36 212.19,192.74 212.19,197.47 211.61,198.04 208.25,198.04 207.27,197.06 200.76,197.06 197.96,194.26 197.96,193.25 197.58,192.87 197.58,190.45 199.36,188.67 v2(200.37,188.67)
  IN05 w0.254: v2(132.96,192.84) 133.62,192.18 133.62,191.79 134.05,191.36 153.28,191.36 154.02,192.1 165.32,192.1 v2(166.34,193.12) 166.85,193.63 167.74,193.63 169.01,192.36 174.21,192.36 176.75,189.82 177.51,189.82 177.9,190.2 177.9,191.21 177.26,191.85 v2(177.26,193.25) 178.28,193.25 179.04,192.48 187.42,192.48 v2(188.18,193.25) 188.69,193.25 191.1,190.83 197.71,190.83 199.87,188.67 v2(200.37,188.67)
  BOTTOM w0.254: PR1506.1 166.47,192.99 v2(166.34,193.12) ; v2(177.26,193.25) PR1512.1
  BOTTOM w0.356: v2(200.37,188.67) 200.12,188.93 PR1606.1 ; v2(211.42,188.67) 211.3,188.67 211.04,188.93 PR1620.1
  BOTTOM w0.381: PR1611.1 188.08,193.15 v2(188.18,193.25)
EC_ADP_ID_ON_N: length 125.3
  TOP w0.097: v2(76.3,81.99) 77.95,81.99 78.33,82.38 78.33,89.23 v1(79.85,90.76) 81.25,92.15 81.25,93.17 81.5,93.42 PQ101.5
  IN05 w0.091: v2(44.16,48.34) 44.67,47.83 47.49,47.83 53.97,41.35 53.97,37.39 58.49,32.87 66.42,32.87 68.98,30.31 70.07,30.31 72.87,33.1 75.66,33.1 76.17,33.61 79.34,33.61 79.6,33.35 v2(81.38,33.35)
  IN08 w0.091: v2(81.38,33.35) 76.55,38.18 76.55,50.24 77.15,50.85 77.15,58.96 76.47,59.64 76.47,65.56 74.39,67.64 74.39,78.31 75.03,78.95 76.17,78.95 76.47,79.25 76.47,80.81 76.3,80.98 v2(76.3,81.99)
  BOTTOM w0.076: 38.55,51.16 38.04,51.16 37.78,51.41 U5.D12
  BOTTOM w0.097: 38.55,51.16 39.97,49.74 39.97,48.85 40.41,48.41 44.09,48.41 v2(44.16,48.34)
EC_AGND: length 203.2
  TOP w0.203: R558.2 154.91,133.1 154.91,132.32 147.54,124.95 147.54,115.9 140.68,109.05 124.48,109.05 v2(124.23,109.3)
  IN05 w0.203: v2(94.41,38.18) 93.4,37.16 90.27,37.16 88.67,35.56 58.04,35.56 55.59,38.01 55.59,43.01 53.54,45.06 53.54,46.59 51.89,48.24 49.09,48.24 45.82,51.51 45.21,51.51 44.96,51.77 44.96,52.2 44.32,52.83 41.93,52.83 41.24,52.15 38.32,52.15 37.68,51.51 v1(37.37,51.51)
  IN08 w0.203: v2(124.23,109.3) 123.84,108.92 122.27,108.92 111.98,98.63 111.98,89.23 108.75,86 108.75,70.76 105.12,67.14 105.12,66.37 101.19,62.44 99.71,62.44 98.52,61.25 98.52,43.13 96.87,41.48 96.87,40.08 95.47,38.69 94.96,38.69 94.46,38.18 v2(94.41,38.18)
  BOTTOM w0.254: U5.E10 37.18,51.51 v1(37.37,51.51)
EC_CK32K/GPJ6: length 7.3
  TOP w0.097: v2(28.67,50.24) 29.1,49.81 R526.2
  BOTTOM w0.076: U5.F2 32.77,52.41 32.51,52.67 31.97,52.67
  BOTTOM w0.097: R261.2 28.67,50.04 v2(28.67,50.24) 28.67,50.42 29.56,51.31 30.49,51.31 31.84,52.67 31.97,52.67
EC_CLEAR_CMOS: length 219.1
  TOP w0.089: v3(40.99,50.52) 40.99,50.85 40.41,51.44 R523.1
  TOP w0.097: v2(233.65,45.8) 233.78,45.67 233.9,45.67 236.06,43.51 242.23,43.51 C401.1 243.35,44.28 R428.2 244.32,44.49 Q12.2
  IN03 w0.089: 41.5,50.58 41.05,50.58 v3(40.99,50.52)
  IN03 w0.091: 41.5,50.58 43.83,50.58 45.35,49.06 45.75,49.06 45.88,49.18 58.72,49.18 60.8,51.26 60.8,51.77 63.21,54.18 70.58,54.18 72.26,55.86 76.57,55.86 77.15,55.29 86.42,55.29 88.88,57.75 103.87,57.75 106.27,60.15 110.84,60.15 111.86,59.13 126.84,59.13 126.97,59.01 130.4,59.01 131.92,57.48 156.05,57.48 156.69,56.85 188.94,56.85 190.98,54.82 214.8,54.82 219.5,50.12 220.57,50.12 224.25,46.43 233.01,46.43 v2(233.65,45.8)
EC_CS_N: length 10.8
  BOTTOM w0.097: U5.A7 35.27,45.77 35.04,45.54 35.04,41.79 35.27,41.56 v1(35.27,40.97) 34.78,40.48 RP4.8
EC_FAN_PWM1: length 347.9
  IN05 w0.089: 40.86,58.63 40.86,58.25 41.5,57.61
  IN05 w0.091: v2(115.54,38.56) 115.28,38.31 113.15,38.31 110.72,35.88 101.88,35.88 97.89,39.87 97.89,40.59 92.93,45.55 90.28,45.55 89.3,46.52 72.4,46.52 72.05,46.87 61.41,46.87 55.5,52.78 55.09,52.78 52.8,55.07 52.8,57.74 51.95,58.59 46.66,58.59 45.54,57.46 41.64,57.46 41.56,57.55 41.5,57.61 ; v2(34.39,60.23) 35.2,60.23 35.91,59.52 36.8,59.52 37.81,60.53 39.59,60.53 40.86,59.26 40.86,58.63
  IN08 w0.091: v2(115.54,38.56) 115.79,38.81 115.79,42.75 119.71,46.67 167.94,46.67 170.25,44.35 189.33,44.35 191.44,42.24 200.12,42.24 202.74,44.86 212.5,44.86 215.5,41.86 235.31,41.86 235.44,41.99 253.59,41.99 254.02,41.56 255.4,41.56 255.7,41.86 255.7,42.27 255.9,42.47 256.57,42.47 258.55,44.45 258.55,44.79 259.43,45.67 264.64,45.67 265.65,44.66 267.56,44.66 270.2,42.02 275.84,42.02 276.19,42.37 277.34,42.37 277.97,41.74 293.34,41.74 293.59,41.48 296.77,41.48 300.83,45.55 304.64,45.55 305.78,46.69 305.78,53.29 304.51,54.56 298.42,54.56 297.78,55.2 297.78,68.91 299.31,70.44 299.31,71.33 298.67,71.96 v2(298.42,71.96)
  BOTTOM w0.076: 35.03,56.21 35.03,55.67 34.77,55.42 U5.M6
  BOTTOM w0.097: 35.03,56.21 35.03,58.12 34.89,58.25 34.89,59.72 v2(34.39,60.23) ; v2(298.42,71.96) 296.85,73.53 295.78,73.53 294.62,74.7 JFAN1.3
EC_FAN_PWM2: length 121
  IN05 w0.203: v2(34.39,59.01) 34.51,58.88 39.47,58.88 41.38,56.97 45.94,56.97 47.06,58.09 51.56,58.09 52.04,57.61 52.04,54.82 54.77,52.08 55.15,52.08 57.12,50.11 57.12,49.43 60.17,46.38 67.54,46.38 68.12,45.8 74.9,45.8 76.93,43.77 82.26,43.77 83.92,45.42 v2(83.92,45.75)
  IN10 w0.203: v2(83.92,45.75) 83.92,47.45 84.55,48.09 84.55,52.4 84.93,52.78 84.93,62.44 85.69,63.2 85.69,67.01 88.36,69.68 88.36,88.68 91.28,91.61 91.28,95.84 91.79,96.35 92.68,96.35 v2(92.81,96.47)
  BOTTOM w0.097: U5.N6 34.77,57.99 34.51,58.25 34.51,58.88 v2(34.39,59.01)
  BOTTOM w0.254: v2(92.81,96.47) 93.3,96.97 JFAN2.3
EC_FAN_TACH1: length 341.8
  TOP w0.089: v1(38.27,56.47) 38.27,57.71 R253.2
  IN05 w0.091: v2(116.43,37) 113.36,37 111.16,34.81 100.54,34.81 96.36,38.98 96.36,39.81 92.15,44.02 84.17,44.02 83.28,43.13 74.29,43.13 73,44.42 67.89,44.42 66.54,45.78 59.76,45.78 55.75,49.78 53.44,49.78 52.85,50.37 51.02,50.37 50.01,51.39 49.5,51.39 46.2,54.69 41.5,54.69 40.69,55.5 39.7,55.5 38.73,56.47 v1(38.27,56.47)
  IN08 w0.091: v2(116.43,37) 116.05,37.38 116.05,42.7 118.81,45.46 168.68,45.46 170.12,44.02 189.07,44.02 191.18,41.91 200.68,41.91 203.34,44.58 212.27,44.58 215.29,41.56 235.55,41.56 235.73,41.74 253.46,41.74 253.87,41.33 256.26,41.33 258.79,43.86 258.79,44.53 259.68,45.42 264.38,45.42 265.53,44.28 267.56,44.28 270.17,41.66 275.99,41.66 276.3,41.35 276.96,41.35 277.08,41.48 293.21,41.48 293.47,41.23 296.89,41.23 300.83,45.16 304.9,45.16 306.17,46.43 306.17,53.67 305.02,54.82 298.55,54.82 298.04,55.32 298.04,68.79 299.69,70.44 299.69,72.98 v2(298.55,74.12)
  BOTTOM w0.076: 37.53,56.02 37.53,55.67 37.28,55.42 U5.M11
  BOTTOM w0.089: 37.53,56.02 37.85,56.34 38.14,56.34 v1(38.27,56.47)
  BOTTOM w0.097: v2(298.55,74.12) 298.16,74.5 295.86,74.5 295.78,74.42 295.4,74.42 295.15,74.68 295.15,75.44 294.64,75.95 JFAN1.2
EC_FAN_TACH2: length 117.1
  TOP w0.089: v1(39.21,55.45) 39.21,56.47 39.08,56.59 R254.2
  IN05 w0.203: v1(39.21,55.45) 39.47,55.2 40.48,55.2 41.37,54.31 46.07,54.31 49.37,51.01 49.88,51.01 50.88,50.01 52.78,50.01 55.85,46.94 55.85,45.42 57.63,43.64 57.63,42.88 57.88,42.62 58.39,42.62 58.64,42.88 68.29,42.88 69.57,41.61 74.64,41.61 75.79,42.75 78.33,42.75 78.58,42.5 83.66,42.5 v2(84.68,43.51)
  IN10 w0.203: v2(92.81,95.58) 92.42,95.96 91.92,95.96 91.66,95.71 91.66,91.52 88.74,88.6 88.74,69.55 86.2,67.01 86.2,63.07 85.31,62.18 85.31,52.66 84.93,52.28 84.93,47.7 84.68,47.45 v2(84.68,43.51)
  BOTTOM w0.076: 38.58,55.16 38.04,55.16 37.78,55.41 U5.M12
  BOTTOM w0.097: 38.58,55.16 38.92,55.16 v1(39.21,55.45)
  BOTTOM w0.254: v2(92.81,95.58) 92.94,95.72 JFAN2.2
EC_I2C_CLK3: length 836.8
  TOP w0.089: R563.2 36.29,50.82 v1(36.22,50.89)
  TOP w0.097: v2(299.82,174.58) 300.45,175.21 302.36,175.21 302.53,175.39 PR3584.1 ; v2(69.82,82.38) 69.44,82.76 R2242.1 ; PR3575.1 304.97,85.63 304.64,85.3 303.37,85.3 v2(302.86,84.79) ; R2240.1 80.99,76.91 v2(80.49,76.41) v1(78.07,78.82) 76.55,80.34 74.52,80.34 73.88,80.98 v2(73.88,81.87)
  IN03 w0.089: v1(36.22,50.89) 36.22,50.68 35.66,50.12 30.45,50.12 30.07,49.74 29.81,49.74
  IN03 w0.091: 29.81,49.74 29.69,49.74 28.92,48.97 28.54,48.97 27.15,47.58 27.15,45.93 v2(26.13,44.91)
  IN05 w0.091: v2(73.88,81.87) 73.37,81.36 70.24,81.36 69.82,81.78 v2(69.82,82.38) ; v2(302.86,84.79) 303.14,85.07 303.14,91.09 303.79,91.74 303.79,93.41 305.68,95.3 305.68,98.99 303.75,100.92 302.36,100.92 301.47,101.81 301.47,102.7 301.88,103.11 301.88,103.75 301.24,104.39 301.24,108.16 304.26,111.18 304.26,122.25 304.9,122.89 304.9,161.77 302.9,163.77 302.9,171.49 v2(299.82,174.58) ; v2(61.56,34.37) 60.67,33.48 58.65,33.48 54.48,37.65 54.48,41.71 52.32,43.87 52.32,45.95 51.81,46.46 49.6,46.46 47.72,48.34 45.76,48.34 44.44,49.66 42.77,49.66 42.31,50.12 36.99,50.12 v1(36.22,50.89)
  IN08 w0.091: v2(296.13,66.29) 295.75,65.91 295.75,59.64 294.61,58.5 289.02,58.5 288.85,58.67 278.43,58.67 275.33,61.78 275.33,62.67 274.8,63.2 274.8,67.64 271.28,71.16 258.96,71.16 258.29,71.83 258.29,74.12 258.03,74.37 253.84,74.37 252.95,73.49 252.95,72.19 247.9,67.14 243.81,67.14 243.55,66.88 242.03,66.88 241.59,67.32 240.06,67.32 239.74,67.64 239.11,67.64 238.86,67.39 237.59,67.39 237.33,67.14 233.65,67.14 233.01,67.77 233.01,69.17 232.76,69.42 232.38,69.42 231.49,68.53 226.03,68.53 224.89,69.68 222.85,69.68 221.77,70.76 221.77,73.8 218.79,76.79 212.57,76.79 207.49,81.87 207.49,90.76 209.51,92.78 209.51,94.37 210.64,95.5 210.64,102.54 213.52,105.42 215.49,105.42 215.81,105.74 v2(217.01,105.74) ; v2(299.82,58.88) 300.5,59.56 300.5,60.36 299.56,61.29 299.56,67.46 302.1,70 302.1,71.6 303.12,72.62 303.12,77.8 303.37,78.06 303.37,84.28 v2(302.86,84.79)
  IN10 w0.091: v2(299.82,58.88) 297.15,61.54 296.6,61.54 296.13,62.01 v2(296.13,66.29) ; v2(26.13,44.91) 26.97,44.07 26.97,42.33 26.51,41.86 26.51,38.31 28.92,35.89 28.92,20.95 26.59,18.62 26.59,7.26 29.83,4.02 41.12,4.02 41.62,4.52 46.83,4.52 50.38,8.08 61.92,8.08 62.75,7.24 62.75,6.86 v2(64.99,4.63) ; v2(299.82,174.58) 299.31,174.07 297.64,174.07 285.21,186.5 283.33,186.5 281.78,188.04 273,188.04 271.47,189.56 263.11,189.56 262.22,190.45 259.43,190.45 258.03,189.06 239.24,189.06 237.84,190.45 219.68,190.45 209.74,200.39 206.37,200.39 206.09,200.1 199.74,200.1 199.49,200.36 185.01,200.36 183.86,199.21 183.86,197.89 183.79,197.82 183.2,197.82 183,198.02 183,198.81 182.85,198.96 181.78,198.96 181.4,198.58 v2(176.63,198.58) 174.59,200.61 160.82,200.61 158.79,198.58 155.42,198.58 147.03,190.2 147.03,184.76 144.98,182.71 128.11,182.71 125.83,180.42 119.88,180.42 113.25,173.79 113.25,133.43 109.61,129.78 109.61,119.62 99.92,109.93 97.27,109.93 87.34,100.01 87.34,94.06 82.65,89.36 82.65,82.5 81.12,80.98 81.12,76.79 80.74,76.41 v2(80.49,76.41) 80.2,76.12 80.2,73.28 75.33,68.41 73.5,68.41 70.07,64.98 70.07,49.12 67.31,46.35 67.31,43.31 68.83,41.78 68.83,36.4 67.44,35 62.2,35 v2(61.56,34.37)
  BOTTOM w0.076: U5.E8 35.77,51.78 36.03,51.52 36.03,51.08 v1(36.22,50.89)
  BOTTOM w0.097: PR1314.1 177.57,197.64 v2(176.63,198.58) ; v2(217.01,105.74) PR3580.1 ; v2(64.99,4.63) 64.56,4.19 63.06,4.19 R2341.2
EC_I2C_CLK3_R: length 8.9
  TOP w0.076: U19.B3 68.84,8.11 68.45,8.11
  TOP w0.097: v1(67.79,7.95) 67.95,8.11 68.45,8.11
  BOTTOM w0.089: 66.77,5.58 67.02,5.83 67.02,6.3 67.41,6.68 67.41,7.57 v1(67.79,7.95)
  BOTTOM w0.097: R2341.1 63.05,6.01 65.66,6.01 66.18,5.49 66.69,5.49 66.77,5.58
EC_I2C_CLK5: length 258
  TOP w0.089: v1(34.77,54.94) 34.77,55.13 R238.2
  TOP w0.097: R319.1 265.58,27.84 v2(264.89,28.53)
  IN03 w0.091: v2(264.89,28.53) 264.34,29.08 264.34,33.02 264.77,33.45 264.77,34.85 262.1,37.52 260.02,37.52 259.33,38.21 211.51,38.21 210.78,37.47 206.6,37.47 205.97,38.11 203.54,38.11 203.46,38.03 203.13,38.03 203.05,38.11 202.27,38.11 202.19,38.03 201.86,38.03 201.78,38.11 201.03,38.11 200.93,38.01 200.58,38.01 200.48,38.11 123.32,38.11 119.45,34.24 117.44,34.24 v2(116.94,33.73)
  IN05 w0.091: v2(116.94,33.73) 115.87,34.8 112.08,34.8 111.43,34.15 100.15,34.15 95.63,38.68 95.63,39.39 95.01,40 88.23,40 85.49,37.26 59.95,37.26 58.23,38.98 58.23,39.54 56.61,41.16 56.61,43.51 54.58,45.55 54.58,46.87 52.26,49.19 49.34,49.19 45.16,53.37 40.87,53.37 40.69,53.55 39.44,53.55 37.71,55.28 35.12,55.28 v1(34.77,54.94)
  BOTTOM w0.089: U5.K6 v1(34.77,54.94)
EC_I2C_DATA3: length 830.2
  TOP w0.089: R564.2 35.23,49.99 v1(35.23,50.88)
  TOP w0.097: v2(300.58,174.58) 302.3,174.58 PR3587.1 ; v2(70.71,82.38) 70.45,82.63 R2243.1 ; v2(72.99,81.87) v1(72.99,80.98) 72.99,80.72 73.63,80.09 76.17,80.09 80.36,75.9 80.87,75.9 v2(81.38,76.41) 81.88,76.91 R2241.1 ; PR3578.1 297.71,85.75 297.78,85.68 300.96,85.68 301.34,85.3 301.85,85.3 302.36,84.79 302.36,84.41 v2(302.86,83.9)
  IN03 w0.089: v1(35.23,50.88) 35.23,50.71 34.89,50.37 31.85,50.37 31.34,50.88 29.81,50.88
  IN03 w0.091: v2(26.13,44.02) 25.7,44.45 25.7,47.53 25.93,47.76 26.82,47.76 28.42,49.36 28.8,49.36 29.31,49.86 29.31,50.37 29.81,50.88
  IN05 w0.091: v2(70.71,82.38) 71.22,81.87 v2(72.99,81.87) ; v2(302.86,83.9) 303.53,84.57 303.53,91.17 304.01,91.65 304.01,93.32 305.9,95.21 305.9,99.15 303.88,101.17 302.74,101.17 302.61,101.3 302.61,103.33 301.46,104.48 301.46,108.02 304.51,111.08 304.51,122.13 305.15,122.76 305.15,161.88 303.12,163.91 303.12,172.04 v2(300.58,174.58) ; v2(62.33,34.37) 61.05,33.1 58.65,33.1 54.22,37.52 54.22,41.58 51.33,44.47 51.33,45.97 51.1,46.2 49.43,46.2 47.55,48.09 45.05,48.09 44.35,48.79 42.82,48.79 42.01,49.61 36.5,49.61 v1(35.23,50.88)
  IN08 w0.091: v2(217.01,106.38) 216.13,106.38 215.39,105.64 213.41,105.64 210.42,102.65 210.42,95.61 209.28,94.47 209.28,92.93 207.23,90.88 207.23,81.74 212.44,76.53 218.66,76.53 221.39,73.8 221.39,70.63 222.6,69.42 224.76,69.42 227.93,66.25 235.17,66.25 235.68,66.75 237.71,66.75 238.15,67.2 238.69,67.2 239.32,66.57 239.94,66.57 240.5,67.13 241.33,67.13 242.34,66.12 246.35,66.12 246.86,66.63 247.67,66.63 252.37,71.33 257.65,71.33 258.03,70.95 271.04,70.95 274.38,67.61 274.38,61.58 278.23,57.74 295.24,57.74 296.01,58.5 296.01,65.37 v2(296.93,66.29) ; v2(302.86,83.9) 303.12,83.65 303.12,78.18 302.86,77.93 302.86,72.72 301.85,71.71 301.85,70.06 299.31,67.52 299.31,60.15 v2(299.82,59.64)
  IN10 w0.091: v2(26.13,44.02) 26.73,43.42 26.73,42.72 26.13,42.12 26.13,38.02 26.78,37.37 26.78,32.34 27.27,31.84 27.27,25.99 26.53,25.24 26.53,18.89 25.62,17.99 25.62,14.3 26.13,13.8 26.13,7.37 29.74,3.76 41.37,3.76 41.89,4.28 47.41,4.28 50.04,6.91 52.2,6.91 53.15,7.86 60.01,7.86 61.06,6.81 62.05,6.81 v2(64.23,4.63) ; v2(296.93,66.29) 297.66,65.56 297.66,63.96 298.16,63.45 298.16,61.29 v2(299.82,59.64) ; v2(62.33,34.37) 67.44,34.37 69.21,36.15 69.21,41.91 67.56,43.56 67.56,46.23 70.33,48.99 70.33,63.09 80.42,73.19 80.42,74.95 81.38,75.9 v2(81.38,76.41) 81.38,80.72 83.03,82.38 83.03,89.36 87.85,94.19 87.85,100.03 97.5,109.68 100.17,109.68 109.82,119.33 109.82,129.49 113.63,133.3 113.63,173.82 119.98,180.17 125.95,180.17 128.24,182.45 145.09,182.45 147.29,184.65 147.29,190.14 155.47,198.33 158.9,198.33 160.25,199.68 166.04,199.68 166.59,200.23 174.14,200.23 v2(175.79,198.58) 176.22,198.15 177.34,198.15 177.51,198.33 181.53,198.33 181.91,198.71 182.67,198.71 182.77,198.61 182.77,197.87 183.08,197.56 183.89,197.56 184.08,197.75 184.08,199.07 185.11,200.1 198.85,200.1 199.07,199.89 206.25,199.89 206.54,200.17 209.58,200.17 219.55,190.2 237.71,190.2 239.11,188.8 258.21,188.8 259.6,190.2 262.1,190.2 262.99,189.31 271.37,189.31 272.89,187.79 281.65,187.79 283.2,186.24 285.1,186.24 297.53,173.82 299.82,173.82 v2(300.58,174.58)
  BOTTOM w0.089: v1(35.23,50.88) 35.23,51.21 35.27,51.26 U5.D7
  BOTTOM w0.097: v2(217.01,106.38) 216.67,106.38 216.62,106.43 PR3583.1 ; PR1312.1 v2(175.79,198.58) ; v2(64.23,4.63) 64.21,4.65 R2342.2
EC_I2C_DATA3_R: length 7.5
  TOP w0.076: 68.48,7.62 68.85,7.62 U19.B2
  TOP w0.097: 68.48,7.62 68.43,7.57 68.42,7.57 v1(67.79,6.94)
  BOTTOM w0.089: 67.28,5.54 67.28,6.18 67.79,6.68 v1(67.79,6.94)
  BOTTOM w0.097: R2342.1 63.72,5.79 65.51,5.79 66.03,5.27 67.01,5.27 67.28,5.54
EC_I2C_DATA5: length 274.9
  TOP w0.089: R244.2 v1(34.26,54.94)
  TOP w0.097: v2(264.89,30.05) 265.02,29.92 265.2,29.92 R318.1
  IN05 w0.091: v2(117.82,33.73) 116.54,35.01 111.99,35.01 111.34,34.37 100.24,34.37 95.92,38.69 95.92,39.4 95.04,40.29 87.55,40.29 85.82,38.56 70.97,38.56 67.67,41.86 61.69,41.86 59.4,39.58 58.52,39.58 56.86,41.23 56.86,43.57 54.96,45.47 54.96,46.8 52.35,49.41 49.43,49.41 45.25,53.59 41,53.59 40.79,53.8 39.57,53.8 37.79,55.58 34.89,55.58 v1(34.26,54.94)
  IN08 w0.091: v2(117.82,33.73) 117.23,34.33 117.23,36.62 118.85,38.25 118.85,40.5 122.47,44.12 167.39,44.12 169.89,41.61 177.77,41.61 179.65,39.73 202.35,39.73 205.07,42.45 211.48,42.45 215.18,38.75 256.95,38.75 260.57,42.37 262.95,42.37 264.39,40.93 264.39,35.18 265.33,34.24 265.33,30.49 v2(264.89,30.05)
  BOTTOM w0.076: U5.J6 34.52,54.17 34.52,54.68 v1(34.26,54.94)
EC_INT_N: length 254.7
  IN03 w0.091: v2(40.2,38.69) 40.2,38.43 40.48,38.15 40.48,34.5 42.77,32.21 56.99,32.21 57.63,31.58 66.77,31.58 68.01,30.34 70.67,30.34 72.99,28.02 76.68,28.02 77.57,27.13 82.01,27.13 82.9,28.02 97.5,28.02 99.98,30.5 109.19,30.5 113.51,34.82 114.72,34.82 115.16,35.26 116.81,35.26 121.23,39.68 121.23,41.96 122.59,43.32 130.09,43.32 v2(133.32,40.08)
  IN08 w0.091: v2(40.2,38.69) 40.96,39.45 41.37,39.45 43.78,41.86 43.78,44.91 42.54,46.15 42.54,49.39 v2(43.28,50.12)
  IN10 w0.091: v3(229.58,66.75) 227.43,68.91 222.85,68.91 216.63,62.69 212.82,62.69 209.65,65.87 209.65,72.63 209.01,73.27 204.66,73.27 203.85,72.46 203.85,70.11 199.87,66.12 179.42,66.12 178.66,65.36 178.66,59.73 177.39,58.46 162.11,58.46 159.1,55.45 146.59,55.45 133.32,42.19 v2(133.32,40.08)
  BOTTOM w0.097: R566.2 43.86,50.78 43.86,50.7 v2(43.28,50.12) R370.1 ; U2.R41 228.7,66.25 229.08,66.63 229.46,66.63 v3(229.58,66.75)
EC_INT_N_R: length 4.6
  BOTTOM w0.076: U5.E12 38.03,51.66 38.58,51.66
  BOTTOM w0.089: 38.68,51.66 39.97,50.37
  BOTTOM w0.097: 39.97,50.37 40.22,50.12 v1(40.48,50.12) R370.2 ; 38.58,51.66 38.68,51.66
EC_KSO16: length 5
  TOP w0.089: R578.2 40.99,54.26 v1(40.84,54.11) 40.68,54.11 v1(40.1,54.69) 39.97,54.69 39.62,54.33 R267.2
  BOTTOM w0.097: v1(40.1,54.69) 39.82,54.41 U5.K13
EC_KSO17: length 6.7
  TOP w0.089: v1(39.85,56.59) 39.85,56.54 v1(40.23,56.16) 40.43,55.96 R579.2 R324.2
  IN10 w0.089: v1(37.36,54.31) 39.21,56.16 v1(40.23,56.16)
  BOTTOM w0.089: v1(37.36,54.31) 37.31,54.31 36.91,53.91 U5.J10
EC_ON: length 374.7
  TOP w0.097: PR1415.1 51.15,9.6 50.64,9.1 49.88,9.1 v2(49.12,9.86) 48.81,10.16 PR313.1 ; v2(22.19,46.18) 21.43,46.94 v1(21.05,46.94) R152.1
  IN05 w0.091: v2(56.13,22.48) 56.31,22.66 62.8,22.66 63.51,23.37 67.49,23.37 68.04,22.81 72.49,22.81 73.37,23.7 77.06,23.7 79.23,25.88 82.39,25.88 83.03,25.24 96,25.24 97.13,26.38 111.23,26.38 114.41,29.55 119.43,29.55 120.33,30.46 120.33,42.69 121.67,44.02 190.6,44.02 193.14,46.56 212.51,46.56 212.89,46.18 214.54,46.18 215.44,45.28 224.62,45.28 225.34,44.56 228.99,44.56 229.54,44.01 233.86,44.01 236.14,41.73 249.77,41.73 252.57,44.53 252.57,46.18 252.95,46.56 254.22,46.56 256,48.34 256,49.61 257.55,51.16 257.55,55.63 261.76,59.85 265.07,59.85 265.31,59.6 266.28,59.6 266.8,59.08 v2(266.8,52.4) ; v2(36.29,61.17) 35.66,61.17 34.64,62.18 31.72,62.18 31.08,61.55 v2(31.08,60.91)
  IN08 w0.091: v2(56.13,22.48) 54.99,21.34 54.99,20.83 53.93,19.76 51.15,19.76 50.13,18.75 50.13,10.87 v2(49.12,9.86)
  IN10 w0.091: v2(49.12,9.86) 48.48,9.22 47.34,9.22 43.36,5.24 28.97,5.24 26.89,7.32 26.89,18.37 29.31,20.78 29.31,37.29 27.53,39.07 27.15,39.07 26.85,39.37 26.85,41.56 27.27,41.99 27.27,44.53 26.44,45.37 22.5,45.37 22.19,45.67 v2(22.19,46.18) 23.84,47.83 26.38,47.83 26.64,48.09 26.64,53.17 28.04,54.56 28.04,58.5 30.45,60.91 v2(31.08,60.91)
  BOTTOM w0.097: PR505.1 266.64,52.51 266.74,52.4 v2(266.8,52.4) ; R256.2 R251.2 35.71,60.33 36.29,60.91 v2(36.29,61.17)
EC_ON_R: length 2.7
  BOTTOM w0.089: R256.1 35.4,57.71 35.27,57.59
  BOTTOM w0.097: U5.N7 35.27,57.59
EC_PECI: length 8.1
  TOP w0.097: R252.1 28.42,45.93 v1(28.67,46.18)
  BOTTOM w0.097: C245.2 28.29,45.8 v1(28.67,46.18) 28.72,46.13 v1(29.25,46.13) 29.25,46.89 29.53,47.17 30.12,47.17 31.08,48.14 31.08,49.23 32.27,50.41 U5.B1
EC_PUMP_FG: length 301.2
  TOP w0.089: 29.81,47.76 29.81,47.22 30.22,46.82 R2347.1 30.99,47.3 v1(30.99,47.37)
  TOP w0.097: 29.81,47.76 29.3,48.27 R526.1
  IN03 w0.089: 41.5,48.42 41.5,49.05 41.32,49.23 39.85,49.23 38.96,50.12 37.81,50.12 36.16,48.47 32.19,48.47 31.97,48.25 31.97,47.7 31.65,47.37 v1(30.99,47.37)
  IN03 w0.091: v2(74.17,42.29) 74.35,42.29 75.7,40.94 82.77,40.94 83.31,41.47 105.9,41.47 106.91,40.47 108.36,40.47 118.78,50.88 152.01,50.88 159.51,43.39 209.65,43.39 214.39,38.65 256.72,38.65 259.81,41.74 262.73,41.74 265.89,38.58 265.89,25.83 265.4,25.34 265.4,24.38 265.94,23.85 265.94,18.29 266.49,17.73 273.46,17.73 274.52,18.8 281.59,18.8 v2(284.77,21.97) ; v2(55.24,48.26) 55.04,48.46 46.7,48.46 46.15,47.91 42,47.91 41.5,48.42
  IN05 w0.091: v2(55.24,48.26) 55.75,48.77 56.26,48.77 56.62,48.41 56.62,47.02 58.21,45.42 66.01,45.42 67.67,43.76 69.19,43.76 69.95,43 73.46,43 v2(74.17,42.29)
  BOTTOM w0.097: v2(284.77,21.97) JPUMP1.4
EC_PUMP_PWM: length 304.9
  IN03 w0.091: v2(64.13,47.75) 64.13,47.67 68.77,43.04 71.02,43.04 71.49,43.51 76.8,43.51 78.33,41.99 82.39,41.99 83.27,42.87 90.78,42.87 91.41,42.24 105.76,42.24 106.95,43.44 107.97,43.44 109.95,45.42 112.38,45.42 118.5,51.54 152.44,51.54 159.7,44.28 210.01,44.28 214.99,39.3 256.12,39.3 259.44,42.62 263.1,42.62 266.65,39.08 266.65,25.61 266.83,25.43 266.83,20.95 266.65,20.78 266.65,19.74 266.95,19.43 268.91,19.43 269.24,19.76 281.76,19.76 284.48,22.48 285.51,22.48 v2(286.02,21.97)
  IN05 w0.091: v2(35.4,62.18) 35.91,62.69 38.58,62.69 43.15,58.12 45.05,58.12 46.18,59.24 53.33,59.24 55.98,56.59 55.98,53.42 61.57,47.83 64.06,47.83 v2(64.13,47.75)
  BOTTOM w0.097: U5.N5 34.27,57.85 33.73,58.39 33.73,61.02 34.26,61.55 34.77,61.55 v2(35.4,62.18) ; JPUMP1.3 v2(286.02,21.97)
EC_RST_N: length 3.6
  BOTTOM w0.076: U5.M4 33.77,55.42 34.03,55.67 34.03,56.21
  BOTTOM w0.097: 34.03,56.21 34.03,57.83 33.31,58.55 R237.2
EC_SCI_N: length 253.2
  TOP w0.097: R173.2 v3(224.12,66.25)
  IN03 w0.091: v2(134.33,38.81) 133.57,39.58 133.06,39.58 129.76,42.88 122.77,42.88 121.45,41.56 121.45,39.59 116.83,34.97 115.45,34.97 114.94,34.46 113.46,34.46 109.28,30.28 100.11,30.28 97.6,27.77 83.03,27.77 82.14,26.88 77.44,26.88 76.55,27.77 72.87,27.77 70.51,30.12 67.91,30.12 66.72,31.32 57.5,31.32 56.86,31.96 42.39,31.96 40.23,34.12 40.23,38.05 39.08,39.2 35.91,39.2 35.45,38.74 35.45,38.01 35.12,37.67 34.77,37.67 34.56,37.88 34.56,38.39 34.34,38.61 32.31,38.61 v2(31.72,39.2)
  IN10 w0.089: 30.35,46.69 30.35,48.01 30.58,48.23 30.58,55.71 31.08,56.21 31.08,58.12 30.58,58.63
  IN10 w0.091: v3(224.12,66.25) 222.09,66.25 220.55,64.71 220.33,64.71 217.3,61.67 204.18,61.67 203.63,62.23 183.66,62.23 182.98,61.55 182.98,59.46 180.26,56.75 168.33,56.75 166.28,54.69 160.5,54.69 159.86,54.05 147.16,54.05 134.84,41.73 134.84,39.45 134.33,38.94 v2(134.33,38.81) ; v2(30.37,60.02) 30.45,59.95 30.45,58.75 30.58,58.63 ; v2(31.72,39.2) 31.08,39.83 30.45,39.83 30.1,40.18 30.1,41.4 30.35,41.66 30.35,46.69
  BOTTOM w0.076: U2.M44 226.8,67.78 225.77,66.75 225.52,66.75
  BOTTOM w0.097: v3(224.12,66.25) 224.12,66.35 224.53,66.75 225.52,66.75 ; D4.2 v2(30.37,60.02)
EC_SCI_N_R: length 7.1
  BOTTOM w0.089: 32.48,58.63 32.48,58.54 32.9,58.12 33.24,58.12 33.5,57.86
  BOTTOM w0.097: U5.N4 33.77,57.59 33.5,57.86 ; v1(30.96,61.67) 31.81,60.82 D4.1 32.48,59.36 32.48,58.63
EC_SCK: length 9.1
  BOTTOM w0.076: U5.B5 34.52,50.16 34.52,49.61
  BOTTOM w0.097: RP4.5 34.04,41.98 34.2,42.14 v1(34.2,43.18) 34.33,43.31 34.33,45.29 34.16,45.47 34.16,47.3 34.52,47.66 34.52,49.61
