# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+2.5V_MEM: length 8.5
  BOTTOM w0.254: PR429.1 PR438.2 209.8,111.03 210,110.82 210,108.13 208.63,106.76 v2(208.63,105.36)
  vias: v1(206.22,92.28) v2(202.66,88.34) v2(202.66,87.07) v2(203.3,75.01) v2(203.3,73.74)
+3V: length 572.8
  TOP w0.254: R254.1 39.08,59.13 v2(38.7,59.52) 38.2,59.01 R253.1 ; v2(232.63,56.85) 232.99,56.49 R171.2 233.06,56.06 233.9,56.06 234.18,56.34 234.18,57.76 234.51,58.09 237.46,58.09 R787.1 ; R2327.2 85.64,72.93 84.04,71.33 84.04,67.77 83.66,67.39 79.47,67.39 v2(78.84,68.02) ; v2(284.96,173.31) R2185.1 285.64,172.88 285.85,172.67 289.53,172.67 290.62,173.76 R2184.1 ; R2312.2 11.58,145.44 12.16,144.86 R2313.2 ; R113.2 231.82,61.12 231.11,60.4 228.64,60.4 R856.2 227.54,59.3 227.18,59.3 226.89,59.01 222.47,59.01 222.27,59.21 R185.2 ; v2(113.38,68.91) 113.82,68.47 PR1413.2 ; JDIMM2.256 196.65,88.56 196.44,88.78 196.44,90.21 v2(196.98,90.76) ; JDIMM2.255 196.4,80.69 196.56,80.85 197.38,80.85 v2(198.27,81.74) ; R2187.1 299.31,76.79 v2(298.42,77.68) ; JDIMM4.256 196.85,73.2 197.2,72.85 v2(197.96,72.85) 197.85,72.96 JDIMM4.260 ; R49.2 106.8,96.12 v2(107.03,96.35) ; JDIMM4.255 v2(196.6,64.47) ; R179.2 239.87,50.5 239.49,50.12 v3(239.36,50.12) ; v2(305.02,77.17) 305.02,78.01 R2188.1
  TOP w0.305: R103.2 R108.1 R182.1 223.31,69.37 222.52,68.58 R173.1 221.86,66.25 221.2,65.59 221.2,62.06 v2(220.82,61.67)
  TOP w0.356: v2(27.02,58.63) 27.65,57.99 31.85,57.99 32.35,57.48 R233.1 ; v2(231.87,45.8) R164.2 R304.1 ; R2327.2 R2328.2 ; PR624.1 80.11,46.36 v2(80.11,46.05) ; R112.2 230.09,46.49 v2(230.09,45.8) ; v2(220.82,61.67) 220.19,61.04 220.19,60.18 220.72,59.64 R185.2
  TOP w0.381: R2347.2 31.82,46.82 v1(32.03,46.61)
  TOP w0.457: v2(246.6,47.45) 246.65,47.4 C179.2 ; v3(246.25,55.55) 246.3,55.6 R181.1 ; v2(279.37,29.8) 279.5,29.67 L12.1 ; R304.1 230.09,46.49 ; 220.72,59.64 220.72,58.5 221.51,57.71 221.51,56.39 v2(221.71,56.19) 222.07,55.83 R106.2 R109.2
  TOP w0.508: R169.1 225.85,46.49 v2(226.54,45.8) 226.54,45.42 226.92,45.04 231.36,45.04 231.87,45.55 v2(231.87,45.8) ; v2(278.61,76.53) 279.37,75.77 v1(279.37,72.98) 279.37,72.09 279.56,71.9 C553.1 279.88,70.37 R461.1 ; R2312.2 v2(10.76,146)
  IN03 w0.508: v2(226.54,45.8) 226.03,45.29 219.42,45.29 218.54,46.18 v2(218.54,46.56) ; v2(150.76,199.6) 150.76,198.09 v2(151.8,197.04) 152.43,196.42 158.08,196.42 159.1,197.44 168.5,197.44 171.16,194.77 172.05,194.77
  IN03 w1.016: 36.29,88.34 36.29,102.82 21.81,117.3 18.89,117.3 11.78,124.41 11.78,125.43 12.67,126.32 12.67,141.18 9.62,144.22 9.62,145.11 10.51,146 v2(10.76,146) 12.16,146 14.32,148.16 15.97,148.16
  IN05 w0.508: v2(150.76,199.6) 149.1,197.95 148.05,197.95 142.84,192.74 135.86,192.74 131.92,196.68 131.92,199.98 130.14,201.76 121.89,201.76 117.7,197.56 117.7,196.68 116.55,195.53 116.55,192.48 v2(116.3,192.23) ; v2(277.97,76.53) 277.21,75.77 275.56,75.77 275.18,75.39 271.75,75.39 267.68,71.33 254.6,71.33 253.84,70.56 253.84,68.53 255.37,67.01 v2(255.37,66.75)
  IN08 w0.508: v2(221.71,56.19) 220.95,55.43 220.95,49.23 221.14,49.03 221.14,47.64 220.7,47.2 219.17,47.2 v2(218.54,46.56) ; v2(301.5,38.86) 298.83,38.86 298.45,39.24 290.19,39.24 289.99,39.04 289.13,39.04 288.92,39.24 286.64,39.24 286.13,38.73 286.13,37.97 284.61,36.45 284.61,30.35 283.59,29.34 282.57,29.34 282.11,29.8 v2(279.37,29.8) ; v2(266.1,24.84) 266.16,24.84 268.19,26.88 273.4,26.88 274.03,26.24 276.7,26.24 279.37,28.91 v2(279.37,29.8) ; v2(279.37,29.8) 279.37,31.58 279.75,31.96 279.75,34.12 v2(280.51,34.88)
  IN10 w0.508: v2(310.23,113.74) 310.23,109.05 310.86,108.41 310.86,96.73 310.48,96.35 310.48,80.34 v2(305.91,75.77)
  BOTTOM w0.254: R2339.1 86.2,80.01 86.2,81.36 86.84,81.99 v2(87.47,81.99) ; R162.1 192.83,54.69 Q1.2 ; v3(249.02,48.59) 249.9,47.7 249.9,46.69 250.11,46.49 R99.2 R102.2 ; Q2.5 218.41,44.15 218.59,43.97 R165.1 ; R61.2 47.16,43.18 46.83,43.51 45.56,43.51 v2(45.43,43.39) 45.04,43.78 U26.5 ; v2(44.27,49.23) 44.16,49.33 R566.1 ; v2(196.98,90.76) 197.58,90.76 198.07,90.27 JDIMM1.255 ; R337.2 26.82,47.83 25.75,47.83 v2(25.24,47.32) ; Q1.5 195.22,54.69 R161.1 ; 151.15,199.19 PU1303.B4 ; v2(199.1,64.47) 199.55,64.91 JDIMM3.260 ; R166.1 217.19,46.82 218.28,46.82 v2(218.54,46.56) ; v2(246.6,47.45) 246.69,47.37 U4.5 ; JDIMM3.255 198.3,73.19 v2(197.96,72.85)
  BOTTOM w0.305: v2(218.54,46.56) 218.41,46.43 Q2.2 Q2.5 ; PU1303.B1 v2(151.8,197.04) ; R827.2 50.41,46.26 v2(50.9,45.77)
  BOTTOM w0.356: PR1240.1 v2(116.3,192.23) ; R255.2 v2(27.02,58.63) ; v2(150.76,199.6) 150.35,199.2 PC1323.1 150.73,198.77 151.15,199.19 ; TP19.1 219.55,57.61 v2(219.42,57.48) ; v2(185.26,198.48) 185.11,198.33 PR1315.2 ; v2(56.56,39.4) 56.23,39.07 R830.1 ; R242.2 R241.2 v2(40.86,43.39) ; R170.2 229.41,46.49 v2(230.09,45.8) ; R548.1 R549.1 R186.2 221.2,59.39 220.95,59.13 220.95,56.95 v2(221.71,56.19) 222.07,55.83 R106.2 R109.2
  BOTTOM w0.457: R574.1 279.19,29.62 v2(279.37,29.8) ; R219.1 252.44,66.47 253.37,67.39 254.86,67.39 255.37,66.88 v2(255.37,66.75) ; R162.1 192.5,56.7 v2(191.97,57.23) ; v2(196.95,53.42) 196.13,54.23 R161.1 ; C347.1 266.22,27.25 266.36,27.38 C348.2 266.36,28.27 266.29,28.35 L11.1
  BOTTOM w0.508: C347.1 266.22,24.97 v2(266.1,24.84) ; v2(280.51,34.88) 280.54,34.85 R285.2 ; v2(310.23,113.74) 307.69,113.74 306.55,114.89 306.55,120.09 308.32,121.87 308.32,161.12 302.61,166.83 287.5,166.83 284.96,169.37 v2(284.96,173.31) ; v2(298.42,77.68) 298.42,77.3 298.67,77.04 302.36,77.04 302.86,76.53 304.77,76.53 305.02,76.79 v2(305.02,77.17) 305.28,77.17 305.91,76.53 v2(305.91,75.77)
  vias: v2(16.99,149.3) v2(16.99,148.54) v2(36.54,87.45) v2(36.54,86.69) v2(37.19,88.09) v2(37.18,87.46) v2(37.18,86.7) v2(37.76,87.71) v2(57.88,71.58) v2(58.26,72.22) v2(63.47,11.13) v2(63.47,10.49) v2(64.1,40.59) v2(64.48,39.7) v2(64.87,40.34) v2(65.25,39.7) v2(65.25,36.53) v2(65.63,40.34) v2(65.75,38.94) v2(65.75,38.18) v2(66.01,39.7) v2(66.01,36.53) v2(66.39,40.34) v2(66.52,38.94) v2(66.52,38.18) v2(66.77,39.7) v2(66.77,36.53) v2(67.15,41.1) v2(67.15,40.34) v2(67.28,38.94) v2(67.28,38.18) v2(67.53,36.53) v2(69.18,80.34) v2(69.95,80.34) v2(72.99,83.52) v2(73.63,83.52) v2(87.47,81.23) v2(89.88,63.07) v2(90.31,63.67) v2(90.39,62.67) v2(90.9,63.05) v2(90.98,64.32) v2(90.95,63.69) v2(91.62,64.32) v2(91.61,63.69) v2(91.59,63.05) v2(192.45,195.15) v2(193.08,195.15) v2(195.68,53.42) v2(196.98,84.28) v2(196.98,83.01) v2(196.98,70.95) v2(196.98,69.68) v2(198.22,53.42) v2(199.03,81.74) v2(199.74,81.44) v2(206.22,105.57) v2(206.22,104.93) v2(206.22,104.3) v2(206.22,103.64) v2(206.22,103) v2(277.97,77.17) v2(278.61,77.17) v2(282.92,78.44) v2(282.92,77.3) v2(284.45,78.44) v2(284.45,77.3) v2(293.21,70.18) v2(293.21,69.55) v2(293.85,70.18) v2(293.85,69.55) v2(294.48,70.18) v2(294.48,69.55) v2(301.5,39.75) v2(302.39,39.75) v2(302.39,38.86) v2(302.39,37.85) v2(303.28,39.75) v2(303.28,38.86) v2(303.28,37.85) v2(304.16,39.75) v2(304.16,38.86) v2(304.16,37.85) v3(196.95,92.64)
+3V_1.8V_EC: length 5.8
  TOP w0.305: v1(34.77,53.43) 34.82,53.47 v1(34.82,54.41) 34.54,54.13 C242.2
  TOP w0.356: C242.2 33.88,54.56 33.78,54.66 33.78,55.17 32.56,56.39 R233.2
  BOTTOM w0.254: v1(34.77,53.43) 34.29,53.91 U5.J5
+3V_CAMERA:
  vias: v1(155.8,196.8)
+3V_DP_CON: length 3.7
  TOP w0.254: R410.2 17.62,161.88 16.86,162.64 15.08,162.64
  vias: v1(14.95,150.83)
+3V_DPA_REP: length 39.4
  TOP w0.305: 71.09,93.42 72.92,95.25 73.2,95.25 ; 73.2,95.25 73.58,95.25 v2(74.39,94.44) 74.64,94.69 76.04,94.69 76.8,95.46 77.57,95.46 78.15,96.04 v2(78.15,96.47) ; 73.2,95.25 v2(73.2,97.54)
  BOTTOM w0.254: R396.2 78.15,97.11 v2(78.15,96.47) ; U2015.3 70.28,92.87 70.47,93.06 ; 70.47,93.06 71.47,94.06 72.23,94.06 72.41,94.24 73.53,94.24 74.18,93.59 74.18,92.88 C2715.2 73.88,92.08 73.88,91.14 73.72,90.97 73.72,90.63 73.97,90.38 U2016.9 ; 70.47,93.06 v2(70.47,93.03) ; U2015.6 v2(70.53,91.37) ; U2015.27 v2(65.8,88.37) ; U2015.15 70.31,86.87 70.53,86.65 v2(70.53,86.61) ; v2(74.39,94.44) R387.2 ; R2144.2 66.01,83.14 66.52,82.63 68.88,82.63 R2109.2 R2108.2 ; U2015.33 v2(65.8,91.37) ; U2015.9 v2(70.53,89.87) ; U2015.30 v2(65.8,89.87) ; R395.2 v2(73.2,97.54) ; U2015.12 v2(70.53,88.37) ; U2015.36 v2(65.63,92.87) ; U2015.24 v2(65.8,86.87)
  BOTTOM w0.305: v2(70.53,86.61) 70.53,85.98 71.09,85.42 71.09,83.65 70.63,83.19 R2108.2
  vias: v1(67.02,85.93)
+3V_DPE_REP: length 18
  TOP w0.254: C493.2 76.22,75.14 R2280.2
  TOP w0.305: C527.2 77.24,75.09 v2(77.82,74.5) ; C526.1 73.07,75.09 72.87,74.88 v2(72.87,74.5) ; v2(77.82,69.55) 77.82,70.31 77.36,70.77 R454.1 ; 75.91,67.52 75.91,65.99 76.12,65.79 R518.1 v2(76.93,65.1) ; C493.2 75.48,75.09 75.28,74.88 v2(75.28,74.5)
  BOTTOM w0.254: U2013.32 76.03,74.87 75.66,74.5 v2(75.28,74.5) ; U2013.12 72.53,69.14 72.87,69.47 v2(72.87,69.55) ; U2013.6 75.53,69.3 v2(75.28,69.55) ; v2(72.87,74.5) 72.87,74.7 72.53,75.04 U2013.25 ; U2013.36 78.03,75.09 77.82,74.88 v2(77.82,74.5) ; R518.1 v2(76.93,65.1) ; U2013.1 78.03,69.14 77.82,69.35 v2(77.82,69.55)
  BOTTOM w0.356: 71.01,78.9 R510.2
  vias: v1(71.09,76.41) v2(70.2,79.07) v2(70.2,78.18) v2(70.2,77.3)
+3V_DPF_REP: length 14.9
  BOTTOM w0.254: R590.1 v2(65.88,54.82) ; U2014.1 68.38,58.98 68.04,59.31 v2(68.04,59.39) ; U2014.32 v2(66.38,64.35) ; v2(68.8,68.15) 68.8,68.25 68.45,68.61 R2281.2 ; v2(63.21,64.34) 63.21,64.6 62.88,64.93 U2014.25 62.88,65.57 62.58,65.87 60.67,65.87 60.42,66.12 60.42,67.26 61.77,68.61 R439.2 ; U2014.36 68.38,64.93 68.04,64.6 v2(68.04,64.34) ; v2(63.21,59.39) 63.21,59.31 62.88,58.98 U2014.12 ; R591.1 v2(68.55,54.82) ; U2014.6 v2(65.88,59.38)
  vias: v1(61.82,64.21)
+3V_EDP: length 12.7
  BOTTOM w0.203: v2(205.71,195.33) 205.2,194.82 205.2,194.39 204.95,194.14 201.87,194.14 200.7,192.97 200.7,192.43 200.45,192.18 v1(199.61,192.18) 198.98,192.18 198.67,192.48 198.67,193.25 198.52,193.4 198.52,194.06
  BOTTOM w0.254: 198.6,194.14 198.52,194.06
  BOTTOM w0.356: PR1411.2 206.52,194.72 205.91,195.33 v2(205.71,195.33) 205.63,195.33 205.45,195.51 R784.2
+3V_EDP_CONN:
  vias: v1(198.06,197.72)
+3V_GPU: length 885.5
  TOP w0.254: 244.32,117.3 245.46,117.3 245.59,117.17 245.59,116.84 245.84,116.59 246.07,116.59 246.4,116.26 v3(246.65,116.26) 248.53,116.26 249.27,115.52 249.27,114.25 249.66,113.86 250.79,113.86 250.92,114 251.68,114 253.08,112.6 253.08,108.41 251.17,106.51 248.63,106.51 247.36,105.24 247.36,103.84 246.86,103.33 246.86,102.44 247.24,102.06 247.24,100.54 246.22,99.52 243.68,99.52 243.43,99.27 242.28,99.27 241.78,98.76 241.78,92.54 241.01,91.77 241.01,84.92 239.62,83.52 221.84,83.52 221.46,83.14 v2(221.46,77.93) ; 244.32,117.3 244.44,117.17 244.44,116.79 244.44,116.79 244.44,116.78 244.17,116.51 244.16,116.51 243.94,116.28 243.94,115.41 243.69,115.16 241.63,115.16 241.14,115.65 R2298.2 ; 244.32,117.3 244.19,117.42 244.02,117.42 R2299.2 ; v2(217.39,120.73) 217.77,120.35 Q80.2 ; v2(250.82,108.03) 250.82,108.03 250.82,110.29 248.33,112.78 247.19,112.78 v3(247.06,112.65) ; v2(220.06,120.35) Q80.5 219.04,120.35 218.92,120.22 218.92,119.7 219.17,119.44 220.27,119.44 220.54,119.71 223.11,119.71 223.62,120.22 v2(224,120.22) 224,119.84 225.22,118.62 228.77,118.62 229.56,117.83 233.5,117.83 233.52,117.86 R2295.2 R2294.2 ; U2029.5 207.47,166.16 C2696.1 207.44,167.8 207.74,168.1 208.88,168.1 v2(209.26,167.72)
  TOP w0.305: v2(300.58,67.14) 300.58,67.85 R2244.1 300.53,69.35 299.69,70.18 297.64,70.18 v2(296.8,69.34) ; R1006.2 v2(290.93,70.44) ; R798.1 v2(304.59,60.4) ; v2(299.18,81.87) 299.94,81.11 R2270.2
  TOP w0.356: v2(84.93,101.68) 84.93,100.67 84.04,99.77 79.85,99.77 v1(79.34,99.27) 76.3,96.22 75.15,96.22 74.77,96.6 74.77,96.98 73.12,98.63 71.6,98.63 69.56,96.6 v1(67.53,96.6) 61.06,96.6 60.8,96.85 59.66,96.85 59.47,97.05 58.39,97.05 57.19,97.31 55.86,98.64 55.86,99 54.83,100.03 54.07,100.03 53.44,100.66 50.9,100.66 49.88,99.65 49.88,95.96 v2(48.86,94.95) ; U2027.5 202.9,198.44 202.66,198.2 202.66,197.56 C2694.1 203.22,196.6 202.91,196.29 200.91,196.29 v2(200.4,195.79) ; PR720.1 v2(219.93,166.07) ; R797.1 250.16,108.41 250.54,108.03 v2(250.82,108.03)
  TOP w0.381: v2(211.23,197.33) 211.71,196.85 C2695.1 211.07,195.58 210.72,195.22 210.72,194.79 210.02,194.1 U2028.5
  TOP w0.508: v2(273.91,74.12) 273.4,74.12 273.02,74.5 273.02,77.8 273.65,78.44 280.64,78.44 282.67,76.41 285.72,76.41 286.73,77.42 289.66,77.42 290.67,78.44 290.67,80.22 291.05,80.6 298.62,80.6 299.26,79.96 v2(299.43,79.96) ; v2(307.69,196.29) 307.69,195.41 305.4,193.12 305.4,193.12 301.67,189.39 PR3525.1 302.23,185.37 v2(302.36,185.25)
  IN03 w0.305: v2(200.4,195.79) 200.4,195.94 200.88,196.42 210.32,196.42 v2(211.23,197.33)
  IN03 w0.508: v2(304.01,104.73) 303.56,104.28 303.3,104.28 301.47,102.44 301.47,101.17 303.63,99.01 303.63,96.35 303.24,95.96 303.24,94.31 v2(301.21,92.28)
  IN05 w0.254: v3(246.65,116.26) 246.65,115.78 247.24,115.19 247.24,112.83 v3(247.06,112.65)
  IN05 w0.305: v2(296.8,69.34) 295.07,71.07 291.56,71.07 v2(290.93,70.44)
  IN08 w0.305: v2(299.43,79.96) 299.18,79.96 298.42,79.2 297.15,79.2 296.16,78.21 296.16,74.1 297.28,72.98 297.28,69.82 v2(296.8,69.34)
  IN08 w0.356: v2(5.68,122.89) 6.22,123.42 8.2,123.42 v2(9.37,122.25) ; v2(84.93,101.68) 87.6,101.68 97.12,111.2 100.81,111.2 102.08,112.47 102.08,114.51 108.43,120.86 108.43,126.06 112.11,129.75 v2(114.9,129.75) ; 210.79,168.35 211.68,168.35 212.82,167.21 218.15,167.21 219.3,166.07 v2(219.93,166.07) ; 210.79,168.35 210.03,167.59 209.39,167.59 v2(209.26,167.72) 208.63,167.08 208.63,164.29 211.44,161.48 211.44,147.67 208.25,144.48 v2(208.25,130.38) 208.88,129.75 208.88,128.1 207.87,127.08 207.87,124.97 211.09,121.75 216.76,121.75 217.39,121.11 v2(217.39,120.73) 219.68,120.73 v2(220.06,120.35) ; 210.79,168.35 210.92,168.48 210.92,172.16 212.95,174.2 212.95,195.61 v2(211.23,197.33) ; 216.71,105.18 216.58,105.31 v2(216,105.31) ; 216.71,105.18 217.24,105.18 217.57,105.51 217.57,106.96 217.12,107.41 v2(217.12,111.13) ; 216.71,105.18 216.71,104.4 216.28,103.97 215.61,103.97 214.73,104.85 213.96,104.85 211.21,102.1 211.21,94.58 v2(212.24,93.55) 211.9,93.22 211.9,79.99 214.47,77.42 220.95,77.42 v2(221.46,77.93) 221.96,77.42 228.57,77.42 230.22,75.77 231.62,75.77 232.38,75.01 232.38,73.87 233.65,72.6 234.92,72.6 235.43,73.1 236.19,73.1 237.84,71.45 240.89,71.45 241.27,71.07 241.27,70.44 242.03,69.68 244.32,69.68 245.08,68.91 246.73,68.91 250.69,72.88 251.45,72.88 253.59,75.01 258.54,75.01 259.05,74.5 259.05,72.22 259.43,71.83 272.26,71.83 v2(273.91,73.49) ; v2(8.73,119.21) 7.72,120.22 v2(4.92,120.22) ; v2(300.58,67.14) 300.32,66.88 300.32,64.67 v2(304.59,60.4)
  IN08 w0.508: v2(299.43,79.96) 299.94,80.47 299.94,81.36 299.43,81.87 v2(299.18,81.87) ; v2(304.01,104.73) 304.13,104.73 305.15,105.74 305.15,108.41 304.9,108.66 304.9,158.96 302.86,160.99 302.86,184.74 v2(302.36,185.25)
  IN10 w0.356: v2(114.9,129.75) 115.92,128.73 129.64,128.73 v2(130.52,129.62) ; v2(8.73,119.21) 9.37,119.84 v2(9.37,122.25) 12.03,122.25 15.97,118.32 20.92,118.32 38.07,101.17 38.07,99.75 39.47,98.35 39.47,94.57 39.85,94.19 48.1,94.19 v2(48.86,94.95)
  BOTTOM w0.254: PR3428.1 212.36,94.16 212.36,93.68 v2(212.24,93.55) ; v2(8.73,119.21) 8.22,119.21 7.59,119.84 Q41.2 ; v2(216,105.31) 215.69,105.31 215.36,104.98 PR3449.1 ; R2146.1 5.1,120.78 4.92,120.6 v2(4.92,120.22) ; PR3424.1 303.12,103.84 v2(304.01,104.73) ; PR703.1 v2(301.21,92.28) ; Q41.5 7.59,122.46 7.16,122.89 v2(5.68,122.89)
  BOTTOM w0.305: v2(302.36,185.25) 302.23,185.12 301.21,185.12 300.91,184.81 PR801.2
  BOTTOM w0.356: PR712.1 308.65,109.6 307.82,110.44 305.53,110.44 303.63,108.54 303.63,107.9 302.99,107.27 302.99,105.74 v2(304.01,104.73) ; v2(217.12,111.13) 217.12,112.75 217.01,112.86 217.01,116.79 218.43,118.22 223.72,118.22 224,118.49 ; R2145.1 v2(9.37,122.25) ; v2(208.25,130.38) 207.79,129.92 R600.1 207.23,129.8 R1004.1 ; 224,118.49 R2296.2 R2297.2 ; 224,118.49 v2(224,120.22) ; v2(130.52,129.62) 130.4,129.49 130.4,119.08 135.6,113.87 197.33,113.87 199.74,116.28 202.53,116.28 205.71,119.46 207.11,119.46 207.87,118.7 212.19,118.7 213.71,117.17 215.74,117.17 216.12,117.55 216.12,119.56 217.29,120.73 v2(217.39,120.73)
  BOTTOM w0.508: PR22.1 307.68,196.3 v2(307.69,196.29) 307.69,195.79 306.18,194.28 PR28.2 ; v2(301.21,92.28) 301.21,91.77 300.7,91.27 300.7,83.39 v2(299.18,81.87)
+3V_GPU_EN_N: length 3.4
  TOP w0.097: Q94.6 303.75,84.03 v1(303.88,84.03) 303.93,83.98 R2260.2 303.8,82.76 Q94.5
+3V_HDMI_REP: length 17.1
  TOP w0.254: v2(80.49,77.17) 80.23,77.17 79.22,78.18 R2131.2 79.22,79.84 79.98,80.6 79.98,81.23
  TOP w0.305: C2168.2 83.74,87.91 84.04,88.22 v2(84.07,88.22) ; C2722.2 79.78,84.08 v2(79.34,83.65) ; v2(79.34,86.82) 79.72,87.2 C2721.2 ; C2166.2 83.74,85.73 v2(84.04,85.42) ; v2(79.34,88.47) 79.72,88.85 C2170.2
  BOTTOM w0.254: R2143.2 79.29,77.85 79.98,77.17 v2(80.49,77.17) ; v2(79.34,82.12) 79.6,82.12 79.77,82.3 U2019.24 ; v2(84.17,82.38) 84.12,82.32 83.37,82.32 U2019.15 ; U2019.9 83.92,85.3 v2(84.04,85.42) ; v2(79.34,88.47) 79.47,88.47 79.65,88.3 U2019.36 ; v2(84.07,88.22) 83.99,88.3 U2019.3 ; U2019.27 79.62,83.8 79.47,83.65 v2(79.34,83.65) ; U2019.33 79.37,86.8 v2(79.34,86.82)
  vias: v1(85.31,84.41)
+3V_SATA: length 19.8
  TOP w0.254: v2(281.65,67.9) 281.29,67.53 U14.20
  TOP w0.305: C556.2 v2(281.65,67.9) ; U14.10 283.29,62.2 283.69,61.8 284.07,61.8
  TOP w0.457: C557.2 C555.2 284.96,61.42 284.58,61.8 284.07,61.8 ; R462.1 R465.2 281.4,59.9 v2(281.91,59.39) ; R470.2 285.21,70.18 v2(285.08,70.31) 284.19,71.2 v1(283.81,71.2) 283.43,71.2 282.54,70.31 R469.2 ; R466.2 v2(284.07,59.39)
  TOP w0.508: R461.2 C554.1 C556.2 ; v2(285.72,59.39) 286.35,59.39 286.73,59.77 286.73,60.53 286.28,60.99 C557.2
  BOTTOM w0.356: v2(281.65,67.9) 281.83,68.08 R468.2 ; R467.2 285.46,69.93 v2(285.08,70.31)
+3V_SSD1: length 10.7
  BOTTOM w0.254: R480.2 96.11,49.99 96.36,50.24 96.36,52.02 95.09,53.29 Q9.2
  BOTTOM w0.356: 90.39,48.82 90.42,48.85 94.46,48.85 95.04,49.43 R480.2
  vias: v1(89.17,42.35)
+3V_SSD2: length 15.2
  IN10 w0.305: v2(92.81,66.12) 92.68,65.99 92.68,57.44 92.53,57.28 92.53,52.68 v2(92.55,52.66)
  BOTTOM w0.305: Q9.5 92.73,53.29 R486.2 92.68,52.91 92.55,52.78 v2(92.55,52.66)
  vias: v2(93.44,66.12) v2(95.85,82.38) v2(95.85,81.74) v2(96.49,82.38) v2(96.49,81.74) v2(96.87,66.12) v2(97,67.39)
+3V_THERM: length 3.7
  BOTTOM w0.254: U25.1 205.09,113.63 204.82,113.36 204.01,113.36 C631.2
  BOTTOM w0.457: R553.2 203.88,110.77 203.55,110.44 R554.1
+3V_TP:
  vias: v2(278.1,23.45)
+3V_WLAN: length 1.9
  TOP w0.254: R460.2 268.32,75.09 Q8.2
  TOP w0.356: R460.2 268.8,75.01 v2(269.13,74.68)
  vias: v2(259.68,75.64) v2(259.68,73.99) v2(259.68,72.72) v2(261.08,75.64) v2(282.8,75.64) v2(282.8,74.37) v2(282.8,73.36) v2(283.94,75.64)
+3VA_AMP: length 3.9
  TOP w0.254: v2(267.19,30.43) 267.19,30.56 267.58,30.95 U8.14
  BOTTOM w0.457: L11.2 266.49,29.74 C349.2 v2(267.19,30.43) v1(267.84,30.43)
+3VALW: length 504.8
  TOP w0.203: R297.1 33.4,46.99 32.77,47.62 32,47.62
  TOP w0.254: v2(105.51,87.84) 105.73,88.06 106.09,88.06 PR411.2 PR407.2 ; PR509.1 265.22,49.69 264.89,49.36 v2(264.33,49.36) ; v2(117.32,64.21) 117.7,64.59 PR1406.2 ; PU501.7 262.52,46.52 262.99,46.05 ; PU403.7 211.92,117.06 ; v2(198.16,192.61) 198.04,192.74 185.77,192.74 184.45,194.06 R368.1 ; PC434.1 210.73,118.38 210.41,118.7 209.14,118.7 208.25,117.81 208.25,117.17 208.83,116.59 PR427.1 207.82,115.6 207.49,115.27 207.49,114.13 207.79,113.82 PR423.1
  TOP w0.305: v2(11.14,145.11) 10.43,144.4 C512.2 6.59,143.78 U51.1
  TOP w0.356: 69.18,46.18 70.33,46.18 71.22,45.29 71.22,44.66 71.85,44.02 PR626.1 ; v2(37.18,64.85) 37.26,64.93 R2098.1 ; v2(219.93,167.72) 219.81,167.85 PR723.1 ; PC513.1 264.89,43.77 v2(264.38,44.28) 264.26,44.4 264.26,44.78 262.99,46.05
  TOP w0.457: PC434.1 211.55,118.06 211.92,117.7 v2(211.92,117.68) 211.92,117.06
  TOP w0.508: 30.58,47.81 L2.1 ; R2056.1 60.04,95.46 v2(60.29,95.71) ; PC719.1 215.04,169.41 215.5,168.95 v3(216.03,168.95) ; v2(83.92,92.15) PR105.1 ; v2(135.4,148.01) 136.62,149.23 PR1221.1
  IN03 w0.508: v2(126.56,76.13) 126.46,76.03 116.17,76.03 114.9,77.3 114.9,88.85 114.14,89.61 112.87,89.61 111.73,90.76 107.41,90.76 106.78,90.12 106.78,88.49 106.12,87.84 v2(105.51,87.84) ; v2(64.23,93.81) 63.47,93.04 63.47,90.63 63.72,90.38 63.72,86.69 56.86,79.84 54.96,79.84 51.02,75.9 51.02,73.23 v2(49.75,71.96) ; v2(202.02,151.91) 202.34,152.23 203.55,152.23 204.5,153.18 206.03,153.18 206.85,154 206.85,159.46 v2(206.22,160.1) ; v2(264.38,44.28) 264.99,44.89 264.99,48.7 v2(264.33,49.36)
  IN05 w0.508: v2(123.86,136.09) 123.86,137.56 125.7,139.4 135.22,139.4 136.75,140.92 136.75,146 135.4,147.35 v2(135.4,148.01)
  IN05 w0.762: v2(61.18,9.6) v2(61.82,10.24) 61.82,12.65 63.09,13.92 63.09,17.73 65.63,20.27 v2(66.52,20.27)
  IN08 w0.254: v2(60.29,95.71) 55.34,95.71 54.45,96.6 54.45,99.27 53.18,100.54 42.64,100.54 15.84,127.33 15.84,140.41 v2(11.14,145.11) ; v2(206.22,160.1) 206.22,170.26 207.49,171.53 207.49,175.47 208.5,176.48 208.5,182.83 209.39,183.72 209.39,189.57 208.13,190.83 199.94,190.83 v2(198.16,192.61)
  IN08 w0.508: v2(264.38,44.28) 264.38,44.25 267.18,41.46 267.18,41.23 268.29,40.11 276.2,40.11 276.45,40.36 277.72,40.36 278.1,39.98 280.41,39.98 281.24,40.82 283.77,40.82 284.3,40.29 284.3,39.81 283.56,39.07 283.56,37.54 282.04,36.02 282.04,30.94 v2(282.8,30.18) ; v2(64.23,93.81) 65.88,93.81 66.64,93.04 66.64,85.8 65.25,84.41 65.25,80.6 66.24,79.61 v2(66.24,79.58)
  IN10 w0.305: v2(83.92,92.15) 81.5,89.74 79.86,89.74 78.33,88.21 78.33,81.23 77.44,80.34 71.34,80.34 70.61,79.61 66.26,79.61 v2(66.24,79.58)
  IN10 w0.508: v2(126.91,130.5) 126.47,130.5 125.83,131.14 125.83,134.7 124.44,136.09 v2(123.86,136.09) ; 124.71,77.85 124.68,77.88 124.68,106.12 127.71,109.15 127.71,117.66 135.86,125.81 135.86,132.41 140.56,137.11 140.56,142.19 135.4,147.35 v2(135.4,148.01)
  IN10 w1.016: 212.19,126.95 212.19,125.3 ; 213.33,94.57 211.8,96.09 211.8,101.55
  BOTTOM w0.254: R64.1 48.61,48.34 49.45,47.5 v2(49.45,47.25) ; C623.2 42.77,41.23 43.29,41.75 U61.5 ; PU1309.7 122.63,135.5 123.23,136.09 v2(123.86,136.09) PC3539.1 ; PU702.7 215.82,168.74 v3(216.03,168.95)
  BOTTOM w0.356: v2(42.59,41.99) 42.59,41.35 C623.2 ; v2(135.4,148.01) 135.78,148.39 R51.2 ; R831.2 v2(57.32,39.4)
  BOTTOM w0.381: PR3463.1 PR3464.1 126.63,130.22 v2(126.91,130.5) ; U58.5 48.33,39.13 48.97,38.48 C622.2 50.27,38.48 v2(50.42,38.33)
  BOTTOM w0.508: v2(37.18,64.85) 37.18,65.23 39.97,68.02 40.99,68.02 41.88,68.91 R273.2 ; PR501.2 264.26,49.43 v2(264.33,49.36) ; v2(60.29,95.71) 62.2,93.81 v2(64.23,93.81)
  vias: v1(31.46,48.34) v1(31.46,47.73) v1(55.98,40.72) v1(60.17,48.47) v1(113.13,50.88) v2(48.1,71.96) v2(48.99,71.96) v2(48.99,71.05) v2(57.5,26.11) v2(57.5,25.23) v2(57.5,24.34) v2(58.26,26.11) v2(58.26,25.23) v2(58.26,24.34) v2(59.15,26.11) v2(59.15,25.23) v2(59.15,24.34) v2(59.79,39.07) v2(59.79,38.43) v2(60.04,26.11) v2(60.04,25.23) v2(60.04,24.34) v2(60.42,39.07) v2(60.42,38.43) v2(60.8,26.11) v2(60.8,25.23) v2(60.8,24.34) v2(61.06,39.07) v2(61.06,38.43) v2(61.69,26.11) v2(61.69,25.23) v2(61.69,24.34) v2(81.12,45.99) v2(81.12,45.36) v2(81.12,44.72) v2(92.3,24.34) v2(93.19,24.34) v2(93.95,24.34) v2(94.71,24.34) v2(111.73,52.28) v2(111.7,51.52) v2(111.7,50.63) v2(111.7,49.87) v2(127.35,76.97) v2(128.59,77.93) v2(128.57,76.05) v2(202.02,151.14) v2(217.01,78.95) v2(217.65,78.95) v2(219.63,47.83) v2(220.44,47.83) v2(220.44,46.56) v2(251.96,39.86) v2(252.98,39.86)
+3VALW_AUD: length 1.2
  TOP w0.203: U7.10 284.65,32.61 283.5,32.61 v2(283.48,32.59)
  vias: v1(281.68,32.39)
+3VALW_EC_FSPI: length 4.5
  TOP w0.203: v1(33.72,50.88) 33.5,50.66 C308.2 33.93,49.81 34,49.74 34,48.42 R297.2
  BOTTOM w0.152: v1(33.72,50.88) 33.72,50.93 34.21,51.41 U5.D5
+3VALW_LC: length 24.1
  TOP w0.203: U19.J5 U19.K4 ; U19.E9 U19.D10
  TOP w0.254: R567.1 71.16,2.82 71.34,2.64 72.74,2.64 72.94,2.85 R620.1 73.48,2.72 75,2.72 v2(75.91,3.64) ; U19.D5 70.07,9.37 v1(69.58,9.86) ; v3(67.79,5.92) 67.79,6.28 68.6,7.09 U19.A1 ; v1(73.63,12.02) 73.25,12.02 U19.K10 ; U19.D10 69.84,11.87 ; v1(70.45,8.33) 70.6,8.48 U19.E4 ; U19.D4 v1(69.56,8.33) ; U19.K4 v1(73.4,8.56)
  TOP w0.305: C1369.2 v3(76.8,6.02)
  TOP w0.356: C1359.2 66.14,9.22 v3(66.26,9.35) ; C1361.2 65.96,7.95 v3(66.26,7.95) ; 69.84,11.87 69.64,11.87 v1(69.51,11.99) ; v3(76.93,7.45) 77.01,7.52 C1363.2 ; C1367.1 66.64,7.32 v1(67.02,6.94)
  TOP w0.457: C1362.2 v1(75.15,14.05) ; R525.1 v2(75.91,3.64)
  BOTTOM w0.254: R825.2 R814.2 62.76,6.49 62.94,6.32 66.12,6.32 v2(66.52,5.92)
  vias: v1(53.82,7.06)
+3VALW_LC_SPI: length 11.4
  TOP w0.508: C475.1 51.28,5.11 51.35,5.03 R788.2 ; C475.1 52.05,5.85 52.29,5.6 R433.1 v2(52.42,4.78) ; C475.1 C476.2 49.63,5.85 49.3,6.18 U16.8
  BOTTOM w0.254: R783.2 49.47,4.5 v1(49.47,2.87) 50.51,2.87 v2(52.42,4.78)
+3VALW_PCH: length 46.3
  TOP w0.254: 221.7,62.07 221.58,61.95 221.58,61.47 220.82,60.71 v2(220.82,60.4) ; 221.7,62.07 221.58,62.18 221.58,62.56 ; 221.7,62.07 RP1.8 ; R875.1 226.87,65.46 226.87,64.04 226.28,63.45 225.39,63.45 224.76,64.09 221.84,64.09 221.58,63.83 221.58,63.58 ; RP1.5 221.6,63.57 221.58,63.58 ; 221.58,63.58 221.58,63.07 ; 221.58,63.07 221.59,63.07 RP1.6 ; 221.58,63.07 221.58,62.56 ; 221.58,62.56 221.59,62.57 RP1.7
  TOP w0.356: R142.2 R138.2 240.21,47.46 L38.1 241.52,47.13 v2(241.52,46.69) 241.47,46.69 241.22,46.43 C2692.2 ; v2(254.1,49.74) 253.84,49.74 253.46,50.12 253.46,51.26 253.08,51.64 R143.2
  TOP w0.457: R151.2 v2(227.43,45.8)
  TOP w0.508: R215.2 249.84,58.5 253.21,58.5 v2(254.1,57.61)
  IN08 w0.508: v2(221.58,58.75) 220.82,59.52 v2(220.82,60.4)
  BOTTOM w0.305: R137.2 238.09,47.12 238.09,46.43 237.33,45.67 237.33,43.39
  BOTTOM w0.356: v2(220.82,60.4) 220.82,60.28 220.44,59.9 220.44,56.09 221.58,54.94 v2(221.58,54.05) ; R266.1 222.35,56.72 221.58,57.48 v2(221.58,58.75)
  BOTTOM w0.457: v2(220.82,60.4) 221.65,61.23 R213.2
  BOTTOM w0.508: R115.2 219.68,61.55 v2(220.82,60.4)
  vias: v2(254.1,48.57) v2(254.98,57.36)
+3VALW_SLG: length 4.4
  BOTTOM w0.203: 54.76,41.81 54.51,42.06 U22.1
  BOTTOM w0.356: R831.1 C505.1 C506.2 v1(55.47,41.99) 55.27,41.99 55.09,41.81 54.76,41.81
+3VALW_SPI: length 30
  TOP w0.356: R937.1 217.27,52.53 217.06,52.73 R936.1 ; R936.1 215.82,52.73 215.49,52.4 215.49,49.74 215.16,49.41 R938.1 R931.1 ; R936.1 216.38,54.56 v2(217.14,55.32)
  BOTTOM w0.254: v2(217.14,55.32) 217.39,55.07 217.39,53.17 218.28,52.28 218.28,48.34 217.8,47.86 217.16,47.86 216.88,48.14 216.53,48.14 216.17,47.78 R116.2
  BOTTOM w0.356: C178.2 216.63,60.4 216.38,60.15 R118.2 ; v2(217.14,55.32) 217.65,55.83 U3.8
  BOTTOM w0.508: U3.8 217.65,58.12 217.32,58.45 C177.1 C178.2 217.33,60.42 R115.1
+3VALWP: length 19
  TOP w0.381: PR301.1 46.32,8.08 46.83,7.57 49.24,7.57 v1(49.58,7.91) 49.7,8.03 58.54,8.03 61.09,10.58 61.09,12.57
+3VD_AMP:
  vias: v1(280.46,28.3)
+3VD_AUD: length 391.5
  TOP w0.203: v2(286.23,28.27) 286.81,28.86 286.81,29.11 287.13,29.43 U7.19 ; v2(283.48,33.86) 283.54,33.81 284.65,33.81 U7.7
  TOP w0.457: v2(280.51,33.86) R310.2 R289.2 ; v2(281.53,40.08) 283.05,41.61 284.7,41.61 286.23,40.08 R292.2
  IN03 w0.508: v2(281.53,40.08) 281.53,34.88 v2(280.51,33.86)
  IN05 w0.508: v2(283.48,33.86) 284.85,32.49 284.85,31.81 286.23,30.43 v2(286.23,28.27) 286.23,24.84 287.24,23.83 290.67,23.83 291.31,23.19 291.31,15.67 296.93,10.06 298.86,10.06 299.64,9.27 300.74,9.27 302.79,11.33 306.48,11.33 309.85,14.7 309.85,59.9 307.18,62.56 307.18,65.99 309.09,67.9 309.09,72.34 307.18,74.25 307.18,76.79 310.48,80.09 310.48,111.59 308.45,113.62 308.45,119.46 309.47,120.48 309.47,171.91 v2(308.58,172.8)
  IN10 w0.508: v2(293.59,171.66) 293.59,174.45 288.13,179.91 288.13,180.04 287.75,180.42 287.75,181.08 285.24,183.59 282.92,183.59 282.29,184.23 279.23,184.23 277.45,186.01 273.05,186.01 271.44,187.61 220.97,187.61 212.09,196.49 210.87,196.49 208.64,198.72 198.23,198.72 198.22,198.71 186.68,198.71 185.64,197.67 185.64,197.34 184.6,196.29 178.18,196.29 177.69,196.78 174.87,196.78 174.72,196.93 171.24,196.93 170.48,197.69 166.59,197.69 166.06,198.22 v2(164.31,198.22)
  BOTTOM w0.356: C303.2 286.18,28.22 v2(286.23,28.27)
  BOTTOM w0.508: v2(293.59,171.66) 294.61,171.66 295.5,170.77 300.7,170.77 301.59,169.88 305.66,169.88 v2(308.58,172.8) ; JCAM1.8 v2(164.31,198.22)
+3VLP: length 151.7
  TOP w0.508: PR304.2 v2(45.18,8.08) ; v2(28.29,52.02) 28.54,52.27 L1.1
  IN03 w0.508: v2(78.61,4.57) 75.23,4.57 74.07,5.73 72.42,5.73 71.98,5.29 63.98,5.29 63.09,4.4 61.28,4.4 59.25,6.43 52.17,6.43 50.64,4.91 46.45,4.91 45.18,6.18 v2(45.18,8.08)
  IN05 w0.508: v2(78.61,4.57) 77.34,4.57 75.44,6.48 75.44,13.21 76.28,14.05 76.28,16.46 77.69,17.88 v2(77.69,22.3)
  IN10 w0.508: v2(28.29,52.02) 27.53,51.26 27.53,45.55 28.04,45.04 28.04,39.58 30.07,37.54 30.07,20.53 28.04,18.49 28.04,7.06 29.18,5.92 43.02,5.92 v2(45.18,8.08)
  BOTTOM w0.356: PR103.1 94.91,11.97 93.49,10.54 93.22,10.54 93.13,10.46 88.26,5.59 84.33,5.59 83.44,4.7 78.74,4.7 v2(78.61,4.57)
  BOTTOM w0.508: v2(45.18,8.08) 46.15,8.08 PR355.2
  vias: v1(77.7,23.24)
+3VLP_EC: length 111.2
  TOP w0.254: C235.2 33.67,51.64 v1(33.24,51.64) ; R564.1 R563.1 37.36,48.9 38.14,49.69 R299.1 ; v2(36.29,62.18) 35.4,61.29 35.4,58.5 34.26,57.36 R244.1 R238.1 35.83,56.54 36.04,56.34 36.04,55.83 36.24,55.63 C233.2 ; v1(33.24,51.11) 32.81,51.11 C234.2
  TOP w0.356: v2(27.02,54.31) 27.53,54.31 27.71,54.49 R246.1 R259.2 ; C230.1 32.77,55.32 v1(33.28,54.82) ; v1(36.78,54.94) 36.8,54.97 C233.2 ; R250.1 29.69,45.11 29.69,45.04 v2(29.69,45.04) ; R299.1 37.99,50.02 C237.2 v1(37.31,50.88)
  TOP w0.508: C233.2 38.02,55.63 38.45,55.2 38.45,51.9 37.99,51.44 C237.2
  IN08 w0.381: v1(33.28,54.82) 32.1,54.82 30.83,53.55 28.8,53.55 28.04,54.31 v2(27.02,54.31)
  IN10 w0.356: v3(69.6,19.3) 69.26,19.64 60.17,19.64 59.28,20.53 48.61,20.53 47.97,19.89 44.29,19.89 40.1,24.08 39.59,24.08 32.48,31.19 32.48,42.62 v2(33.62,43.77)
  BOTTOM w0.097: R268.1 69.6,18.75 v3(69.6,19.3)
  BOTTOM w0.254: U5.D4 33.66,51.41 33.36,51.11 v1(33.24,51.11) ; U5.E4 33.51,51.91 v1(33.24,51.64) ; U5.K4 33.77,54.54 33.5,54.82 v1(33.28,54.82) ; R251.1 35.48,61.24 36.29,62.06 v2(36.29,62.18) ; U5.D10 v1(37.31,50.88) ; U5.K10 v1(36.78,54.94)
  BOTTOM w0.356: v2(33.62,43.77) 32.73,43.77 32.23,43.26 32.23,42.62 31.97,42.37 R245.1 ; v2(38.96,43.39) R236.1 R243.1 ; R247.1 43.53,47.96 43.71,47.78 44.42,47.78 44.76,48.12 44.76,48.97 45,49.21 v2(45,50.12) 45,52.2 44.67,52.54 L3.1 ; R379.1 v2(35.99,43.39)
  BOTTOM w0.508: v2(33.62,43.77) R249.1 ; R232.1 v2(29.69,45.04)
  vias: v1(28.42,51.13)
+3VLP_EC_AVCC: length 22.2
  TOP w0.356: v1(35.27,52.4) 35.4,52.28 C241.2
  IN10 w0.254: 33.9,52.76 32.96,52.76
  IN10 w0.356: v2(44.3,51.9) 43.66,52.53 41.75,52.53 41.24,52.02 39.34,52.02 37.43,50.12 33.12,50.12 32.35,50.88 32.35,52.15 32.96,52.76 ; 33.9,52.76 34.26,52.4 v1(35.27,52.4)
  BOTTOM w0.254: v1(35.27,52.4) 35.41,52.27 35.92,52.27 U5.E9
  BOTTOM w0.356: v2(44.3,51.9) 43.92,52.28 L3.2 43.79,52.78 R557.1
+5V: length 661.2
  TOP w0.254: PC1257.1 189.91,127.82 190.21,128.12 190.21,128.48 190.05,128.64 PU1254.1 ; v2(113.76,59.77) 113.76,60.66 111.35,63.07 109.49,63.07 PR1412.2
  TOP w0.457: R341.2 v2(276.96,51.9) R342.2
  TOP w0.508: v2(193.03,130.1) 193.19,130.1 193.64,129.65 193.64,127.77 192.88,127 190.13,127 189.91,127.23 PC1257.1
  IN03 w0.508: v2(77.44,93.09) 77.44,94.19 76.04,95.58 73.76,95.58 72.36,96.98 v2(72.36,97.49)
  IN05 w0.508: v2(195.04,193.25) 195.04,192.74 194.53,192.23 190.47,192.23 188.82,193.88 177.96,193.88 v2(175.8,196.04)
  IN08 w0.305: 113.76,58.12 v2(113.76,59.77) ; v2(223.11,46.54) 222.5,45.93 218.21,45.93 217.9,46.23 217.9,51.51 v2(218.79,52.4)
  IN08 w0.762: 70.83,95.84 69.44,94.44 69.44,86.69 68.45,85.7 68.45,81.7 68.29,81.55 68.29,77.8 69.56,76.53 70.45,76.53 70.96,76.03 70.96,74.76 69.82,73.61 v2(68.42,73.61) v2(67.66,73.61) ; v2(193.03,130.1) 193.64,129.49 193.64,128.45 165.58,100.38 165.58,73.49 166.59,72.47 166.59,67.01 168.75,64.85 168.75,58.63 167.48,57.36 157.07,57.36 156.18,56.47 117.57,56.47 115.92,58.12 111.35,58.12 110.2,56.98 104.3,56.98 102.82,58.46 v2(102.82,58.63)
  IN10 w0.508: 115.79,130.89 115.79,161.62 119.73,165.56 119.73,168.35 117.95,170.13 117.95,175.72 119.98,177.75 125.83,177.75 128.87,180.8 146.15,180.8 148.94,183.59 148.94,189.44 156.18,196.68 159.23,196.68 159.99,197.44 165.7,197.44 166.08,197.06 170.15,197.06 170.91,196.29 174.34,196.29 174.59,196.04 v2(175.8,196.04) ; 115.79,130.89 117.19,129.49 128.75,129.49 129.64,130.38 131.03,130.38 v2(131.67,129.75) ; 115.79,130.89 115.15,130.89 113.76,129.5 113.76,113.74 106.78,106.76 98.39,106.76 92.81,101.17 v2(92.81,97.74)
  BOTTOM w0.356: PR1309.2 v2(175.8,196.04) ; TP15.1 v2(218.79,52.4)
  BOTTOM w0.508: v2(16.22,15.83) 17.24,15.83 18.89,14.18 18.89,10.75 21.77,7.87 26.42,7.87 26.92,7.37 48.87,7.37 49.22,7.01 R327.1 ; R386.2 v2(77.44,93.09) ; 206.72,121.49 202.28,117.05 199.36,117.05 196.82,114.51 135.99,114.51 131.03,119.46 131.03,129.11 v2(131.67,129.75) ; R560.1 98.84,91.46 98.14,90.76 95.47,90.76 94.96,91.27 94.96,92.92 94.2,93.68 92.3,93.68 91.92,94.06 91.92,96.85 v2(92.81,97.74)
  BOTTOM w0.762: PU1.3 11.51,142.12 C541.2 14.27,142.12 15.21,141.18 15.21,124.34 17.8,121.75 21.3,121.75 42.64,100.41 46.45,100.41 48.74,98.12 53.05,98.12 53.56,98.63 55.26,98.63 57.31,96.58 65.5,96.58 65.77,96.85 68.68,96.85 69.31,97.49 v2(71.6,97.49)
  vias: v1(12.67,16.84) v2(13.18,17.73) v2(13.18,16.46) v2(13.18,15.83) v2(13.94,17.73) v2(13.94,16.46) v2(13.94,15.83) v2(14.7,17.73) v2(14.7,16.46) v2(14.7,15.83) v2(15.46,16.46) v2(15.46,15.83) v2(16.22,16.46) v2(95.85,72.34) v2(96.23,73.61) v2(96.87,73.61) v2(96.87,72.34) v2(99.54,91.77) v2(100.17,91.77) v2(100.27,44.53) v2(100.27,43.9) v2(100.81,91.77) v2(103.7,43.9) v2(104.47,43.9) v2(286.73,79.84) v2(286.73,79.2) v2(287.37,79.84) v2(287.37,79.2) v2(288.13,79.84) v2(288.13,79.2) v2(288.77,79.84) v2(288.77,79.2) v2(296.51,40.67) v2(296.51,40.03) v2(308.96,51.39) v2(308.96,50.5) v2(308.96,49.61) v2(308.96,48.72) v2(308.96,47.83)
+5V_DEBUG: length 22.1
  BOTTOM w0.305: JDBUG1.1 28.7,3.41 29.06,3.05
  BOTTOM w0.508: R327.2 R326.2 47.75,5.69 47.45,5.38 42.87,5.38 v1(41.73,4.25) 40.53,3.05 29.06,3.05
+5V_FAN1:
  vias: v1(291.21,77.85)
+5V_FAN2:
  vias: v1(97.5,94.47)
+5V_HDD: length 2.8
  BOTTOM w0.097: v1(284.07,81.36) 284.45,81.74 286.73,81.74
+5V_HDMI_CON: length 19.1
  TOP w0.254: v2(7.72,136.1) 8.06,135.75 JHDMI1.18
  TOP w0.356: D2014.2 D2015.2 12.53,140.26 v1(12.16,139.88) 11.53,139.25 11.53,138.38 10.38,137.24 8.07,137.24 7.72,136.89 v2(7.72,136.1)
  BOTTOM w0.635: 5.43,138 5.43,140.22 R440.1
+5V_USB1:
  vias: v1(13.94,64.72) v2(14.7,66.37) v2(14.7,65.36) v2(14.7,64.47) v2(15.59,66.37) v2(15.59,65.36) v2(15.59,64.47)
+5V_USB2:
  vias: v1(19.15,36.91) v2(8.99,33.73) v2(8.99,32.46) v2(16.61,36.91) v2(16.61,36.02) v2(17.88,37.29) v2(17.88,36.02)
+5V_USB_KB:
  vias: v1(61.03,13.69)
+5VA_AUD: length 1.7
  TOP w0.203: v2(290.67,38.48) 289.93,37.74 U7.45
  vias: v1(290.09,40.21)
+5VALW: length 404.3
  TOP w0.254: PR1401.2 111.22,65.74 111.47,65.48 111.47,63.71 112.24,62.94 v2(113.89,62.94)
  TOP w0.305: PR3401.1 304.11,95.58 v2(304.36,95.33)
  TOP w0.356: v2(165.83,189.94) 166.03,189.74 PR1597.2 ; PU1608.1 300.49,88.18 300.65,88.34 PC190.2 300.65,89.56 301.14,90.05 v2(301.64,90.05) ; PR1595.2 176.12,189.44 v2(175.99,189.56) ; PR1631.2 187.04,189.72 v2(186.94,189.82) ; v2(299.05,183.59) 298.67,183.98 PR1471.2
  TOP w0.381: v2(107.7,86.23) 107.71,86.23 107.91,86.04 107.91,86.04 108.53,85.42 PR405.1 ; v2(273.53,193.12) 273.53,195.53 271.62,197.44 271.62,201.76 270.73,202.64 v2(270.73,204.55) ; PU1610.1 299.44,172.98 PC191.2 298.34,172.98 297.78,172.42 v2(297.78,171.91) 297.91,171.78 PR3588.2 ; R1010.1 210.66,151.77 v2(210.66,152.35) ; PR3577.1 v2(296.89,87.07) ; v2(206.78,127.23) 206.24,127.23 205.71,126.7 204.24,126.7 R2265.1 ; R2268.1 v2(290.54,170.95) 290.9,170.59 294.17,170.59 295.5,171.91 v2(296.01,171.91) R1014.1 ; R2260.1 v2(304.84,82.05) ; R810.1 v2(299.13,72.27)
  TOP w0.508: v2(176.63,182.32) 176.88,182.58 PR1509.1 ; PR1502.1 164.69,181.56 v2(164.05,180.93) ; v2(203.93,154.59) 203.93,153.11 204.44,152.61 PR1251.1 ; PR1609.1 187.88,183.65 v2(188.56,182.96)
  IN03 w0.508: v2(204.82,160.1) 204.44,159.72 204.44,156.67 204.95,156.16 204.95,155.02 204.51,154.59 v2(203.93,154.59) ; 222.85,189.69 222.73,189.56 v2(211.55,189.56) ; v2(199.36,182.71) 202.03,180.04 v2(209.29,180.04)
  IN05 w0.356: v2(134.21,189.31) 134.33,189.31 139.92,183.72 v2(150.34,183.72) v2(150.97,183.72)
  IN05 w0.508: v2(299.05,183.59) 298.55,183.09 298.55,180.27 v2(299.8,179.02)
  IN08 w0.356: v2(210.66,152.35) 210.66,148.29 207.36,144.99 207.36,129.26 v2(207.03,128.93) ; v2(206.78,127.23) 206.78,127.84
  IN08 w0.381: v2(206.78,127.23) 206.78,124.74 207.84,123.68 207.84,121.52 210.28,119.08 212.31,119.08 214.17,117.22 214.81,117.22 v2(215.87,116.16) ; v2(207.03,128.93) 207.03,128.1 206.78,127.84
  IN08 w0.508: v2(199.36,182.71) 199.36,180.29 200.88,178.77 200.88,168.48 202.66,166.7 202.66,162.26 v2(204.82,160.1)
  IN10 w0.356: v2(116.81,39.2) 117.57,39.96 117.57,48.52 121.63,52.58 121.63,54.69 121.51,54.82 121.51,57.36 115.92,62.94 v2(113.89,62.94)
  IN10 w0.381: v2(176.37,193.25) 177.01,192.61 186.53,192.61 v2(187.17,193.25)
  IN10 w0.508: v2(129.31,158.52) 129.31,167.9
  BOTTOM w0.203: 131.67,155.88 131.85,155.7 PU1204.18
  BOTTOM w0.254: PU1301.3 59.22,42.57 v2(59.02,42.37)
  BOTTOM w0.33: PU1303.A3 152.81,198.69
  BOTTOM w0.356: PC1280.1 PR1226.1 ; v2(210.66,152.35) 207.74,152.35 207.23,152.86 207.23,154.38 204.57,157.05 204.57,159.85 v2(204.82,160.1) ; 273.53,195.66 274.16,196.29 274.16,197.82 272.64,199.34 PR920.2 ; PR1598.1 165.6,192.08 165.6,192.94 v2(165.42,193.12) ; PR1020.1 222.52,203.74 223.36,202.9 223.36,200.74 v2(223.62,200.49) 223.62,199.77 PR1009.2 ; PR910.1 259.23,203.74 259.94,203.03 259.94,201.12 260.14,200.92 v2(260.14,200.49) PR909.2 ; PU1609.1 216.24,109.13 PC192.2 ; PR1633.2 211.68,188.04 211.98,188.34 211.98,189.13 v2(211.55,189.56) 211.3,189.82 PR1630.1 ; PR1624.2 200.63,188.04 201.01,188.42 201.01,189.44 200.5,189.94 v2(200.37,189.94) 200.25,189.82 PR1625.1 ; PR1596.1 v2(176.37,193.25)
  BOTTOM w0.381: PR915.1 270.73,203.86 v2(270.73,204.55) ; PC1319.1 154.21,198.64 154.65,198.2 154.65,197.44 153.64,196.42 153.32,196.42 150.97,194.08 v2(150.97,184.99) ; PR3534.1 247.03,203.74 247.75,203.03 247.75,200.74 248.09,200.39 v2(248.1,200.39) 248.1,199.75 PR3536.2 ; PR1630.1 210.61,190.53 210.92,190.83 210.92,191.9 PR1409.2 ; PR1503.2 163.74,180.86 163.8,180.93 v2(164.05,180.93) ; v2(211.68,48.97) 210.66,49.99 210.66,63.2 214.73,67.26 214.73,77.68 218.33,81.28 218.95,81.28 221.33,83.66 221.33,85.17 218.73,87.77 PR3442.1 ; PR1014.2 236.06,199.65 v2(236.06,200.26) 235.68,200.64 235.68,202.77 234.72,203.74 PR1023.1 ; PR1628.1 187.19,193.22 v2(187.17,193.25) ; PR1186.1 131.67,186.64 134.21,189.18 v2(134.21,189.31) ; PC192.2 216.25,111.46 216.05,111.66 PR3582.1 ; 131.67,155.88 PC1280.1
  BOTTOM w0.508: v2(248.38,195.66) 248.08,195.96 PR3537.1 ; PR3539.2 v2(248.38,191.72) ; v2(260.57,195.66) 260.57,196.08 PR903.1 ; PR1053.2 v2(223.87,191.72) ; v2(297.78,171.91) 299.05,173.18 301.09,173.18 301.59,173.69 301.59,177.22 v2(299.8,179.02) 297.06,181.75 290.15,181.75 PR3526.1 ; PR3582.1 215.61,113.11 215.87,113.36 v2(215.87,116.16) ; v2(224,195.79) 224,196.29 223.81,196.49 PR1002.1 ; 152.81,198.69 153.91,198.69 PC1319.1 ; PR1226.1 130.12,157.66 129.31,158.47 v2(129.31,158.52) ; PR904.2 v2(260.45,191.72) ; v2(236.19,195.66) 236.19,196.05 235.88,196.36 PR1021.1 ; PR1022.2 v2(236.06,191.72)
  vias: v1(20.42,10.24) v1(40.99,70.44) v1(273.4,49.36) v2(14.07,42.5) v2(14.07,41.35) v2(14.07,40.08) v2(15.34,71.83) v2(15.34,70.56) v2(15.34,41.35) v2(15.34,40.08) v2(16.61,71.83) v2(16.61,70.56) v2(19.02,17.1) v2(19.02,15.32) v2(19.53,17.99) v2(19.53,16.21) v2(20.03,17.1) v2(20.03,15.32) v2(20.03,14.56) v2(20.03,13.67) v2(20.03,12.78) v2(20.03,11.89) v2(20.92,15.32) v2(20.92,14.56) v2(20.92,13.67) v2(20.92,12.78) v2(20.92,11.89) v2(41.58,71.4) v2(41.93,70.08) v2(41.96,71.91) v2(42.41,72.39) v2(42.39,70.59) v2(42.89,71.1) v2(54.07,73.36) v2(54.32,70.31) v2(54.96,71.83) v2(54.96,71.07) v2(54.96,70.31) v2(55.59,71.83) v2(55.59,71.07) v2(55.59,70.31) v2(56.48,12.65) v2(58.13,12.65) v2(100.04,86.31) v2(100.68,86.31) v2(117.57,189.44) v2(117.57,188.8) v2(118.71,43.13) v2(118.71,42.5) v2(118.71,41.86) v2(119.09,43.77) v2(119.6,44.28) v2(128.11,40.34) v2(128.11,39.7) v2(128.11,39.07) v2(128.75,40.34) v2(128.75,39.7) v2(128.75,39.07) v2(129,170.13) v2(129,169.37) v2(129,168.61) v2(129.76,170.13) v2(129.76,169.37) v2(129.76,168.61) v2(150.34,184.99) v2(224.12,42.88) v2(224.76,42.88) v2(225.39,42.88) v2(226.03,42.88) v2(226.66,42.88) v2(227.3,42.88) v2(270.64,20.19) v2(270.64,19.3) v2(271.53,20.19) v2(271.53,19.3) v2(271.88,50.12) v2(271.88,49.48) v2(272.64,50.12) v2(272.64,49.48) v2(274.16,193.12) v2(274.16,188.67) v2(274.8,188.67) v2(301.5,44.32) v2(301.5,43.43) v2(301.5,42.55) v2(301.5,41.66) v2(302.39,44.32) v2(302.39,43.43) v2(302.39,42.55) v2(302.39,41.66) v2(303.28,44.32) v2(303.28,43.43) v2(303.28,42.55) v2(303.28,41.66)
+5VALW_USB_CHG: length 5.5
  TOP w0.305: R503.2 24.15,44.1 24.48,43.77 24.48,42.24 v1(25.37,41.35) 25.81,40.91 C600.1
  vias: v2(23.84,38.43) v2(23.84,37.29) v2(24.86,38.43) v2(24.86,37.29)
+5VALWP: length 39.7
  TOP w0.203: 43.85,16.4 44.15,16.1 PU301.14
  TOP w0.356: 43.53,16.72 43.85,16.4
  TOP w0.381: PR302.1 41.88,7.95 40.1,6.18 40.1,5.54 37.31,2.75 35.15,2.75 32.38,5.52 PC322.1
  TOP w0.508: v2(43.53,17.1) 43.53,16.72
  BOTTOM w0.508: v2(25.11,8.72) 25.11,9.49 30.4,14.78 32.69,14.78 33.15,15.24 41.43,15.24 41.83,14.83 42.72,14.83 43.53,15.64 v2(43.53,17.1)
+5VD_AUD: length 4
  TOP w0.203: 289.53,39.09 289.83,38.79 289.83,38.11 289.53,37.81 U7.46 ; U7.51 287.53,37.64 286.86,38.31 v2(286.86,38.54)
  vias: v1(286.94,39.96) v2(289.48,39.7)
+5VLDO: length 77.3
  TOP w0.356: v2(57.07,10.49) 57.07,10.16 57.45,9.78 PR1414.2
  TOP w0.508: PR312.1 42.26,19.26 v2(42.13,19.13)
  IN03 w0.508: v2(57.07,10.49) 56.05,11.51 44.57,11.51 43.28,12.81 43.28,14.7 44.16,15.59 44.16,17.48 43.4,18.24 43.02,18.24 v2(42.13,19.13)
  BOTTOM w0.508: v2(57.07,10.49) 56.86,10.29 56.86,8.02 55.15,6.3 50.9,6.3 50.28,5.69 R326.1 ; R376.1 R377.1 21.3,43.44
  BOTTOM w0.762: v2(42.13,19.13) 42.29,19.29 42.29,31.67 36.54,37.42 30.19,37.42 28.8,38.81 28.8,40.08 27.02,41.86 26,41.86 24.43,43.44 v1(24.02,43.44) 21.3,43.44
+12V_PUMP: length 18.6
  TOP w0.305: 282.42,13.46 PU604.8
  TOP w0.381: 282.42,13.46 282.17,13.46 281.61,12.9
  TOP w0.508: v2(278.84,12.14) 278.92,12.06 PC3596.1 280.62,12.9 281.61,12.9
  IN03 w0.762: v2(278.84,12.14) 280.01,13.31 281.84,13.31 282.22,13.69 282.22,15.16 283.57,16.51 286.97,16.51 287.65,15.82 287.65,15.16 288.16,14.66 v2(288.54,14.66)
+12V_SWF_BOOST: length 20.7
  TOP w0.254: 279.06,59.85 279.06,62.11 278.86,62.31 276.96,62.31 275.69,63.58 275.69,64.72 275.3,65.1 275.3,70.39 274.5,71.2 273.02,71.2 272.69,70.87 PR609.1
  vias: v1(280.77,57.23) v2(281.91,56.59) v2(281.91,55.96) v2(282.54,56.59) v2(282.54,55.96) v2(283.18,56.59) v2(283.18,55.96)
+AVDD33_LAN: length 1.1
  TOP w0.203: U6.16 v2(43.28,62.49)
  vias: v1(39.41,64.14)
+AVDDH_LAN: length 17.2
  TOP w0.203: U6.22 45.56,59.52 45.69,59.39 45.69,59.01
  TOP w0.508: v2(42.51,59.52) 42.51,59.21 44.24,57.48 45.38,57.48 45.76,57.86 C273.2 45.76,58.93 45.69,59.01
  IN05 w0.635: v2(42.51,59.52) 39.97,62.06 39.97,64.09 41.09,65.21 v2(42.69,65.21)
  BOTTOM w0.508: 43.53,64.65 R272.2
  BOTTOM w0.635: v2(42.69,65.21) 43.25,64.65 43.53,64.65
+AVDDHREG_LAN: length 4.7
  TOP w0.203: v2(45.18,66.53) 45.31,66.53 45.56,66.28 U6.9
  BOTTOM w0.457: R272.1 C272.2 C271.1 45.94,66.12 45.53,66.53 v2(45.18,66.53)
+AVDDL_LAN: length 12.7
  TOP w0.203: U6.31 49.78,60.89 50.01,60.66 50.01,59.9 ; v2(46.96,66.25) 46.76,66.05 U6.6 ; U6.13 v2(43.28,63.69) ; U6.19 v2(43.28,61.29)
  TOP w0.356: v2(53.69,59.9) v1(53,59.21) 52.37,58.58 C260.1 50.01,59.08 50.01,59.9
  BOTTOM w0.356: C264.2 C263.2 43.28,61.29 v2(43.28,61.29)
  BOTTOM w0.457: v2(43.28,63.69) 43.39,63.58 C262.2 ; C261.2 46.83,66.12 v2(46.96,66.25)
+AVDDVCO_LAN: length 7.3
  TOP w0.203: U6.34 v2(50.77,62.09)
  BOTTOM w0.457: C266.1 C267.2 C265.1 50.51,62.82 50.77,62.56 v2(50.77,62.09)
  BOTTOM w0.508: L6.2 50.08,59.25 v1(50.08,60.02) C266.1
+DVDDL_LAN: length 3.1
  TOP w0.203: U6.37 50.35,63.29 50.51,63.45
  TOP w0.381: v2(50.77,63.71) 50.51,63.45
  BOTTOM w0.457: C257.2 v2(50.77,63.71) 50.77,64.29 C259.2
  vias: v1(59.38,63.35) v2(56.1,57.61) v2(56.74,57.61) v2(58.52,64.09) v2(58.52,63.45)
+PVCC_AMP: length 7
  TOP w0.254: U8.42 275.09,34.45 v2(275.05,34.5) ; v2(269.84,35.51) 269.84,35.18 269.62,34.95 U8.6 ; U8.7 269.63,34.45 v2(269.78,34.31) ; v2(275.05,33.73) 275.27,33.95 U8.41 ; U8.43 275.36,34.95 v2(275.05,35.26)
  vias: v1(271.98,40.21)
+V1.00DX:
  vias: v1(202.03,156.42)
+V1.0U_VCCST_VCCSFR:
  vias: v1(199.43,154.49)
+V3.3A_1.8A_VCCPGPPA: length 10.3
  TOP w0.508: R290.1 224.31,50.88 v2(224.89,50.88)
  IN03 w0.508: 230.78,52.33 229.61,52.33 228.39,51.11 227.12,51.11 226.77,51.46 225.47,51.46 v2(224.89,50.88)
  BOTTOM w0.254: v3(232.63,53.55) 232.83,53.35 U2.BA31
  BOTTOM w0.508: R290.1 224.25,50.24 v2(224.89,50.88)
+V3.3A_VCCPAZIO: length 8.1
  TOP w0.457: L38.2 241.19,48.59 241.4,48.8 241.4,48.82 242.21,49.63 242.21,49.66 242.23,49.69 242.23,50.78 C400.2 242.34,51.97 241.7,52.61 C405.2 241.34,52.78 241.34,53.72 241.14,53.93 v3(240.76,53.93)
  BOTTOM w0.254: v3(240.76,53.93) 240.86,53.93 241.3,53.49 U2.BA15
+V3.3A_VCCPGPPBCH: length 6
  TOP w0.457: v3(228.31,52.18) 228.62,52.48 C221.2
  IN03 w0.508: v3(228.31,52.18) 227.91,51.77 227.32,51.77 226.99,52.1 225.09,52.1 v2(224.89,51.9)
  BOTTOM w0.508: v2(224.89,51.9) 224.63,51.64 R210.1
+V3.3A_VCCPGPPD:
  vias: v1(224.91,52.71)
+V3.3A_VCCPGPPEF: length 1.4
  BOTTOM w0.254: U2.AL41 228.57,58.34 v3(228.57,58.83) 228.57,58.93 U2.AJ41
  vias: v1(229.46,59.26)
+V3.3A_VCCPGPPG: length 12.1
  TOP w0.356: C224.2 228.75,62.26 v3(228.95,62.06)
  IN10 w0.356: v3(228.95,62.06) 228.44,61.55 227.13,61.55 226.11,62.56 224.12,62.56 223.49,63.2 v2(220.64,63.2)
  BOTTOM w0.254: U2.AD41 228.41,61.52 v3(228.95,62.06)
  BOTTOM w0.457: R213.1 221.22,62.63 v2(220.64,63.2)
+V3.3A_VCCPSPI:
  vias: v1(226.41,47.5)
+V3.3S_VCCATS: length 13.4
  TOP w0.305: v3(242.67,61.12) 243.12,60.66 C222.1
  IN08 w0.356: v3(242.67,61.12) 242.67,61.29 243.05,61.67 246.48,61.67 248,63.2 251.43,63.2 v2(252.44,64.21)
  BOTTOM w0.254: v3(242.67,61.12) 242.67,61.22 242.37,61.52 U2.AD13
  BOTTOM w0.457: R219.2 v2(252.44,64.21)
+VBAT_EC: length 1.4
  TOP w0.254: v1(33.24,54.28) 33.09,54.44 R235.2
  BOTTOM w0.254: v1(33.24,54.28) 33.27,54.26 33.43,54.26 U5.J4
+VCC19P2_1P0: length 0.7
  BOTTOM w0.254: U2.N17 239.56,67.21 v3(239.49,67.14)
  vias: v1(242.13,68.84)
+VCC_RTC: length 216.5
  TOP w0.254: v2(71.98,21.54) 71.98,21.92 v1(71.72,22.18)
  TOP w0.508: v2(71.98,21.54) 71.98,21.03 72.56,20.45 C640.1 ; C640.1 73.86,20.45 Q11.1 ; C640.1 R571.1 ; v2(112.31,47.88) v1(113.76,47.88) 114.47,47.88 115.13,48.54 152.75,48.54 160.95,56.75 179.65,56.75 187.14,49.25 202.38,49.25 v2(202.41,49.23)
  IN03 w0.508: v2(112.31,47.88) 111.65,48.55 109.78,48.55 107.92,46.69 106.65,46.69 106.05,46.09 106.05,44.28 104.7,42.92 92.13,42.92 90.82,44.23 84.12,44.23 83.53,43.64 78.54,43.64 77.95,44.23 70.28,44.23 69.95,43.89 v2(69.95,43.77)
  IN05 w0.508: v2(202.41,49.23) 208.12,49.23 209.14,48.21 212.95,48.21 213.33,47.83 215.36,47.83 216.38,46.82 216.88,46.82 218.66,48.59 222.6,48.59 224.38,46.82 233.52,46.82 237.08,43.26 240.46,43.26 v2(241.68,44.48)
  IN08 w0.508: v2(69.95,43.77) 69.34,43.16 69.34,39.12 71.6,36.86 71.6,22.81 71.98,22.43 v2(71.98,21.54)
+VCC_SWF:
  vias: v1(288.39,44.48) v2(286.23,55.71) v2(286.23,54.82) v2(286.99,55.71) v2(286.99,54.82) v2(287.12,46.31) v2(287.12,45.29) v2(287.75,55.71)
+VCCAAZPLL_1P0_L: length 6.5
  TOP w0.457: R226.1 242.16,59.31 v1(240.63,59.31) 240.25,58.93 240.25,58.17 C399.1 C398.2 240,57.23 v3(239.62,56.85)
  TOP w0.508: v2(256.64,55.07) 256.77,55.2 L39.2
  BOTTOM w0.254: U2.AN19 239.41,57.06 v3(239.62,56.85)
+VCCAMPHYPLL_1P0: length 0.6
  BOTTOM w0.254: U2.B43 227.4,71.88 v2(227.43,71.86)
  vias: v1(224.94,76.71) v3(225.39,73.1) v3(225.86,73.57)
+VCCAPLLEBB_1P0: length 1.5
  TOP w0.356: v3(234.54,64.85) 234.33,65.05 R218.1
  BOTTOM w0.254: U2.V28 v3(234.54,64.85)
+VCCAUSB_1P0_L: length 2.2
  TOP w0.356: R224.1 245.23,58.75 v3(245.59,58.75)
  BOTTOM w0.254: U2.AL5 245.59,58.57 v3(245.59,58.75) 245.59,58.78 U2.AJ5
+VCCDSW_1P0: length 4.5
  TOP w0.356: C212.1 233.93,53.39 v3(233.65,53.67)
  TOP w0.457: R205.1 255.11,58.96 v2(255.11,58.88)
  IN05 w0.102: 239.36,55.2 240,55.2 ; 240.51,55.71 241.01,55.71 ; 240.51,54.94 241.01,54.94
  BOTTOM w0.254: v3(233.65,53.67) 233.92,53.67 U2.BA29
+VCCDTS_1P0: length 11.5
  TOP w0.254: R217.2 250.46,61.04 248.94,61.04 248.2,61.78 246.27,61.78 245.94,61.45 v1(245.59,61.45) 244.22,61.45 244.09,61.57 241.8,61.57 241.4,61.17 v3(241.4,61.07)
  BOTTOM w0.254: v3(241.4,61.07) 241.01,61.45 U2.AD15
+VCCDUSB_1P0: length 14.4
  TOP w0.508: v3(239.82,62.59) 239.82,62.49 239.67,62.34 239.67,61.9 ; 239.67,61.9 C219.1 ; 239.67,61.9 239.77,61.8 241.24,61.8 241.5,62.06 245.82,62.06 246.07,62.31 247.75,62.31 248.2,62.77 v1(248.76,62.77) 248.94,62.94 251.62,62.94 R221.2
  BOTTOM w0.305: v3(239.82,62.59) 240.23,62.18 U2.AC17
+VCCF24_1P0_L: length 1
  BOTTOM w0.508: v3(251.56,74.22) 251.2,74.58 R189.2
  vias: v1(250.67,70.06) v3(248.13,68.53)
+VCCF100_1P0: length 1.1
  BOTTOM w0.254: v3(240.76,65.92) 240.69,65.99 U2.R17 ; U2.V17 240.3,64.52 240.61,64.82 v3(240.61,64.88)
  vias: v1(242.03,66.25)
+VCCF100OC_1P0: length 14.7
  TOP w0.305: R212.1 251.35,65.36 248.19,65.36 247.81,64.98 v1(246.76,64.98) 246.22,64.98 245.84,64.6 245.84,64.21 245.46,63.83 242.39,63.83 241.85,64.37 239.57,64.37 239.11,64.82 v3(239.11,64.85)
  BOTTOM w0.254: U2.U20 238.75,65.21 v3(239.11,64.85)
+VCCF135_1P0: length 0.5
  BOTTOM w0.305: U2.R19 239.42,65.99 v3(239.49,65.92)
  vias: v1(243.5,67.26)
+VCCFHV_2P8: length 20.2
  IN08 w0.356: v2(253.33,64.21) 251.81,62.69 248.25,62.69 247.49,61.93 247.49,61.29 246.6,60.4 244.56,60.4 244.54,60.43 243.46,60.43 243.44,60.4 240.76,60.4 240.38,60.02 240.38,59.26 240.1,58.98 237.79,58.98 v3(237.59,58.78)
  BOTTOM w0.254: U2.AL22 237.87,58.49 v3(237.59,58.78)
  BOTTOM w0.457: R204.2 v2(253.33,64.21)
