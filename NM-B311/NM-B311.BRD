# Allegro board NM-B311.BRD (continued)
## Copper pours and planes (outline as drawn) (continued)
SW1_5V on TOP (solid shape): 37.21,15.11 37.21,14.35 37.22,14.34 37.22,8.45 36.35,7.57 35.53,7.57 34.89,6.94 34.89,5.67 34.64,5.41 34.13,5.41 33.88,5.67 33.88,7.75 32.77,8.86 32.77,13.08 33.53,13.84 33.53,15.11 33.65,15.24 37.08,15.24
SW2_3V on TOP (solid shape): 54.38,20.55 54.38,13.44 53.49,12.55 53.49,11.2 52.92,10.63 52.19,10.63 52.18,10.62 50.84,10.62 50.54,10.32 50.29,10.32 50.1,10.51 50.1,14.21 50.13,14.25 50.13,20.65 50.26,20.78 54.15,20.78
TBT_SVR_IND on BOTTOM (solid shape): 47.21,98.12 47.21,93.42 46.83,93.04 46.83,92.41 46.92,92.32 46.92,92.3 46.89,92.06 47.03,91.86 47.03,91.57 47.13,91.48 47.13,91.37 47.29,91.21 47.29,91.03 47.24,90.98 47.14,90.98 46.89,90.73 46.89,90.63 46.8,90.55 46.71,90.55 46.64,90.61 46.64,91.15 46.27,91.52 46.2,91.52 46.09,91.63 46.02,91.73 45.93,91.79 44.67,93.04 44.67,98.12 44.8,98.25 47.09,98.25
TBTA_VBUS on BOTTOM: 12.41,80.98 17.62,80.98 17.88,80.72 17.88,77.68 17.49,77.3 12.29,77.3 12.03,77.55 12.03,80.6
TBTA_VBUS on BOTTOM: 31.64,77.3 31.85,77.3 32.1,77.04 32.1,76.79 32.35,76.79 32.86,77.3 32.86,79.78 32.67,79.98 32.67,80.46 32.3,80.83 31.39,80.83 31.21,81 28.39,81 28.04,80.65 28.04,77.8 28.34,77.5 29.71,77.5 29.89,77.68 31.26,77.68
TBTA_VBUS on IN05: 18.13,80.85 18.51,80.47 18.51,77.55 17.75,76.79 10.64,76.79 10.26,77.17 6.7,77.17 6.45,77.42 6.45,80.72 6.57,80.85
TBTA_VBUS on IN10: 18.76,77.55 16.73,75.52 9.49,75.52 8.48,76.53 6.95,76.53 6.45,77.04 6.45,80.98 6.57,81.11 7.33,81.11 7.84,81.61 10.05,81.61 10.47,82.03 16.64,82.03 18.51,83.9 26.38,83.9 26.63,83.66 29.05,83.66 30.7,82.01 30.7,78.36 29.56,77.22 26.94,77.22 26.61,77.55
TGR_1.2V on TOP: 112.87,88.01 112.44,88.45 112.44,88.65 112.24,88.85 111.47,88.85 111.45,88.83 111.45,88.5 111.73,88.22 111.73,87.07 111.6,86.95 111.6,86.19 111.73,86.06 112.24,86.06 112.49,86.31 112.49,86.77 113.3,87.58 113.3,87.89 113.18,88.01
TGR_1.2V on IN05: 109.35,88.27 113.79,88.27 113.92,88.14 113.92,86.74 113.79,86.61 110.49,86.61 109.98,86.11 109.98,82.55 109.6,82.17 106.68,82.17 106.55,82.3 106.55,83.19 106.68,83.31 108.2,83.31 108.46,83.57 108.46,87.38
UG_3V on TOP (solid shape): 47.25,15.61 47.25,15.36 46.63,14.74 45.69,14.74 45.61,14.81 45.61,14.91 45.66,14.96 46.35,14.96 46.45,15.07 46.45,15.57 46.75,15.88 46.99,15.88
UG_5V on TOP: 43.18,14.74 42.62,14.74 42.04,15.32 42.04,15.72 42.14,15.82 42.6,15.82 43.43,14.99 43.43,14.86 43.31,14.73 43.19,14.73
V_PATH on TOP: 35.78,25.99 39.08,25.99 39.21,26.11 39.21,27.38 39.59,27.77 39.59,29.04 39.72,29.16 40.74,29.16 41.37,29.8 41.37,36.15 40.99,36.53 38.07,36.53 37.81,36.78 37.81,37.29 37.69,37.42 37.05,37.42 36.93,37.29 36.93,36.78 36.67,36.53 35.4,36.53 35.02,36.15 35.02,26.75
N16827117 on TOP: 30.07,103.08 31.08,103.08 31.21,102.95 31.21,92.66 30.96,92.41 30.32,92.41 29.94,92.79 29.94,102.95
N16827394 on TOP: 18.89,107.14 18.89,105.36 21.3,105.36 21.3,107.14
N17011706 on TOP: 269.26,37.32 267.76,37.32 267.74,37.34 267.74,37.72 268.29,38.28 268.29,38.94 268.42,39.07 269.62,39.07 269.69,38.99 269.69,37.75
N17011853 on TOP: 275.53,37.32 277.69,37.32 278,37.01 278.48,37.01 278.56,37.09 278.56,37.65 278.33,37.87 277.46,37.87 277.31,38.03 277.31,38.69 277.24,38.76 276.9,38.76 276.83,38.69 276.83,38 276.7,37.87 275.51,37.87 275.46,37.82 275.46,37.39
N17738807 on TOP: 276.96,46.43 276.96,44.91 278.35,44.91 278.35,46.43
N17791539 on TOP: 276.32,44.91 275.05,44.91 274.92,45.04 274.92,46.31 275.05,46.43 276.32,46.43 276.45,46.31 276.45,45.04
N18288666 on TOP: 110.08,21.67 110.97,20.78 110.97,14.3 110.46,13.8 101.57,13.8 100.81,14.56 100.81,18.37 101.19,18.75 102.2,18.75 102.46,19 102.46,19.26 102.84,19.64 103.47,19.64 104.11,20.27 104.11,21.42 104.36,21.67
N18346922 on BOTTOM (solid shape): 249.78,197.18 249.78,194.9 249.65,194.77 249.02,194.77 248.89,194.9 248.89,197.18 249.02,197.31 249.65,197.31
N18349859 on BOTTOM (solid shape): 213.07,197.31 213.07,195.28 212.95,195.15 212.31,195.15 212.19,195.28 212.19,197.31 212.31,197.44 212.95,197.44
N18350280 on BOTTOM (solid shape): 225.39,197.06 225.39,195.02 225.27,194.9 224.63,194.9 224.5,195.02 224.5,197.06 224.63,197.18 225.27,197.18
N18842312 on TOP (solid shape): 31.5,25.27 31.5,23.37 31.37,23.24 30.23,23.24 30.1,23.37 30.1,25.27 30.23,25.4 31.37,25.4
N20073337 on BOTTOM: 255.57,197.23 255.57,196.22 255.67,196.12 256.97,196.12 257.07,196.22 257.07,197.29 256.97,197.39 255.72,197.39
N20074453 on BOTTOM: 267.76,197.23 267.76,196.22 267.86,196.12 269.16,196.12 269.26,196.22 269.26,197.29 269.16,197.39 267.91,197.39
N20076374 on BOTTOM: 218.99,197.23 218.99,196.22 219.09,196.12 220.39,196.12 220.49,196.22 220.49,197.29 220.39,197.39 219.15,197.39
N20077877 on BOTTOM: 231.18,197.23 231.18,196.22 231.29,196.12 232.58,196.12 232.68,196.22 232.68,197.29 232.58,197.39 231.34,197.39
N20138043 on TOP: 113,86.95 114.52,86.95 114.78,86.69 114.78,86.06 114.65,85.93 113,85.93 112.87,86.06 112.87,86.82
N20153824 on TOP (solid shape): 269.08,64.72 269.08,58.35 269.96,57.47 269.96,53.46 270.35,53.06 270.35,49.86 270.1,49.61 268.07,49.61 267.94,49.74 267.94,53.04 267.43,53.55 267.43,63.94 268.4,64.9 268.9,64.9
N20154004 on TOP: 271.57,61.5 271.11,61.04 271.11,59.19 270.99,59.06 270.99,54.87 271.55,54.31 274.16,54.31 274.36,54.11 276.24,54.11 276.57,54.44 276.57,56.72 276.32,56.98 273.02,56.98 272.64,57.36 272.64,59.13 272.38,59.39 272.38,61.5
N20172556 on BOTTOM: 173.48,185.55 173.58,185.65 174.87,185.65 174.97,185.55 174.97,184.36 174.47,183.85 173.7,183.85 173.48,184.08
N20172566 on BOTTOM: 169.89,185.63 169.92,185.65 173.27,185.65 173.35,185.58 173.35,180.7 172.43,179.78 171.04,179.78 170.91,179.66 166.08,179.66 165.7,180.04 165.7,183.47 165.96,183.72 166.72,183.72 166.97,183.98 166.97,184.86 167.74,185.63
N20172725 on BOTTOM: 158.78,185.18 159.25,185.65 162.48,185.65 162.55,185.58 162.55,184.23 161.89,183.57 161.89,181.97 161.06,181.13 154.08,181.13 153.71,180.76 151.75,180.76 151.51,181 151.51,183.67 152.2,184.35 154.18,184.35 155.01,185.18
N20172772 on BOTTOM: 162.68,185.55 162.78,185.65 164.05,185.65 164.18,185.53 164.18,184.1 164.05,183.98 163.04,183.98 162.68,184.33
N20172887 on BOTTOM: 154.37,185.05 153.85,184.53 151.96,184.53 151.54,184.1 151.28,184.1 151.08,184.3 151.08,184.43 151.73,185.08 151.73,185.87 152.5,186.64 154.23,186.64 154.37,186.5
N21283256 on BOTTOM: 255.06,64.72 255.06,64.37 254.2,63.5 254.2,61.07 254.04,60.91 253.38,60.91 253.31,60.99 253.31,63.78 253.38,63.86 253.51,63.86 253.79,64.14 253.79,64.82 253.89,64.93 254.86,64.93
N21283256 on IN08: 242.46,59.24 242.46,58.19 242.72,57.94 247.11,57.94 249.6,60.43 252.77,60.43 253.82,61.47 253.82,62.36 253.74,62.44 253.08,62.44 252.5,61.85 248.86,61.85 246.81,59.8 243.02,59.8
N21871531 on TOP: 78.58,21.92 78.58,21.16 78.2,20.78 78.2,20.27 78.33,20.15 78.96,20.15 79.09,20.27 79.85,20.27 79.98,20.4 79.98,21.8 79.85,21.92
N22751755 on BOTTOM: 182.34,196.17 184.37,196.17 184.5,196.04 184.5,194.49 184.35,194.34 182.42,194.34 182.34,194.42
N22806527 on TOP (solid shape): 29.69,26.5 29.69,20.78 29.43,20.53 23.08,20.53 22.57,21.03 22.57,26.88 22.96,27.26 28.92,27.26
N22807451 on BOTTOM: 84.3,21.8 92.81,21.8 93.31,21.29 93.31,18.29 93.06,18.03 90.42,18.03 90.17,18.29 84.3,18.29 84.04,18.54 84.04,21.54
N23081959 on BOTTOM: 189.83,179.78 188.94,180.67 188.94,181.31 189.33,181.69 189.33,183.34 189.58,183.59 190.85,183.59 191.1,183.85 191.1,185.25 191.51,185.65 194.84,185.65 194.94,185.55 194.94,184.84 196.44,183.34 196.44,180.17 196.06,179.78
N23081993 on BOTTOM: 196.06,183.98 195.07,184.97 195.07,185.55 195.17,185.65 196.44,185.65 196.54,185.55 196.54,184.08 196.44,183.98
N23083331 on BOTTOM: 178.91,183.59 179.17,183.85 179.17,184.1 180.72,185.65 184.04,185.65 184.14,185.55 184.14,184.84 185.64,183.34 185.64,180.17 185.26,179.78 177.77,179.78 176.88,180.67 176.88,181.31 177.13,181.56 177.13,182.96 177.77,183.59
N23083370 on BOTTOM: 185.26,183.98 184.27,184.97 184.27,185.58 184.35,185.65 185.64,185.65 185.74,185.55 185.74,184.08 185.64,183.98
N23089660 on BOTTOM: 201.9,185.88 201.9,184.36 201.77,184.23 200.5,184.23 200.37,184.36 200.37,185.12 200.74,185.49 200.74,185.88 200.78,185.92 201.86,185.92
N23089662 on BOTTOM: 205.84,185.5 205.84,184.86 207.36,183.34 207.36,180.17 206.98,179.78 200.76,179.78 199.84,180.7 199.84,181.74 200.25,182.15 200.25,183.47 200.37,183.59 201.9,183.59 202.15,183.85 202.15,185.37 202.41,185.63 205.71,185.63
N23089706 on BOTTOM: 205.96,185.63 205.96,184.99 206.98,183.98 207.36,183.98 207.49,184.1 207.49,185.63 207.36,185.75 206.09,185.75
N23165924 on TOP: 165.58,186.64 165.58,185.88 164.56,184.86 164.31,184.86 164.05,184.61 164.05,183.85 164.18,183.72 164.94,183.72 166.34,185.12 166.34,186.52 166.21,186.64
N23166841 on TOP: 176.48,186.71 176.48,186.14 175.97,185.63 175.97,185.39 175.99,185.37 175.99,184.87 176.37,184.48 177.38,184.48 177.66,184.76 177.66,185.34 177.19,185.8 177.19,186.66 177.1,186.75 176.53,186.75
N25389389 on TOP (solid shape): 48.1,34.62 48.1,30.43 46.58,28.91 46.58,28.53 42.01,28.53 41.88,28.65 41.88,34.75 42.07,34.94 47.78,34.94
N25407327 on BOTTOM (solid shape): 261.84,197.06 261.84,195.02 261.72,194.9 261.08,194.9 260.95,195.02 260.95,197.06 261.08,197.18 261.72,197.18
N25470408 on BOTTOM: 152.24,200.87 153.51,200.87 153.77,200.61 153.77,199.34 153.64,199.22 153.13,199.22 152.75,199.6 152.75,199.72 152.5,199.98 152.24,199.98 152.11,200.1 152.11,200.74
N25470408 on BOTTOM: 152.59,200.87 153.5,200.87 153.65,200.72 153.65,199.4 153.37,199.12 152.66,199.12 152.56,199.02 152.28,199.02 152.16,199.15 152.16,199.96 152.18,199.99 152.18,200.47
N33525205 on BOTTOM (solid shape): 212.31,161.5 212.31,160.23 212.06,159.97 210.03,159.97 209.77,160.23 209.77,161.12 210.28,161.62 212.19,161.62
N33598415 on BOTTOM: 243.38,197.23 243.38,196.22 243.48,196.12 244.77,196.12 244.88,196.22 244.88,197.29 244.77,197.39 243.53,197.39
N33598972 on BOTTOM (solid shape): 237.46,196.93 237.46,194.9 237.33,194.77 236.7,194.77 236.57,194.9 236.57,196.93 236.7,197.06 237.33,197.06
N35284576 on BOTTOM: 208.76,123.02 208.76,124.54 209.14,124.92 211.3,124.92 211.42,124.79 211.42,123.02 211.3,122.89 208.88,122.89
N35284626 on TOP: 276.83,76.28 276.83,77.42 276.57,77.68 273.65,77.68 273.53,77.55 273.53,76.28 273.65,76.15 274.8,76.15 274.92,76.28 276.19,76.28 276.32,76.15 276.7,76.15
N36026261 on TOP (solid shape): 45.64,10.6 45.64,10.01 45.56,9.93 43.5,9.93 43.45,9.99 43.45,10.65 44.44,11.64 44.6,11.64
N36026271 on TOP (solid shape): 45.82,20.02 45.82,16.84 45.05,16.08 45.05,15.19 44.8,15.19 44.8,16.84 45.18,17.22 45.18,19.76 44.93,20.02 44.29,20.02 44.04,20.27 44.04,20.78 44.16,20.91 44.93,20.91
N36217862 on TOP: 211.17,124.03 211.93,124.03 212.06,123.9 217.9,123.9 218.41,123.4 218.41,121.75 218.28,121.62 217.52,121.62 217.39,121.75 211.3,121.75 211.04,122 211.04,123.9
N39195476 on TOP: 211.93,157.05 211.93,160.73 212.57,161.37 217.39,161.37 217.65,161.12 217.65,158.58 218.28,157.94 218.66,157.94 218.79,157.81 218.79,156.92 218.66,156.8 212.19,156.8
N39291118 on TOP: 290.29,170.26 297.66,170.26 297.78,170.13 297.78,166.58 297.4,166.2 290.16,166.2 289.91,166.45 289.91,169.88
N40181492 on TOP (solid shape): 275.97,16.26 275.97,12.95 276.22,12.7 276.48,12.7 276.61,12.57 276.61,11.56 276.48,11.43 272.29,11.43 272.16,11.56 272.16,12.7 272.03,12.83 269.87,12.83 269.75,12.95 269.75,15.37 269.87,15.49 272.67,15.49 273.56,16.38 275.84,16.38
N40181529 on TOP (solid shape): 280.8,18.54 280.8,17.65 281.18,17.27 282.83,17.27 283.34,16.76 283.34,15.24 283.72,14.86 283.72,13.97 283.59,13.84 280.92,13.84 280.67,13.59 279.4,13.59 279.27,13.72 279.27,18.54 279.4,18.67 280.67,18.67

Small or netless copper shapes (teardrops, artwork): 53 on TOP, 8 on BOTTOM

## Text on the board
Ref Des/Silkscreen Bottom: Pb | e1 | REV:1.0 | Gaming Y | HF | 2017/02/23 | DY730 NM-B311 | +5V | GND | TXD | RXD | +3V | RTCRST_N
DEVICE_TYPE_TOP: TOP
COMPVAL_TYPE_BOTTOM: BOT
User.30: Width/space | 6.7mil | 4.5 / 4.4 | L5/L7 | L1-TOP | L2-GND1 | L3-IN1 | L4-VCC | L5-IN2 | L6-IN3 | L7-GND2 | L8-BOT | LAYER | NAME | 88 ohm | Ref
User.31: FIGURE | SIZE | 8.0 | 10.0 | 16.0 | 28.0 | 36.0 | 98.0 | 118.0 | 118.2 | 126.0 | 166.0 | 26.0 | 43.0 | 55.0 | 63.0 | 49.0x26.0 | 55.0x20.0 | 56.0x32.0 | 63.0x20.0 | 65.0x16.0 | 67.0x24.0 | 67.0x35.0 | 74.0x32.0 | 83.0x35.0 | 87.0x24.0 | 91.0x28.0 | 104.0x28.0 | 110.0x35.0 | 197.0x118.0 | 37.0x26.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 83 | 308 | 3375 | 6848 | 500 | 9 | 12 | 8 | 15 | 3 | 1 | 6 | 7 | 4 | 2
