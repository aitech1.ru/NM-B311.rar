# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NOVO_BTN_N_R: length 2.8
  BOTTOM w0.089: v1(34.13,48.59) 34.09,48.56 34.09,48.25 33.62,47.78 R265.1
  BOTTOM w0.097: v1(34.13,48.59) 34.27,48.74 U5.A5
NVVDD_PSI: length 268
  TOP w0.097: v2(299.56,184.71) 299.52,184.71 298.98,185.25 PR820.2 PR3528.1
  IN05 w0.091: v2(214.6,89.36) 215.23,90 239.47,90 239.79,90.31 239.79,104.65 241.27,106.12 241.27,108.9 241.43,109.07 241.43,110.5 242.27,111.33 v2(242.89,111.33) ; v2(304.9,81.36) 304.39,81.87 304.39,82.5 304.26,82.63 304.26,90.97 304.79,91.5 304.79,92.05 306.17,93.42 306.65,93.42 307.34,94.12 307.34,101.77 306.04,103.08 303.98,103.08 302.79,104.27 302.79,106.67 304.86,108.74 304.86,109.77 305.53,110.44 305.53,121.62 306.42,122.51 306.42,170.89 300.7,176.61 300.7,179.91 299.31,181.31 299.31,182.71 299.69,183.09 299.69,184.59 v2(299.56,184.71)
  IN10 w0.091: v2(304.9,81.36) 304.13,80.6 302.23,80.6 301.09,79.45 297.91,79.45 296.5,80.86 277.46,80.86 277.09,81.23 267.18,81.23 266.95,81 250.26,81 249.9,81.36 242.28,81.36 239.24,84.41 239.24,86.61 239.87,87.25 239.87,98.76 242.92,101.81 242.92,110.95 242.89,110.99 v2(242.89,111.33)
  BOTTOM w0.097: v2(214.6,89.36) 214.47,89.49 v1(214.47,90.25) 214.8,90.58 PR3570.2 ; R977.2 244.19,110.44 243.3,111.33 v2(242.89,111.33) ; 241.65,113.49 241.49,113.66 G2.BD2
  BOTTOM w0.1: 241.65,113.49 241.81,113.33 241.81,111.81 242.28,111.33 v2(242.89,111.33)
NVVDD_PWM_VID: length 215.4
  TOP w0.097: PR1467.1 297.91,186.39 v2(298.04,186.26)
  IN05 w0.091: v2(298.04,186.26) 297.28,185.5 297.28,179.53 303.88,172.93 303.88,164.27 306.04,162.11 306.04,122.51 305.28,121.75 305.28,110.7 304.55,109.97 304.55,108.76 302.57,106.78 302.57,104.13 305.02,101.68 305.02,100.92 305.28,100.66 306.29,100.66 307.13,99.83 307.13,94.21 306.59,93.68 306.04,93.68 304.51,92.15 304.51,91.53 304.01,91.03 304.01,82.47 303.88,82.35 v2(303.88,81.99)
  IN10 w0.091: v3(241.79,116.97) 242.49,116.97 243.94,115.52 243.94,110.57 243.67,110.31 243.67,101.56 240.63,98.52 240.63,84.1 242.65,82.08 250.29,82.08 250.92,81.45 266.51,81.45 266.8,81.74 277.43,81.74 277.72,81.45 297.82,81.45 297.91,81.36 303.24,81.36 v2(303.88,81.99)
  BOTTOM w0.097: v3(241.79,116.97) 241.49,116.67 G2.BD6
NVVDDS_B+:
  vias: v2(224.92,89.15) v2(225.81,89.15) v2(227.96,89.15) v2(228.85,89.15) v2(231.14,89.15) v2(232.03,89.15) v2(232.92,89.15)
NVVDDS_BS1: length 2.2
  BOTTOM w0.254: 215.49,96.47 215.23,96.47 215.02,96.69 PU1604.1
  BOTTOM w0.508: 215.49,96.47 215.87,96.47 216.25,96.09 PR3434.1
NVVDDS_BS2: length 3.3
  BOTTOM w0.254: PU1604.15 215.02,100.19 215.54,100.71
  BOTTOM w0.508: 215.54,100.71 215.67,100.71 216.96,102.01 PR3445.1
NVVDDS_COMP: length 3.6
  BOTTOM w0.254: PU1604.12 213.82,101.65 PC3516.1 213.79,102.06 213.53,102.31 213.53,102.57 PR3444.1 PR3446.1
NVVDDS_EN_R: length 2.7
  BOTTOM w0.097: PR3550.1 PC3505.1 PU1604.3
NVVDDS_FB: length 8.3
  BOTTOM w0.254: PR3579.2 213.05,105.29 213.48,104.85 PR3573.2 213.05,104.4 PR3441.1 212.52,104.3 212.16,103.94 212.16,102.62 ; 212.16,102.62 PC3571.2 212.69,101.86 PC3516.2 212.87,101.37 213.42,100.83 PU1604.11 ; 212.16,102.62 212.11,102.57 PR3438.1
NVVDDS_FBRTN: length 3.8
  BOTTOM w0.254: PU1604.10 212.53,99.3 212.31,99.52 212.31,99.88 211.55,100.64 PR3448.1 PC3506.1 PR3436.1
NVVDDS_FS: length 1.3
  BOTTOM w0.254: PR3440.2 211.64,99.52 212.26,98.9 PU1604.9
NVVDDS_HG1: length 29.8
  IN08 w0.508: v2(235.33,89.15) 235.33,88.9 234.06,87.63 218.44,87.63 216.63,89.44 216.63,94.65 215.18,96.09 v2(214.73,96.09)
  BOTTOM w0.254: PU1604.2 214.62,96.2 v2(214.73,96.09)
  BOTTOM w0.508: v2(235.33,89.15) 235.14,88.96 PR3591.1
NVVDDS_HG1_R: length 2
  BOTTOM w0.508: PR3591.2 236.54,88.94 235.93,89.54 PQ1411.1
NVVDDS_HG2: length 19.8
  IN08 w0.508: v2(223.14,89.15) 223.14,89.41 222.76,89.79 220.37,89.79 219.3,90.86 219.3,96.42 218.15,97.57 218.15,99.73 216.84,101.04 215.03,101.04 v2(214.9,100.92)
  BOTTOM w0.254: v2(214.9,100.92) 214.62,100.63 PU1604.14
  BOTTOM w0.508: PR3592.1 222.95,88.96 v2(223.14,89.15)
NVVDDS_HG2_R: length 1.9
  BOTTOM w0.508: PR3592.2 224.28,88.38 224.28,89.45 PQ1412.1
NVVDDS_LG1: length 24.4
  IN05 w0.508: v2(216.63,98) 219.81,94.82 223.82,94.82 224.18,94.46 224.76,94.46 225.81,95.5 236.25,95.5 v2(236.63,95.89)
  BOTTOM w0.254: PU1604.19 216.52,98.1 v2(216.63,98)
  BOTTOM w0.508: PQ1411.8 235.93,95.57 236.25,95.89 v2(236.63,95.89)
NVVDDS_LG2: length 12.6
  IN05 w0.508: v2(216.66,99.19) 220.39,95.46 224.18,95.46 v2(224.51,95.12)
  BOTTOM w0.254: PU1604.17 216.38,98.9 v2(216.66,99.19)
  BOTTOM w0.508: v2(224.51,95.12) 224.51,95.57 224.3,95.78 223.98,95.78 223.77,95.57 PQ1412.8
NVVDDS_PEX_EN: length 218.6
  TOP w0.097: R2334.2 299.56,67.43 299.61,67.48 R2244.2 ; v2(212.54,153.11) 212.19,153.11 211.32,153.98 211.32,156.39 210.92,156.8 210.28,156.8 209.9,156.42 R1009.1 ; R2244.2 299.61,68.61 v2(299.56,68.66) ; R2244.2 299.18,67.9 299.05,67.77 D2009.2 D2010.2 298.51,66.25 298.36,66.09 298.36,65.64 298.51,65.48 D2020.2 ; PR715.2 v2(219.93,162.51)
  IN08 w0.091: v2(219.93,162.51) 219.3,161.88 219.3,157.31 218.03,156.04 213.71,156.04 212.54,154.87 v2(212.54,153.11) 212.54,151.62 212.82,151.34 212.82,146.61 212.24,146.03 212.24,127.85 217,123.08 222.08,123.08 222.44,122.73 222.44,121.96 221.33,120.86 220.95,120.86 220.82,120.73 220.82,118.93 220.56,118.67 217.75,118.67 216.63,117.55 216.63,115.78 216.34,115.49 216.34,112.82 217.92,111.24 217.92,107.52 218.14,107.3 218.14,104.77 216.74,103.37 213.28,103.37 211.77,101.86 211.77,95.03 212.88,93.93 212.88,86.51 v2(213.96,85.42) 213.96,83.77 v2(218.79,78.95)
  IN10 w0.091: v2(218.79,78.95) 219.17,79.33 229.58,79.33 230.09,79.84 236.57,79.84 238.09,78.31 245.41,78.31 245.8,77.93 248.76,77.93 249.06,77.63 262.3,77.63 262.6,77.93 285.46,77.93 286.23,77.17 289.61,77.17 296.34,70.44 296.77,70.44 298.55,68.66 v2(299.56,68.66)
  BOTTOM w0.097: v2(213.96,85.42) v1(216,87.46) 216,93.49 215.25,94.24 PR3550.2
NVVDDS_PEX_EN_N: length 22.8
  TOP w0.097: v1(211.8,151.59) 211.17,150.96 209.77,150.96 209.57,151.16 R1010.2 209.52,151.64 Q92.5 ; Q104.4 218.41,161.4 218.19,161.62 212.06,161.62 208.5,158.07 208.5,153.5 208.88,153.11 209.39,153.11 209.52,152.99 Q92.5 ; Q92.5 Q92.6
NVVDDS_PSI: length 56
  TOP w0.097: v3(240.39,115.65) 241.14,114.89 243.81,114.89 244.75,115.83 R1002.2
  IN05 w0.091: v3(240.39,115.65) 240.63,115.4 240.63,114.25 240.25,113.87 239.49,113.87 239.36,113.74 239.36,111.33 238.94,110.91 238.61,110.91 235.25,107.55 235.25,104.68 234.56,103.99 220.07,103.99 217.63,101.55 211.8,101.55 211.55,101.3 211.55,97.49 215.57,93.47 v2(215.57,93.3)
  BOTTOM w0.097: PR3456.2 215.57,92.92 v2(215.57,93.3) ; v3(240.39,115.65) 240.49,115.65 240.79,115.94 G2.BE5
NVVDDS_PSI_R: length 9.1
  BOTTOM w0.097: PR3570.1 PR3456.1 213.25,92.79 v1(211.75,92.79) 211.75,94.77 212.13,95.15 PR3428.2 PR3454.2 213.33,95.46 213.82,95.95 PU1604.4
NVVDDS_PVCC: length 2.8
  BOTTOM w0.254: PU1604.18 216.5,98.5 216.55,98.56 216.76,98.56
  BOTTOM w0.356: 216.76,98.56 217.27,98.56 PC3509.1 217.32,97.37 PR3442.2
NVVDDS_PWM_VID: length 56.3
  IN05 w0.091: v2(240.76,110.57) 240.76,106.47 238.6,104.31 238.6,91.31 237.94,90.66 217.88,90.66 216.25,92.28 212.69,92.28 211.55,93.42 211.55,93.65 211.14,94.06 210.66,94.06 210.41,93.81 v2(210.41,93.55)
  BOTTOM w0.097: PR3439.1 v2(210.41,93.55)
  BOTTOM w0.1: G2.BE4 241.13,114.92 241.13,112.99 241.27,112.86 241.27,111.97 240.76,111.46 v1(240.76,111.2) v2(240.76,110.57)
NVVDDS_PWROK: length 139.5
  TOP w0.097: Q97.2 291.61,76.53 290.93,75.85 R2263.2 288.97,75.85 v2(288.89,75.77) ; D2017.2 D71.1 288.48,71.58 287.97,71.58 v2(287.62,71.23) 287.34,71.23 286.86,71.71 v1(286.86,72.22) 286.86,72.98 287.02,73.14 D2013.2
  IN03 w0.091: v2(288.89,75.77) 289.53,75.14 289.53,73.14 v2(287.62,71.23)
  IN08 w0.091: v2(287.62,71.23) 286.89,71.96 284.45,71.96 283.69,71.2 280.38,71.2 279.75,70.56 279.75,68.41 279.37,68.02 276.85,68.02 275.73,69.14 275.73,69.85 274.2,71.38 259.12,71.38 258.56,71.95 258.56,74.23 258.14,74.64 253.73,74.64 252.19,73.1 252.19,72.6 251.68,72.09 250.54,72.09 246.86,68.41 243.81,68.41 243.68,68.28 242.67,68.28 242.03,68.91 240.63,68.91 239.74,69.8 235.55,69.8 235.3,69.55 233.27,69.55 233.14,69.68 233.14,71.84 232.76,72.22 229.9,72.22 225.07,77.04 214.22,77.04 211.55,79.71 211.55,89.74 209.77,91.52 209.77,94.19 210.85,95.27 210.85,102.45 213.61,105.21 215.33,105.21 215.91,104.63 v2(216.12,104.63)
  BOTTOM w0.097: PR3426.2 216.25,103.97 216.12,104.09 v2(216.12,104.63)
NVVDDS_PWROK_N: length 38
  TOP w0.097: v2(298.57,58.19) 298.57,59.37 298.42,59.51 298.42,61.81 302.23,65.61 v1(302.23,66.5) 301.91,66.82 301.91,68.47 299.56,70.82 299.56,73.74 299.05,74.25 299.05,75.01 298.75,75.31 297.86,75.31 297.66,75.52 297.66,76.28 296.39,77.55 294.41,77.55 R2261.2 ; Q97.6 292.96,77.04 R2261.2 ; R2261.2 293.85,76.99 293.85,76.03 293.01,75.18 291.93,75.18 291.7,75.41 Q97.3 ; Q98.2 v2(303.37,56.47)
  IN10 w0.091: v2(298.57,58.19) 301.64,58.19 v2(303.37,56.47)
NVVDDS_REFIN: length 5.1
  BOTTOM w0.254: PU1604.7 212.14,98.1 211.63,97.59 PC3570.1 211.63,97.16 211.4,96.93 PR3540.2 PR3432.1
NVVDDS_TGR1: length 29.1
  IN08 w0.508: v2(234.44,89.15) 234.44,88.93 233.78,88.27 218.74,88.27 217.3,89.71 217.3,95.12 216.95,95.47 v2(216.95,96.41)
  BOTTOM w0.254: PU1604.20 216.03,97.7 216.25,97.49
  BOTTOM w0.508: PC3515.2 217.52,95.84 v2(216.95,96.41) 216.5,96.85 216.5,97.23 216.25,97.49 ; PQ1411.2 234.44,89.82 v2(234.44,89.15)
NVVDDS_TGR2: length 18.1
  IN08 w0.508: v2(216.63,100.28) 217.42,99.49 217.42,97.33 218.54,96.22 218.54,90.53 219.91,89.15 v2(222.25,89.15)
  BOTTOM w0.254: PU1604.16 215.91,99.3 216.12,99.52 216.12,99.77
  BOTTOM w0.508: PC3519.2 217.11,100.77 v2(216.63,100.28) 216.12,99.77 ; PQ1412.2 222.25,89.72 v2(222.25,89.15)
NVVDDS_VID_R: length 4.3
  BOTTOM w0.097: PR3439.2 PC3510.1 211.86,95.71 212.95,95.71 213.42,96.18 PU1604.5
NVVDDS_VIDBUF: length 2
  BOTTOM w0.254: PU1604.6 212.53,97.7 212.44,97.62 212.44,96.98 211.8,96.35 PR3433.2
NVVDDS_VREF: length 3.9
  BOTTOM w0.254: PR3431.1 209.7,98.12 209.77,98.05 211.35,98.05 211.63,98.33 PC3507.1 211.75,98.5 PU1604.8
OC_WARN: length 247.8
  TOP w0.097: R986.2 250.92,107.52 251.71,108.31 251.71,112.73 251.43,113.01 251.07,113.01 250.92,112.86 248.65,112.86 248.39,113.11 244.82,113.11 v3(244.57,112.86)
  IN05 w0.091: v2(305.78,83.77) 306.29,84.28 306.29,91.42 308.03,93.15 308.03,102.67 306.78,103.92 304.18,103.92 303.45,104.65 303.45,106.26 304.21,107.01 305.4,107.01 307.05,108.66 307.05,111.33 306.29,112.09 306.29,121.24 307.18,122.13 307.18,171.28 302.04,176.42 302.04,180.74 301.09,181.69 301.09,183.09 301.47,183.47 301.47,192.99 297.91,196.55 297.4,196.55 297.15,196.29 v2(296.89,196.29)
  IN10 w0.091: v3(244.57,112.86) 245.59,112.86 246.48,111.97 246.48,111.59 244.74,109.85 244.74,106.04 244.19,105.49 244.19,101.19 241.14,98.14 241.14,84.33 242.96,82.52 250.6,82.52 251.23,81.89 266.31,81.89 266.67,82.25 277.72,82.25 278.08,81.89 297.93,81.89 299.18,83.14 305.15,83.14 v2(305.78,83.77)
  BOTTOM w0.097: v2(296.89,196.29) 296.89,195.41 297.43,194.87 PR35.2 298.21,194.56 298.63,194.14 PR31.2
  BOTTOM w0.1: G2.BB4 243.23,114.92 243.23,113.05 243.55,112.73 244.44,112.73 v3(244.57,112.86)
PA_USB2_RBIAS: length 2.2
  TOP w0.076: 48.81,81.51 48.94,81.64 48.94,82.15 v1(49.27,82.48)
  TOP w0.178: 48.81,81.51 48.81,81.25 R2046.1
  BOTTOM w0.178: v1(49.27,82.48) 48.95,82.81 U2005.H19
PB_USB2_RBIAS: length 2.3
  TOP w0.178: R2047.2 47.72,81.59 48.61,82.48 v1(48.62,82.48)
  BOTTOM w0.178: v1(48.62,82.48) 48.3,82.81 U2005.F19
PC_BEEP: length 3.7
  TOP w0.097: C330.1 287.7,27.38 288.89,28.58 288.89,29.09 288.73,29.25 U7.23
PCH_2_CPU_TRIGGER: length 226.8
  TOP w0.097: v2(173.45,53.42) 173.45,41.26 v2(173.99,40.72)
  IN08 w0.091: v2(173.45,53.42) 172.56,52.53 170.78,52.53 169.89,53.42 169.89,72.85 169.13,73.61 169.13,102.95 194.91,128.73 194.91,131.52 195.42,132.03 195.42,141.18 191.36,145.24 189.96,145.24 189.05,146.16 186.13,146.16 185.73,146.55 v2(185.72,146.55)
  IN10 w0.091: v2(173.99,40.72) 174.64,40.07 184.72,40.07 186,41.35 203.93,41.35 207.04,44.47 211.99,44.47 215.46,40.99 246.81,40.99 250.29,44.47 250.29,46.19 251.05,46.95 251.05,49.87 251.75,50.57 251.75,56.53 252.03,56.81 253,56.81 253.43,56.39 v2(253.71,56.39)
  BOTTOM w0.097: R203.1 252.83,57.23 253.67,56.39 v2(253.71,56.39)
  BOTTOM w0.102: v2(185.72,146.55) 185.34,146.93 U1.H23
PCH_2_CPU_TRIGGER_R: length 4.5
  BOTTOM w0.097: R203.2 250.72,56.72 250.41,56.72 249.83,57.3 248.72,57.3 247.77,58.25 U2.AL2
PCH_CLKRUN_N: length 8.6
  TOP w0.097: v3(238.17,49.74) 238.17,50.47 238.98,51.29 238.98,52.53 238.86,52.66 238.86,54.31 v3(238.47,54.69)
  BOTTOM w0.097: v3(238.17,49.74) 238.09,49.74 236.65,48.29 R136.2 ; U2.AW22 237.87,54.09 v3(238.47,54.69)
PCH_CS0_N: length 222.2
  TOP w0.097: R937.2 217.29,49.38 v2(217.29,48.47)
  IN03 w0.091: v2(31.59,40.34) 32.35,41.1 32.35,43.51 33.42,44.58 45.88,44.58 47.1,45.8 48.61,45.8 49.37,45.04 52.33,45.04 53.57,46.28 61.03,46.28 63.83,49.08 71.45,49.08 75.28,52.91 87.22,52.91 88.87,54.56 95.6,54.56 95.98,54.18 97,54.18 98.39,55.58 104.77,55.58 106.17,56.98 125.68,56.98 127.2,55.45 155.04,55.45 160.62,49.86 175.1,49.86 175.86,49.1 201.52,49.1 202.47,48.15 212.89,48.15 213.33,47.7 216,47.7 216.76,48.47 v2(217.29,48.47)
  IN10 w0.091: v3(231.87,48.97) 231.41,48.97 229.76,47.32 224.52,47.32 224.02,47.83 221.84,47.83 221.1,48.57 217.39,48.57 v2(217.29,48.47)
  BOTTOM w0.097: U2.BD31 233.27,50.5 232.94,50.17 232.53,50.17 232.25,49.89 232.25,49.36 v3(231.87,48.97) ; RP4.1 31.73,40.48 v2(31.59,40.34) ; U3.1 217.65,48.82 v2(217.29,48.47)
PCH_GPP_B23: length 1.8
  TOP w0.097: R547.2 235.3,55.63 v3(234.92,55.25)
  BOTTOM w0.097: v3(234.92,55.25) 235.2,55.53 235.43,55.53 U2.AT27
PCH_GPP_E8: length 3.9
  BOTTOM w0.097: TP160.1 223.39,61.45 v1(223.56,61.45) 226.03,61.45 226.16,61.57 U2.AD44
PCH_GPP_F6: length 4.2
  BOTTOM w0.076: U2.AB42 227.48,63 226.21,63
  BOTTOM w0.097: TP170.1 225.27,63.33 225.52,63.07 226.13,63.07 226.21,63
PCH_GPP_F7: length 4.1
  BOTTOM w0.076: U2.AB43 227.12,62.82 226.54,62.82 226.41,62.69
  BOTTOM w0.097: TP171.1 224.12,62.31 v1(224.38,62.56) 224.5,62.69 226.41,62.69
PCH_GPP_F8: length 1.4
  TOP w0.097: v1(231.11,61.67) v3(230.7,62.08)
  BOTTOM w0.097: U2.AB36 230.55,62.23 v3(230.7,62.08)
PCH_GPP_F9: length 1.7
  TOP w0.097: v3(229.71,62.06) 229.33,61.67 TP169.1
  BOTTOM w0.097: v3(229.71,62.06) 229.03,62.74 U2.AB39
PCH_GPP_G18: length 6.1
  BOTTOM w0.076: U2.N43 227.1,67.39 226.66,67.39 225.8,66.53
  BOTTOM w0.097: v1(223.23,67.14) 223.23,66.75 223.06,66.58 R303.1 223.31,65.87 224.28,65.87 224.94,66.53 225.8,66.53
PCH_HOLD_N: length 34.1
  TOP w0.097: R126.1 233.19,51.34 v3(233.65,50.88)
  IN10 w0.091: v3(233.65,50.88) 233.27,51.26 232.38,51.26 232,50.88 231.11,50.88 230.47,50.24 226.16,50.24 225.96,50.44 224.5,50.44 223.94,51.01 222.23,51.01 219.81,53.42 217.82,53.42 217.39,53.85 213.12,53.85 v2(212.69,53.42)
  BOTTOM w0.097: U2.BD30 233.65,51.64 v3(233.65,50.88) ; v2(212.69,53.42) 212.44,53.67 212.44,58.53 v1(212.67,58.75) 213.76,59.85 R120.1
PCH_HOLD_N_R: length 3.7
  BOTTOM w0.097: v1(214.57,58.93) R120.2 R118.1 U3.7
PCH_I2C_CLK0: length 80
  TOP w0.097: v3(229.84,55.58) 229.46,55.2 228.7,55.2 227.93,54.44 223.82,54.44 R109.1 ; v2(264.51,25.35) 264.51,25.81 R321.1
  IN08 w0.091: v3(229.84,55.58) 229.97,55.58 230.6,56.21 234.92,56.21 235.74,57.04 236.25,57.04 236.44,56.85 236.44,55.83 237.71,54.56 237.71,53.04 237.97,52.78 238.73,52.78 239.24,52.28 239.87,52.28 240.38,52.78 241.14,52.78 241.52,52.4 242.03,52.4 242.41,52.78 243.17,52.78 243.81,52.15 246.86,52.15 247.75,53.04 247.75,53.93 248.19,54.37 252.89,54.37 253.46,54.94 254.73,54.94 256.13,53.55 v2(256.64,53.55)
  IN10 w0.091: v2(256.64,53.55) 256.64,52.53 257.78,51.39 264.51,51.39 265.65,50.24 265.65,26.5 v2(264.51,25.35)
  BOTTOM w0.097: v3(229.84,55.58) 229.81,55.61 U2.AR38
PCH_I2C_CLK1: length 222.6
  TOP w0.089: 76.55,11.69 76.22,11.69 v1(76.04,11.51)
  TOP w0.097: 76.55,11.69 R879.2 ; v3(228.19,55.58) 227.68,55.07 226.92,55.07 226.41,55.58 v1(226,55.58) 223.56,55.58 R106.1
  IN03 w0.091: v2(137.89,38.81) 137.89,39.45 132.86,44.48 122.11,44.48 120.14,42.51 120.14,40.3 117.54,37.7 114.79,37.7 108.71,31.62 99.2,31.62 96.76,29.18 82.16,29.18 81.38,28.4 78.33,28.4 77.44,29.29 73.37,29.29 70.96,31.7 v2(70.06,31.7)
  IN08 w0.089: v1(76.04,11.51) 76.04,14.43 75.66,14.81 73.37,14.81 72.74,14.18 72.74,10.62 72.36,10.24 70.71,10.24 70.48,10.47 70.48,14.12 69.54,15.07
  IN08 w0.091: v2(70.06,31.7) 70.06,25.1 69.01,24.04 69.01,15.6 69.54,15.07
  IN10 w0.091: v2(137.89,38.81) 138.53,39.45 138.53,41.81 148.36,51.64 167.63,51.64 169.92,53.93 174.64,53.93 175.53,54.82 186.02,54.82 187.45,56.24 194.84,56.24 195.57,56.98 203.68,56.98 204.32,57.61 217.27,57.61 218.19,58.54 220.89,58.54 223.85,55.58 v3(228.19,55.58)
  BOTTOM w0.097: v3(228.19,55.58) 228.29,55.68 U2.AR41
PCH_I2C_CLK2: length 248.9
  IN03 w0.091: v2(136.62,40.08) 132.47,44.24 122.21,44.24 120.36,42.39 120.36,40.21 117.63,37.48 114.88,37.48 108.77,31.37 99.35,31.37 96.94,28.96 82.32,28.96 81.5,28.15 78.07,28.15 77.18,29.04 73.23,29.04 71.05,31.22 68.4,31.22 67.02,32.59 58.39,32.59 57.75,33.23 47.47,33.23 45.11,35.59 44.48,35.59 44.17,35.89 42.77,35.89 41.93,36.73 41.93,39.02 40.48,40.47 39.34,40.47 v2(39.21,40.59)
  IN05 w0.089: 29.81,58.37 30.04,58.14 30.04,54.21 30.83,53.42 30.83,50.55 31.88,49.5 31.88,47.35 31.37,46.84 31.37,46.69
  IN05 w0.091: 31.37,46.69 31.37,43.23 34.9,39.69 38.31,39.69 v2(39.21,40.59) ; v3(29.56,58.63) 29.81,58.37
  IN10 w0.091: v3(224.89,57.48) 224.89,58.25 223.23,59.9 220.19,59.9 219.93,60.15 218.28,60.15 216.5,58.37 186.53,58.37 186.02,57.86 186.02,56.59 185.01,55.58 174.97,55.58 174.09,54.69 169.28,54.69 167.12,52.53 147.67,52.53 136.62,41.48 v2(136.62,40.08)
  BOTTOM w0.089: 31.34,58.37 32.77,56.94 32.77,56.43
  BOTTOM w0.097: R548.2 223.82,57.1 224.5,57.1 v3(224.89,57.48) 225.27,57.86 226.16,57.86 226.9,58.61 U2.AK44 ; v3(29.56,58.63) 29.81,58.37 31.34,58.37 ; U5.N2 32.77,56.43
PCH_I2C_DATA0: length 77.4
  TOP w0.097: R320.1 265.2,29.04 265.14,29.04 v2(264.89,29.29)
  IN08 w0.091: v2(256.64,54.31) 257.14,54.82 257.14,55.96 255.24,57.86 254.6,57.86 254.22,58.25 248.76,58.25 247.36,56.84 242.32,56.84 241.81,57.36 237.62,57.36 237.11,57.86 229.08,57.86 227.3,56.09 226.54,56.09 225.27,54.82 v3(224,54.82)
  IN10 w0.091: v2(264.89,29.29) 265.4,29.8 265.4,49.94 264.2,51.13 257.43,51.13 256.13,52.44 256.13,53.8 v2(256.64,54.31)
  BOTTOM w0.076: 226.27,55.6 226.51,55.6 226.59,55.53 227.04,55.53 227.1,55.58 227.49,55.58 U2.AT42
  BOTTOM w0.097: 226.27,55.6 225.61,54.94 224.12,54.94 v3(224,54.82) 223.87,54.94 R111.1
PCH_I2C_DATA1: length 220.3
  TOP w0.097: v3(77.44,10.87) 77.64,10.67 R880.2
  IN03 w0.091: v2(137.89,40.08) 133.27,44.71 122.01,44.71 119.92,42.62 119.92,40.4 117.44,37.92 114.61,37.92 108.53,31.84 99.04,31.84 96.6,29.4 83.55,29.4 83.41,29.54 73.81,29.54 71.14,32.21 69.23,32.21 v2(68.72,31.7)
  IN08 w0.089: 76.55,10.47 76.06,10.47 75.79,10.75 75.79,11 75.66,11.13 75.66,11.64 75.79,11.76 75.79,14.33 75.56,14.56 73.88,14.56
  IN08 w0.091: 73.88,14.56 73.48,14.56 72.99,14.07 72.99,10.24 72.23,9.48 70.71,9.48 70.28,9.91 70.28,13.97 68.75,15.5 68.75,29.85 68.72,29.88 v2(68.72,31.7) ; 76.55,10.47 76.97,10.47 76.97,10.47 77.04,10.47 v3(77.44,10.87)
  IN10 w0.091: v3(224,55.96) 224,56.04 223.03,57.01 223.03,58.09 221.86,59.26 220.48,59.26 220.08,58.86 218.01,58.86 217.01,57.86 204.26,57.86 203.63,57.23 195.45,57.23 194.69,56.47 186.94,56.47 185.54,55.07 175.36,55.07 174.45,54.16 169.79,54.16 167.52,51.9 148.11,51.9 138.26,42.05 137.89,41.68 v2(137.89,40.08)
  BOTTOM w0.097: U2.AR44 226.32,55.83 226.16,55.83 225.77,55.45 224.63,55.45 224.12,55.96 v3(224,55.96) 223.44,55.96 R107.1
PCH_I2C_DATA2: length 249.4
  IN03 w0.091: v2(136.62,38.81) 136.62,39.45 132.05,44.02 122.3,44.02 120.58,42.3 120.58,40.1 116.64,36.16 113.87,36.16 108.86,31.15 99.44,31.15 97.03,28.75 82.48,28.75 81.63,27.89 77.91,27.89 77.06,28.75 73.21,28.75 70.96,31 68.29,31 66.95,32.34 58.13,32.34 57.5,32.97 44.04,32.97 42.77,34.24 42.77,35.51 41.71,36.57 41.71,38.86 40.48,40.08 38.83,40.08 v2(38.32,40.59)
  IN05 w0.089: 31.65,46.69 31.65,46.74 32.13,47.22 32.13,47.5 32.26,47.62 32.64,47.62 32.89,47.88 32.89,49.12 31.97,50.04 31.97,58.63
  IN05 w0.091: v2(31.97,59.13) 31.97,58.63 ; 31.65,46.69 31.65,43.33 35.07,39.91 37.64,39.91 v2(38.32,40.59)
  IN10 w0.091: v3(224.12,57.48) 224.12,58.02 222.63,59.52 220.31,59.52 219.93,59.13 217.9,59.13 216.88,58.12 186.91,58.12 186.28,57.48 186.28,56.34 185.26,55.32 175.1,55.32 174.21,54.44 169.39,54.44 167.23,52.28 147.85,52.28 137.94,42.37 137.26,41.68 137.26,39.45 v2(136.62,38.81)
  BOTTOM w0.076: U5.M3 33.27,55.42 33.53,55.67 33.53,56.21
  BOTTOM w0.097: U2.AK45 226.08,58.37 225.14,58.37 224.25,57.48 v3(224.12,57.48) 223.87,57.74 223.87,57.94 R549.2 ; v2(31.97,59.13) 32.23,58.88 32.23,58.45 32.73,57.94 33.04,57.94 33.53,57.45 33.53,56.21
PCH_INTRUDER_N: length 3.5
  TOP w0.097: R114.2 242.28,49.1 242.79,49.61 v3(242.79,49.86)
  BOTTOM w0.097: v3(242.79,49.86) 242.62,50.03 242.62,51.01 242.95,51.34 242.95,51.34 U2.BE11
PCH_ITP_PMODE: length 24.3
  TOP w0.097: R596.2 256.94,61.34 v2(256.64,61.04) 256.51,60.91 v1(255.75,60.91) ; v3(249.9,53.42) 249.9,53.67 TP61.1
  IN08 w0.091: v3(249.9,53.42) 250.34,52.99 254.53,52.99 255.11,52.4 257.02,52.4 258.41,53.8 258.41,59.01 258.03,59.39 256.89,59.39 256.64,59.64 v2(256.64,61.04)
  BOTTOM w0.097: v3(249.9,53.42) 249.9,53.8 248.76,54.94 248,54.94 247.49,55.46 U2.AT2
PCH_JTAG_TCK: length 3.3
  TOP w0.097: v1(250.03,56.09) 249.9,56.09 v2(249.52,56.47)
  BOTTOM w0.097: U2.AN3 247.32,57.15 247.63,56.84 248.95,56.84 249.32,56.47 v2(249.52,56.47)
PCH_JTAG_TDI: length 4.8
  TOP w0.097: R306.1 250.79,54.31 250.54,54.56 v1(250.16,54.56) 249.78,54.94 v2(249.78,55.2)
  BOTTOM w0.097: U2.AP2 247.86,56.24 248.76,56.24 249.78,55.22 v2(249.78,55.2)
PCH_JTAG_TDO: length 3.9
  TOP w0.097: R507.1 v2(250.54,55.2)
  BOTTOM w0.097: U2.AP1 248.82,56.59 249.45,55.96 250.03,55.96 250.54,55.45 v2(250.54,55.2)
PCH_JTAG_TMS: length 5.8
  BOTTOM w0.076: U2.AR2 248.67,55.97 249.37,55.27
  BOTTOM w0.097: R216.1 v1(251.23,53.45) 250.36,54.31 250.03,54.31 249.37,54.97 249.37,55.27
PCH_JTAGX: length 2.7
  TOP w0.097: v3(247.07,56.44) 247.82,56.44 v1(248.13,56.14) 248.18,56.19 R220.1
  BOTTOM w0.097: U2.AR3 247.07,56 v3(247.07,56.44)
PCH_LAN_WAKE_N: length 4
  BOTTOM w0.097: U2.BD11 242.98,51.77 242.42,51.22 242.42,50.23 242.28,50.09 242.28,49.36 241.89,48.96 R288.1
PCH_PECI: length 5.2
  BOTTOM w0.097: U2.AL3 247.11,58.25 247.36,57.99 247.59,57.99 247.74,57.84 247.74,57.51 248.15,57.1 249.65,57.1 250.54,56.21 R174.1
PCH_PLTRST_N: length 246.9
  TOP w0.097: v2(248.76,47.45) 248.76,46.82 248.51,46.56 R117.1
  IN03 w0.091: v2(45.74,36.96) 45.74,36.73 47.85,34.62 58.39,34.62 59.15,33.86 71.29,33.86 73.92,31.23 86.18,31.23 88.05,33.1 95.71,33.1 96.4,33.79 107.43,33.79 119.64,45.99 137.95,45.99 145.26,38.69 v2(149.57,38.69)
  IN05 w0.091: v2(248.76,47.45) 247.87,48.34 243.43,48.34 242.03,46.94 242.03,45.67 241.27,44.91 238.65,44.91 238.02,45.55 238.02,45.88 237.2,46.69 v2(237.2,46.74) 237.2,46.82 235.43,48.59 235.43,52.53 v3(234.92,53.04)
  IN10 w0.091: v2(237.2,46.74) 234.96,44.49 225.56,44.49 225.01,45.04 216.63,45.04 214.15,47.51 205.9,47.51 202.41,44.02 153.84,44.02 150.34,40.52 150.34,39.45 v2(149.57,38.69)
  BOTTOM w0.097: U2.BB27 235.15,53.04 v3(234.92,53.04) ; R835.2 v1(50.98,38.7) 50.98,37.37 50.04,36.42 46.28,36.42 v2(45.74,36.96) ; v2(248.76,47.45) 249.27,46.94 C180.1 248.92,46.64 248.76,46.8 U4.1 247.73,46.8 247.62,46.69 247.62,46.31 247.75,46.18 248.2,46.18 U4.2
PCH_PWRBTN_N: length 268.2
  TOP w0.097: v2(27.02,57.48) 26.89,57.36 TP58.1 ; v2(219.93,51.64) 220.19,51.39 R381.2
  IN05 w0.089: 30.19,46.69 30.19,52.4 29.81,52.78
  IN05 w0.091: 30.19,46.69 30.19,46.43 29.69,45.93 29.43,45.93 28.92,45.42 28.92,42.36 29.55,41.74 30.07,41.74 30.32,41.99 31.85,41.99 34.64,39.2 38.58,39.2 39.2,39.82 39.46,39.82 40.35,40.72 46.58,40.72 49.53,37.77 49.53,35.23 56.03,28.73 56.53,28.73 57.44,27.82 62.65,27.82 64.49,25.99 71.9,25.99 74.31,28.4 82.14,28.4 82.64,28.9 93.76,28.9 94.75,29.89 97.72,29.89 99.62,31.78 110.77,31.78 111.38,32.39 118.28,32.39 v2(118.71,31.96) ; 29.81,52.78 28.54,54.05 28.54,55.71 27.02,57.23 v2(27.02,57.48)
  IN08 w0.091: v2(118.71,31.96) 121.13,34.37 121.13,41.23 122.93,43.03 140.03,43.03 v2(142.97,40.08)
  IN10 w0.091: v3(241.78,55.96) 241.4,55.58 241.4,53.29 241.01,52.91 240.51,52.91 239.67,52.08 239.29,52.08 238.86,51.64 236.44,51.64 235.3,50.5 231.11,50.5 230.6,49.99 225.9,49.99 225.65,50.24 224.25,50.24 223.87,50.63 220.95,50.63 v2(219.93,51.64) 219.93,52.02 219.11,52.85 217.33,52.85 217.27,52.78 198.6,52.78 196.18,50.37 178.91,50.37 178.66,50.63 178.66,50.88 178.15,51.39 176.24,51.39 175.23,50.37 171.29,50.37 170.4,49.48 149.91,49.48 142.97,42.55 v2(142.97,40.08)
  BOTTOM w0.097: 27.81,57.48 v2(27.02,57.48) ; v3(241.78,55.96) 242.04,55.96 U2.AT13
PCH_PWRBTN_N_R: length 6
  BOTTOM w0.076: U5.M2 32.52,55.67 32.16,55.67
  BOTTOM w0.089: 32.16,55.67 31.85,55.98 31.85,56.98 30.96,57.86 29.94,57.86 29.81,57.74
  BOTTOM w0.097: 29.81,57.74 v1(29.69,57.61) 29.56,57.48 D3.1
PCH_RTC_X1: length 8.7
  BOTTOM w0.076: 243.55,50.93 243.78,51.16 243.78,51.54 243.88,51.64 243.88,52.1 244.12,52.33 U2.BC9
  BOTTOM w0.097: 243.55,50.93 243.55,50.59 243.88,50.26 243.88,49.34 243.73,49.18 243.73,48.42 244.19,47.96 244.19,47.15 R192.2 244.52,45.95 C205.2 244.49,44.98 Y1.1
PCH_RTC_X2: length 7.8
  BOTTOM w0.076: U2.BD10 243.59,51.7 243.59,51.24 243.35,51.01
  BOTTOM w0.097: Y1.2 243.63,44.98 C208.2 243.61,45.95 R192.1 243.91,47.12 243.91,47.9 243.53,48.29 243.53,49.27 243.68,49.42 243.68,50.18 243.35,50.51 243.35,51.01
PCH_SCK: length 24
  TOP w0.097: R122.1 v2(214.73,51.13) R938.2
  IN10 w0.091: v2(214.73,51.13) 215.74,52.15 217.52,52.15 220.19,49.48 221.33,49.48 221.71,49.1 229.33,49.1 229.58,49.36 230.85,49.36 231.24,49.74 v3(231.87,49.74)
  BOTTOM w0.076: 233.01,51.51 233.01,52.04 U2.BC31
  BOTTOM w0.097: v3(231.87,49.74) 231.87,49.88 232.36,50.37 232.76,50.37 233.06,50.68 233.06,51.46 233.01,51.51
PCH_SCK_R: length 205.4
  TOP w0.097: R122.2 214.73,53.17 v2(214.47,53.42)
  IN03 w0.089: 34.39,46.69 35.4,46.69 38.03,49.31
  IN03 w0.091: 38.03,49.31 38.47,49.31 39.98,47.8 39.98,47.8 40.54,47.24 46.73,47.24 47.2,47.7 54.3,47.7 54.77,47.24 60.35,47.24 63.06,49.95 70.8,49.95 74.9,54.05 86.73,54.05 89.5,56.82 104.41,56.82 105.58,57.99 126.21,57.99 127.73,56.47 155.65,56.47 161.24,50.88 175.59,50.88 176.35,50.12 182.01,50.12 182.69,50.8 199.51,50.8 201.37,52.66 213.71,52.66 v2(214.47,53.42) ; v2(30.7,41.23) 31.13,41.66 31.13,43.44 34.39,46.69
  BOTTOM w0.097: v2(30.7,41.23) 31.34,41.86 31.97,41.86 32.09,41.98 RP4.4 ; v2(214.47,53.42) 215.11,54.05 U3.6
PCH_SI: length 30.9
  TOP w0.097: v3(232.63,48.97) 233.32,49.66 R125.1 ; R593.2 R124.1 v2(213.58,51.13) R931.2
  IN10 w0.091: v2(213.58,51.13) 214.09,50.63 214.98,50.63 215.91,51.56 216.59,51.56 219.3,48.85 221.2,48.85 221.96,48.09 224.25,48.09 224.63,47.7 229.71,47.7 231.36,49.36 232.25,49.36 v3(232.63,48.97)
  BOTTOM w0.076: U2.BB29 234.42,52.62 234.13,52.33 234.13,51.54 234.26,51.41 234.26,50.55 234.13,50.42
  BOTTOM w0.097: 234.13,50.42 233.8,50.09 233.57,50.09 232.63,49.15 v3(232.63,48.97)
PCH_SI_R: length 207.2
  TOP w0.097: v2(213.58,53.42) R124.2
  IN03 w0.091: v2(30.7,40.34) 30.19,40.85 30.19,41.48 30.7,41.99 30.7,43.51 34.26,47.07 35.4,47.07 37.94,49.61 38.7,49.61 39.85,48.47 40.48,48.47 41.47,47.48 46.59,47.48 47.07,47.96 54.5,47.96 54.97,47.5 59.2,47.5 62.58,50.88 62.58,52.15 63.72,53.29 70.96,53.29 72.74,55.07 76.17,55.07 76.68,54.56 86.77,54.56 89.25,57.04 104.32,57.04 105.65,58.37 126.25,58.37 127.9,56.72 155.75,56.72 161.34,51.13 175.69,51.13 176.46,50.37 181.9,50.37 182.59,51.06 199.41,51.06 201.26,52.91 213.07,52.91 v2(213.58,53.42)
  BOTTOM w0.097: v2(30.7,40.34) 31.13,40.77 32.02,40.77 32.23,40.98 RP4.2 ; v2(213.58,53.42) 213.84,53.67 U3.5
PCH_SMB_CLK: length 120
  TOP w0.097: R573.1 272.29,20.32 v2(272.41,20.19)
  IN05 w0.091: v2(195.8,45.42) 196.02,45.2 196.43,45.2 196.64,44.99 197,44.99 197.2,45.2 214.29,45.2 215.08,44.41 224.26,44.41 224.98,43.69 228.63,43.69 229.18,43.14 233.5,43.14 235.78,40.85 253.02,40.85 254.26,39.61 257.81,39.61 259.63,41.43 262.5,41.43 263.75,40.18 263.75,35.64 265.4,33.99 265.4,26.62 268.05,23.98 268.05,23.52 268.33,23.24 268.78,23.24 269.03,22.99 269.03,21.57 269.95,20.65 271.96,20.65 v2(272.41,20.19)
  IN08 w0.091: v2(195.8,45.42) 196.56,46.18 196.56,48.79 193.64,51.71 193.64,56.72 v2(193.14,57.23)
  BOTTOM w0.097: v2(193.14,57.23) R81.1 193.06,57.99 TP64.1 191.48,57.99 190.93,57.43 190.93,54.31 191.13,54.11 R162.2 193.32,54.11 Q1.1
PCH_SMB_DAT: length 111.6
  TOP w0.097: R572.1 270.56,21.72 v2(270.51,21.72)
  IN05 w0.091: v2(196.82,45.42) 214.38,45.42 215.17,44.63 224.35,44.63 225.07,43.9 228.72,43.9 228.9,43.72 228.9,43.72 229.27,43.36 233.59,43.36 235.87,41.07 253.11,41.07 254.35,39.83 257.65,39.83 259.63,41.81 262.5,41.81 264.13,40.17 264.13,35.77 265.65,34.24 265.65,27.13 268.43,24.36 268.76,24.36 270,23.11 270,22.23 v2(270.51,21.72)
  IN08 w0.091: v2(194.41,57.23) 193.9,56.72 193.9,51.77 196.82,48.85 v2(196.82,45.42)
  BOTTOM w0.097: R82.1 v2(194.41,57.23) TP63.1 194.66,56.34 195.29,56.34 195.68,55.96 R161.2 195.22,55.15 195.18,55.19 Q1.4
PCH_SO: length 26
  TOP w0.097: R119.2 v2(216.38,51.13) R936.2
  IN10 w0.091: v3(232.63,49.74) 233.01,49.36 233.01,48.59 232.89,48.47 232.25,48.47 232.12,48.34 232.12,48.09 231.11,47.07 224.5,47.07 224,47.58 221.58,47.58 220.82,48.34 218.79,48.34 218.41,47.96 217.14,47.96 216.76,48.34 216.76,50.75 v2(216.38,51.13)
  BOTTOM w0.097: v3(232.63,49.74) 232.86,49.74 233.5,50.37 233.7,50.37 234.03,50.7 234.03,51.22 U2.BE30
PCH_SO_R: length 201.5
  TOP w0.097: R119.1 216.38,48.72 v2(216.12,48.47)
  IN03 w0.091: v2(31.59,41.35) 31.59,43.39 33.04,44.83 45.82,44.83 47.01,46.02 49.15,46.02 49.88,45.29 52.27,45.29 53.48,46.5 60.87,46.5 63.67,49.3 71.29,49.3 75.15,53.17 87.11,53.17 89.47,55.53 95.14,55.53 96.11,54.56 96.74,54.56 98.14,55.96 104.71,55.96 105.98,57.23 125.79,57.23 127.31,55.71 155.29,55.71 160.88,50.12 175.28,50.12 176.03,49.36 201.64,49.36 202.53,48.47 212.95,48.47 213.46,47.96 215.61,47.96 v2(216.12,48.47)
  BOTTOM w0.097: v2(216.12,48.47) 216.38,48.72 U3.2 ; RP4.3 31.71,41.48 v2(31.59,41.35)
PCH_THERMTRIP_N: length 4.7
  TOP w0.097: R287.1 v2(250.54,59.26)
  BOTTOM w0.076: U2.AJ3 247.33,59.43 247.47,59.29 248.25,59.29 248.92,58.63
  BOTTOM w0.097: 248.92,58.63 249.9,58.63 v2(250.54,59.26)
PCH_TRST_N: length 7.6
  TOP w0.097: v3(245.87,54.11) 246.42,54.11 247.75,52.78 249.27,52.78 v1(249.4,52.66) 249.9,52.15 v3(249.9,51.64)
  BOTTOM w0.097: v3(245.87,54.11) 245.87,53.69 U2.AY5 ; v3(249.9,51.64) 250.79,50.75 R202.1
PCH_UART2_CTS_N: length 4.5
  BOTTOM w0.097: U2.AN43 227.32,56.99 227.04,56.72 226.28,56.72 225.9,56.34 v1(224.53,56.34) 223.69,56.34 R535.2
PCH_UART2_RTS_N: length 2
  TOP w0.097: v3(225.65,56.72) 225.83,56.9 R536.2
  BOTTOM w0.097: v3(225.65,56.72) 225.77,56.72 226.08,57.03 U2.AN44
PCH_UART2_RXD: length 12.4
  TOP w0.097: R266.2 223.69,56.34 224.25,56.34 224.63,55.96 v3(224.89,55.96)
  IN08 w0.091: v3(224.89,55.96) 224.5,56.34 222.35,56.34 221.96,56.72 220.82,56.72 v2(218.54,54.44)
  BOTTOM w0.097: v2(218.54,54.44) 218.92,54.82 TP17.1 ; U2.AR45 226.07,56.09 226.03,56.09 225.9,55.96 v3(224.89,55.96)
PCH_UART2_TXD: length 13.8
  TOP w0.097: v3(228.95,55.58) 228.49,56.04 227.88,56.04 227.73,55.88 R534.2 226.74,55.88 226.28,56.34 224.63,56.34 224.25,56.72 v3(224.12,56.72)
  IN08 w0.091: v3(224.12,56.72) 222.6,56.72 222.22,57.1 220.57,57.1 220.19,56.72 219.3,56.72 v2(218.54,57.48)
  BOTTOM w0.097: v2(218.54,57.48) 219.55,56.47 TP16.1 ; U2.AR39 229.05,55.68 v3(228.95,55.58)
PCH_VRALERT_N: length 4.6
  BOTTOM w0.076: 237.79,51.44 237.3,51.93 U2.BD23
  BOTTOM w0.097: R137.1 238.59,48.53 v1(238.59,49.42) 238.55,49.46 238.55,49.91 238.35,50.12 237.87,50.12 237.79,50.19 237.79,51.44
PCH_WP_N: length 24.7
  TOP w0.097: v3(232.63,48.09) 232.76,47.96 R594.2
  IN10 w0.091: v2(216.71,47.58) 216.94,47.35 223.72,47.35 224.25,46.82 231.36,46.82 v3(232.63,48.09)
  BOTTOM w0.076: U2.BC29 234.31,52.12 234.31,51.62 234.44,51.49 234.44,50.4
  BOTTOM w0.097: 234.44,50.4 233.78,49.74 233.57,49.74 233.04,49.2 233.04,48.49 v3(232.63,48.09) ; R121.2 R116.1 216,46.87 v2(216.71,47.58)
PCH_WP_N_R: length 3
  BOTTOM w0.097: v1(214.07,47.78) R121.1 214.98,48.09 215.11,48.21 U3.3
PCH_XDP_PRDY_N: length 5.9
  TOP w0.097: R201.1 v3(250.54,53.42)
  BOTTOM w0.076: 249.14,55.22 248.64,55.73 246.72,55.73 U2.AT4
  BOTTOM w0.097: 249.14,55.22 249.14,54.89 250.54,53.5 v3(250.54,53.42)
PCH_XDP_PREQ_N: length 6.5
  TOP w0.097: R200.1 v3(250.54,52.53)
  BOTTOM w0.097: U2.AT3 246.86,55.38 246.86,54.69 247.01,54.54 247.72,54.54 247.75,54.56 248.76,54.56 249.52,53.8 249.52,53.17 v1(249.96,52.73) 250.16,52.53 v3(250.54,52.53)
PCH_XTAL24_IN: length 7.6
  BOTTOM w0.097: Y2.1 246.36,78.83 245.89,78.36 245.89,77.76 246.81,76.85 C206.1 246.78,76.64 R190.2 247.06,75.49 247.06,75.26 246.74,74.93 246.74,74.53 245.99,73.79 245.99,73.33 U2.A6
PCH_XTAL24_OUT: length 5.8
  BOTTOM w0.097: U2.A5 246.2,73.03 246.2,73.66 247.09,74.55 v1(247.09,74.78) 247.31,75.01 247.31,75.39 R190.1 247.69,76.64 C207.1 247.67,77.3 247.89,77.52 Y2.3
PCIE1_TBT_RX_DN0: length 237.3
  IN05 w0.114: v2(57.58,77.07) 57.37,76.86 57.37,76.28 57.63,76.03 58.38,76.03 60.31,74.1 60.31,69.31 64.37,65.24 64.85,65.24 66.4,63.69 66.4,61.79 66.77,61.42 68.54,61.42 71.91,58.05 72.93,58.05 73.25,57.74 73.25,56.72 73.74,56.23 80.37,56.23 81.39,55.21 89.01,55.21 90.54,56.73 93.33,56.73 95.49,58.89 97.27,58.89 98,59.63 98,61.4 99.93,63.34 101.08,63.34 101.68,63.94 101.68,67.63 103.87,69.82 104.65,69.82 106.64,71.8 109.92,71.8 110.48,72.36 114.14,72.36 114.9,73.12 119.21,73.12 119.97,72.36 124.97,72.36 128,75.38 128.94,75.38 131.89,78.32 134.35,78.32 136.06,80.03 143.04,80.03 145.24,82.23 145.24,85.58 147.13,87.47 195.31,87.47 195.82,87.98 199.12,87.98 200.39,89.25 203.41,89.25 206.71,85.94 211.43,85.94 213.66,83.72 220.28,83.72 221.99,85.42 237.08,85.42 241.98,80.52 241.98,78.95 242.55,78.38 242.55,70.7 241.4,69.55 240.89,69.55 v3(240.76,69.42)
  BOTTOM w0.097: U2.H15 240.83,69.49 v3(240.76,69.42)
  BOTTOM w0.104: v2(57.58,77.07) 57.38,77.26 57.38,77.45 C2030.1
PCIE1_TBT_RX_DP0: length 237.3
  IN05 w0.114: v2(56.94,77.07) 57.11,76.9 57.11,76.17 57.52,75.76 58.27,75.76 60.04,73.99 60.04,69.2 64.26,64.98 64.74,64.98 66.14,63.58 66.14,61.68 66.66,61.15 68.43,61.15 71.8,57.79 72.82,57.79 72.98,57.63 72.98,56.61 73.63,55.96 80.26,55.96 81.28,54.94 89.12,54.94 90.65,56.47 93.44,56.47 95.6,58.63 97.38,58.63 98.27,59.52 98.27,61.29 100.04,63.07 101.19,63.07 101.95,63.83 101.95,67.52 103.98,69.55 104.76,69.55 106.75,71.53 110.03,71.53 110.59,72.09 114.25,72.09 115.01,72.85 119.09,72.85 119.86,72.09 125.08,72.09 128.11,75.11 129.05,75.11 132,78.06 134.46,78.06 136.17,79.77 143.15,79.77 145.51,82.12 145.51,85.47 147.24,87.2 195.42,87.2 195.93,87.71 199.23,87.71 200.5,88.98 203.3,88.98 206.6,85.68 211.32,85.68 213.55,83.45 220.39,83.45 222.1,85.16 236.97,85.16 241.71,80.41 241.71,78.84 242.28,78.26 242.28,70.81 241.29,69.82 240.77,69.82 240.63,69.96 240.63,70.13 240.69,70.18 v3(240.76,70.18)
  BOTTOM w0.097: U2.G15 240.83,70.26 v3(240.76,70.18)
  BOTTOM w0.104: C2028.1 57.13,77.45 57.13,77.25 v2(56.94,77.07)
PCIE1_TBT_TX_DN0: length 231.1
  IN05 w0.114: v2(59.2,73.94) 59.04,73.78 59.04,72.75 59.15,72.63 59.15,72.18 59.04,72.06 59.04,71.82 59.15,71.71 59.15,71.25 59.04,71.13 59.04,70.83 59.15,70.72 59.15,70.26 59.04,70.15 59.04,69.32 62.72,65.64 62.72,64.06 64.03,62.75 64.55,62.75 64.99,62.32 64.99,59.52 65.88,58.63 68.55,58.63 70.45,56.72 71.72,56.72 73.1,55.34 79.99,55.34 81,54.32 89.39,54.32 90.92,55.85 93.71,55.85 95.74,57.88 98.28,57.88 99.14,58.74 99.14,61.28 100.32,62.45 101.71,62.45 102.58,63.32 102.58,67.13 104.13,68.67 104.77,68.67 106.93,70.83 110.22,70.83 110.86,71.47 114.66,71.47 115.42,72.23 118.82,72.23 119.59,71.47 125.34,71.47 128.26,74.38 132.02,74.38 133.48,75.84 134.53,75.84 135.21,76.52 135.21,77.79 136.57,79.14 143.55,79.14 145.26,80.85 146.53,80.85 147.53,81.85 147.53,85.92 148.07,86.45 195.82,86.45 196.2,86.83 200.74,86.83 203.03,84.55 211.29,84.55 213.01,82.83 220.72,82.83 221.99,84.1 228.76,84.1 229.18,84.52 235.05,84.52 235.46,84.1 236.34,84.1 237.14,83.3 237.93,83.3 238.15,83.08 241.07,80.17 241.07,78.61 241.36,78.32 241.36,75.99 240.95,75.59 240.95,74.51 240.41,73.97 240.41,73.64 240.56,73.49 240.84,73.49 240.99,73.64 v3(240.99,73.74)
  BOTTOM w0.104: v3(240.99,73.74) 240.53,73.28 U2.A16 ; C2029.2 59.01,74.99 59.01,74.13 v2(59.2,73.94)
PCIE1_TBT_TX_DP0: length 231.1
  IN05 w0.114: v3(240.99,73.1) 240.88,73.22 240.45,73.22 240.14,73.53 240.14,74.08 240.68,74.62 240.68,75.7 241.09,76.1 241.09,78.2 240.8,78.5 240.8,80.06 237.82,83.04 237.03,83.04 236.23,83.84 235.35,83.84 234.94,84.26 229.29,84.26 228.87,83.84 222.1,83.84 220.83,82.56 212.9,82.56 211.18,84.28 202.92,84.28 200.63,86.57 196.31,86.57 195.93,86.19 148.18,86.19 147.8,85.8 147.8,81.74 146.64,80.59 145.37,80.59 143.66,78.88 136.68,78.88 135.48,77.68 135.48,76.41 134.64,75.57 133.59,75.57 132.14,74.12 128.37,74.12 125.45,71.2 119.48,71.2 118.71,71.96 115.53,71.96 114.77,71.2 110.97,71.2 110.33,70.56 107.04,70.56 104.88,68.41 104.24,68.41 102.85,67.02 102.85,63.21 101.82,62.18 100.43,62.18 99.41,61.17 99.41,58.63 98.39,57.61 95.85,57.61 93.82,55.58 91.03,55.58 89.5,54.05 80.89,54.05 79.88,55.07 72.99,55.07 71.61,56.46 70.34,56.46 68.44,58.36 65.77,58.36 64.72,59.41 64.72,62.21 64.44,62.48 63.92,62.48 62.45,63.95 62.45,65.53 58.77,69.21 58.77,73.74 v2(58.57,73.94)
  BOTTOM w0.104: U2.B16 240.65,72.49 240.99,72.83 v3(240.99,73.1) ; v2(58.57,73.94) 58.76,74.13 58.76,74.99 C2027.2
PCIE2_TBT_RX_DN1: length 236.4
  IN05 w0.114: v2(52.2,71.75) 51.91,71.47 51.91,69.16 60.04,61.04 60.04,58.1 62.21,55.93 62.21,54.8 62.83,54.18 63.46,54.18 65.37,52.28 70.2,52.28 71.45,51.02 73.61,51.02 74.5,50.13 80.88,50.13 81.39,50.64 90.38,50.64 91.52,49.5 95.74,49.5 100.18,53.94 102.22,53.94 105.87,57.59 105.87,60.52 106.26,60.9 106.26,64.71 108.57,67.02 116.42,67.02 116.5,66.93 119.42,66.93 119.73,66.62 136.99,66.62 138.98,68.61 138.98,73.09 139.51,73.63 145.28,73.63 145.52,73.87 145.9,73.87 147.81,75.78 165.21,75.78 165.82,76.39 165.82,77.66 166.48,78.32 220.83,78.32 221.15,78.64 221.78,78.64 222.49,79.34 227.99,79.34 228.36,79.7 236.46,79.7 237.38,78.78 237.38,77.78 237.09,77.49 237.09,75.97 236.57,75.45 236.57,74.63 237.71,73.49 237.97,73.49 239.36,72.09 239.36,71.5 239.49,71.37 239.88,71.37 240.01,71.25 240.01,71.07 239.88,70.95 v3(239.62,70.95)
  BOTTOM w0.097: v3(239.62,70.95) 239.69,71.02 U2.E17
  BOTTOM w0.104: v2(52.2,71.75) 51.91,72.03 51.91,72.22 52.29,72.6 v2(53.56,72.6) 55.9,72.6 56.17,72.86 56.17,73.39 C2034.1
PCIE2_TBT_RX_DP1: length 236.5
  IN05 w0.114: v3(239.62,70.26) 239.09,70.78 239.09,71.98 237.86,73.22 237.6,73.22 236.3,74.52 236.3,75.56 236.82,76.08 236.82,77.6 237.12,77.89 237.12,78.67 236.35,79.44 228.47,79.44 228.11,79.07 222.6,79.07 221.89,78.37 221.26,78.37 220.95,78.06 166.59,78.06 166.08,77.55 166.08,76.28 165.32,75.52 147.92,75.52 146.01,73.6 145.63,73.6 145.39,73.36 139.62,73.36 139.24,72.98 139.24,68.49 137.1,66.36 119.62,66.36 119.31,66.67 116.39,66.67 116.3,66.75 108.68,66.75 106.52,64.6 106.52,60.79 106.14,60.4 106.14,57.48 102.33,53.67 100.29,53.67 95.85,49.23 91.41,49.23 90.27,50.37 81.5,50.37 80.99,49.86 74.39,49.86 73.5,50.75 71.34,50.75 70.09,52.01 65.26,52.01 63.35,53.92 62.72,53.92 61.94,54.69 61.94,55.82 59.77,57.99 59.77,60.93 51.65,69.05 51.65,71.48 v2(51.38,71.75)
  BOTTOM w0.097: U2.G17 v3(239.62,70.26)
  BOTTOM w0.104: v2(51.38,71.75) 51.66,72.03 51.66,72.32 52.19,72.85 55.8,72.85 55.91,72.97 55.91,73.39 C2032.1
PCIE2_TBT_TX_DN1: length 237.1
  IN05 w0.114: v2(55.19,76.94) 55.23,76.9 55.23,76.11 57.32,74.02 57.32,69.78 61.63,65.46 61.63,63.51 62.71,62.44 62.71,59.26 64.23,57.74 67.91,57.74 70.39,55.26 71.91,55.26 73.1,54.07 79.99,54.07 80.63,53.43 89.89,53.43 91.03,54.58 94.47,54.58 95.46,55.56 95.46,56.32 96,56.86 100.57,56.86 102.08,58.37 102.08,60.79 103.59,62.3 103.59,66.86 104.25,67.53 104.88,67.53 107.3,69.94 110.6,69.94 111.24,70.58 116.06,70.58 116.83,71.34 118.19,71.34 119.46,70.07 125.33,70.07 126.48,71.21 127.11,71.21 127.46,71.56 127.46,72.33 128.63,73.49 132.7,73.49 133.96,74.76 135.48,74.76 137.38,76.66 137.38,77.68 137.96,78.25 143.92,78.25 145.5,79.84 147.03,79.84 148.45,81.25 195.69,81.25 196.04,81.6 196.04,85.28 196.45,85.69 197.44,85.69 198.33,84.8 201.37,84.8 203.03,83.15 210.26,83.15 211.48,81.94 221.09,81.94 222.36,83.21 229.13,83.21 229.53,83.62 234.56,83.62 234.97,83.21 235.82,83.21 236.65,82.39 237.55,82.39 240.18,79.76 240.18,74.73 239.88,74.44 239.69,74.44 239.67,74.41 239.65,74.41 v2(239.48,74.25)
  BOTTOM w0.076: U2.B19 239.38,72.24 239.46,72.16 239.57,72.16 239.64,72.24 239.64,72.67 239.59,72.72 239.39,72.72 239.03,73.08 239.03,73.21 239.11,73.28 239.11,73.43 239.03,73.51 239.03,73.69 239.16,73.82 239.16,73.99 239.03,74.12 239.03,74.25 239.14,74.35 239.38,74.35 v2(239.48,74.25)
  BOTTOM w0.104: C2033.2 55,77.47 55,77.13 v2(55.19,76.94)
PCIE2_TBT_TX_DP1: length 237
  IN05 w0.114: v2(239.49,75.01) 239.47,74.99 239.47,74.82 239.58,74.7 239.77,74.7 239.91,74.84 239.91,79.65 237.44,82.12 236.54,82.12 235.71,82.95 234.86,82.95 234.45,83.35 229.64,83.35 229.24,82.95 222.47,82.95 221.2,81.67 211.37,81.67 210.15,82.88 202.91,82.88 201.26,84.53 198.22,84.53 197.33,85.42 196.56,85.42 196.31,85.17 196.31,81.49 195.8,80.98 148.56,80.98 147.15,79.57 145.61,79.57 144.03,77.99 138.07,77.99 137.65,77.57 137.65,76.55 135.59,74.49 134.07,74.49 132.81,73.23 128.74,73.23 127.73,72.22 127.73,71.45 127.22,70.95 126.59,70.95 125.44,69.8 119.35,69.8 118.08,71.07 116.94,71.07 116.17,70.31 111.35,70.31 110.71,69.68 107.41,69.68 104.99,67.26 104.36,67.26 103.85,66.75 103.85,62.19 102.34,60.68 102.34,58.26 100.68,56.59 96.11,56.59 95.73,56.21 95.73,55.45 94.58,54.31 91.14,54.31 90,53.17 80.52,53.17 79.88,53.8 72.99,53.8 71.8,54.99 70.28,54.99 67.8,57.47 64.12,57.47 62.44,59.15 62.44,62.33 61.37,63.4 61.37,65.35 57.06,69.67 57.06,73.91 54.96,76 54.96,76.28 54.83,76.41 54.65,76.41 54.55,76.5 v2(54.55,76.94)
  BOTTOM w0.076: U2.C19 239.13,72.16 239.13,72.77 238.88,73.02 238.88,74.39 239.17,74.67 239.17,74.69
  BOTTOM w0.104: v2(54.55,76.94) 54.74,77.13 54.74,77.48 C2031.2 ; 239.17,74.69 v2(239.49,75.01)
PCIE3_TBT_RX_DN2: length 240.6
  IN05 w0.076: 238.54,69.62 238.56,69.62 238.62,69.68 238.77,69.68 238.86,69.59 238.86,68.48 239.06,68.28 239.26,68.28 v3(239.49,68.05)
  IN05 w0.114: 238.54,69.62 236.88,69.62 236.56,69.95 236.56,72.11 234.66,74 234.66,76.33 233.39,77.61 231.54,77.61 231.2,77.27 223.34,77.27 222.19,76.13 213.43,76.13 212.75,75.45 202.35,75.45 201.15,74.25 182.72,74.25 182.4,73.92 168.12,73.92 167.86,73.67 148.87,73.67 147.92,72.72 147.92,69.04 146.78,67.9 145.78,67.9 144.75,66.87 141.78,66.87 139.68,64.77 139.68,64.36 139.14,63.82 119.23,63.82 118.37,64.68 115.63,64.68 115.41,64.91 109.75,64.91 109.19,64.34 109.19,60.91 107.92,59.64 107.92,56.47 103.09,51.64 101.44,51.64 97.25,47.45 90.39,47.45 90.04,47.81 73.66,47.81 72.5,48.96 69.45,48.96 68.8,49.61 60.81,49.61 59.4,51.02 58.5,51.91 58.5,56.75 57.88,57.37 57.88,58.75 57.63,59.01 56.1,59.01 54.9,60.21 52.79,62.32 52.79,64.36 47.72,69.43 47.72,70.58 46.83,71.47 46.83,73.75 46.72,73.87 46.45,73.87 v2(46.32,73.74)
  BOTTOM w0.104: U2.L17 239.57,67.97 v3(239.49,68.05) ; C2038.1 47.75,73.74 47.56,73.93 v2(47.04,73.93) 46.51,73.93 v2(46.32,73.74)
PCIE3_TBT_RX_DP2: length 240.6
  IN05 w0.076: v3(239.49,68.66) 239.26,68.43 239.12,68.43 239.01,68.55 239.01,69.65 238.83,69.83 238.62,69.83 238.56,69.89 238.54,69.89
  IN05 w0.114: 238.54,69.89 237,69.89 236.82,70.06 236.82,72.22 234.93,74.11 234.93,76.44 233.5,77.87 231.43,77.87 231.09,77.54 223.23,77.54 222.08,76.39 213.32,76.39 212.64,75.71 202.24,75.71 201.04,74.51 182.61,74.51 182.29,74.19 168.01,74.19 167.75,73.94 148.76,73.94 147.66,72.83 147.66,69.15 146.67,68.16 145.67,68.16 144.64,67.14 141.67,67.14 139.41,64.88 139.41,64.47 139.03,64.09 119.34,64.09 118.48,64.95 115.74,64.95 115.52,65.17 109.64,65.17 108.92,64.45 108.92,61.02 107.65,59.75 107.65,56.58 102.98,51.91 101.33,51.91 97.14,47.72 90.5,47.72 90.15,48.07 73.77,48.07 72.61,49.23 69.56,49.23 68.91,49.88 60.92,49.88 58.77,52.02 58.77,56.86 58.15,57.48 58.15,58.86 57.74,59.27 56.21,59.27 55.01,60.48 53.05,62.43 53.05,64.47 47.99,69.54 47.99,70.69 47.1,71.58 47.1,73.86 46.83,74.13 46.57,74.13 v2(46.32,74.37)
  BOTTOM w0.104: U2.K17 240.09,68.66 v3(239.49,68.66) ; v2(46.32,74.37) 46.51,74.19 47.56,74.19 47.75,74.37 C2036.1
PCIE3_TBT_TX_DN2: length 233.7
  IN05 w0.114: v2(52.8,75.14) 52.48,75.46 52.48,75.72 52.78,76.03 53.44,76.03 53.91,75.55 53.91,75.36 54.13,75.15 54.32,75.15 54.56,74.91 54.56,74.71 54.77,74.5 54.97,74.5 55.21,74.26 55.21,74.07 55.42,73.85 55.61,73.85 56.09,73.38 56.09,73.13 55.97,73.02 55.97,72.68 56.09,72.56 56.09,69.05 56.26,68.88 56.26,68.68 56.48,68.46 56.69,68.46 56.91,68.24 56.91,68.03 57.13,67.81 57.33,67.81 58.03,67.11 58.03,66.6 58.66,65.98 58.91,65.98 60.41,64.48 60.41,62.96 61.55,61.82 61.55,58.78 63.99,56.34 64.99,56.34 67.41,53.93 71.6,53.93 72.61,52.91 79.5,52.91 80.13,52.28 90.39,52.28 91.41,53.29 95.85,53.29 98.01,55.45 101.31,55.45 104.36,58.5 104.36,61.42 104.74,61.8 104.74,65.74 107.79,68.79 111.09,68.79 111.73,69.42 117.19,69.42 117.7,68.91 119.98,68.91 120.36,68.53 127.73,68.53 128.75,69.55 128.75,71.98 129.01,72.24 130.43,72.24 130.66,72.01 132.96,72.01 134.44,73.49 135.86,73.49 137.51,75.14 144.49,75.14 145.4,76.04 145.4,77.57 145.82,77.99 146.94,77.99 149.04,80.09 206.47,80.09 206.98,80.6 211.8,80.6 211.99,80.78 221.56,80.78 222.84,82.06 229.61,82.06 230.01,82.46 230.35,82.46 230.48,82.34 230.8,82.34 230.93,82.46 231.26,82.46 231.39,82.34 231.72,82.34 231.85,82.46 232.17,82.46 232.3,82.34 232.63,82.34 232.76,82.46 233.09,82.46 233.22,82.34 233.55,82.34 233.68,82.46 234.07,82.46 234.48,82.06 234.97,82.06 235.8,81.23 237.07,81.23 238.98,79.32 238.98,76.17 238.8,75.99 238.68,75.99 238.45,76.23 v2(238.45,76.28)
  BOTTOM w0.076: 238.68,73.43 238.68,72.91 238.87,72.72 U2.B20
  BOTTOM w0.104: C2037.2 52.61,75.67 52.61,75.33 v2(52.8,75.14) ; 238.68,73.43 238.68,74.88 238.86,75.06 238.86,75.87 v2(238.45,76.28)
PCIE3_TBT_TX_DP2: length 233.6
  IN05 w0.114: v2(238.45,75.64) 238.53,75.72 238.91,75.72 239.25,76.06 239.25,79.43 237.18,81.5 235.91,81.5 235.08,82.32 234.59,82.32 234.18,82.73 229.9,82.73 229.5,82.32 222.73,82.32 221.45,81.05 211.87,81.05 211.69,80.86 206.87,80.86 206.36,80.36 148.93,80.36 146.83,78.25 145.71,78.25 145.13,77.68 145.13,76.15 144.38,75.4 137.4,75.4 135.75,73.75 134.33,73.75 132.85,72.27 130.77,72.27 130.54,72.51 128.9,72.51 128.48,72.09 128.48,69.66 127.62,68.8 120.48,68.8 120.09,69.18 117.81,69.18 117.3,69.69 111.62,69.69 110.98,69.05 107.68,69.05 104.48,65.85 104.48,61.91 104.1,61.53 104.1,58.61 101.2,55.72 97.9,55.72 95.74,53.56 91.3,53.56 90.28,52.54 80.24,52.54 79.61,53.18 72.72,53.18 71.71,54.19 67.52,54.19 65.1,56.61 64.1,56.61 61.82,58.89 61.82,61.93 60.67,63.07 60.67,64.59 59.02,66.25 58.77,66.25 58.3,66.71 58.3,67.22 56.36,69.16 56.36,73.49 53.55,76.29 52.67,76.29 52.21,75.83 52.21,75.19 v2(52.17,75.14)
  BOTTOM w0.076: U2.C20 238.72,72.07 238.6,72.19 238.6,72.78 238.53,72.85 238.53,73.32 238.42,73.42 238.42,73.43
  BOTTOM w0.104: C2035.2 52.35,75.68 52.35,75.32 v2(52.17,75.14) ; 238.42,73.43 238.42,74.99 238.6,75.16 238.6,75.56 238.52,75.64 v2(238.45,75.64)
PCIE4_TBT_RX_DN3: length 238.8
  IN05 w0.114: v2(48.1,77.19) 48.1,76.79 47.61,76.29 47.61,74.74 48.1,74.24 48.1,73.5 48.74,72.86 49.87,72.86 50.51,72.22 50.51,68.66 52.04,67.13 52.68,67.13 59.15,60.67 59.15,57.73 59.79,57.1 59.79,56.34 61.07,55.05 61.07,51.38 61.68,50.77 69.29,50.77 69.93,50.13 73.24,50.13 74.12,49.24 90.5,49.24 91.14,48.61 96.37,48.61 100.82,53.05 102.73,53.05 106.76,57.09 106.76,60.13 108.03,61.4 108.03,64.83 109.27,66.07 115.97,66.07 116.1,65.94 119.01,65.94 119.47,65.48 137.64,65.48 140.19,68.04 144.25,68.04 145,68.79 145,72.09 145.89,72.98 146.28,72.98 148.12,74.83 167.38,74.83 167.64,75.08 180.64,75.08 180.96,75.4 199.63,75.4 201.28,77.05 212.58,77.05 212.83,77.31 221.72,77.31 222.84,78.43 229.9,78.43 230.29,78.81 236.09,78.81 236.38,78.53 236.38,76.52 235.76,75.9 235.76,74.42 237.73,72.45 237.73,71.7 237.92,71.5 238.63,71.5 238.75,71.38 238.75,71.23 v3(238.47,70.95)
  BOTTOM w0.097: v3(238.47,70.95) 238.8,70.95 U2.E20
  BOTTOM w0.104: C2042.1 47.91,77.57 47.91,77.39 v2(48.1,77.19)
PCIE4_TBT_RX_DP3: length 238.8
  IN05 w0.114: v2(47.47,77.17) 47.54,77.09 47.54,76.61 47.34,76.4 47.34,74.63 47.84,74.13 47.84,73.39 48.63,72.6 49.76,72.6 50.25,72.11 50.25,68.55 51.93,66.87 52.57,66.87 58.88,60.56 58.88,57.62 59.52,56.99 59.52,56.23 60.8,54.94 60.8,51.26 61.57,50.5 69.18,50.5 69.82,49.86 73.12,49.86 74.01,48.97 90.39,48.97 91.03,48.34 96.48,48.34 100.93,52.78 102.84,52.78 107.03,56.98 107.03,60.02 108.3,61.29 108.3,64.72 109.38,65.8 115.86,65.8 115.99,65.68 118.9,65.68 119.36,65.22 137.75,65.22 140.3,67.77 144.36,67.77 145.27,68.68 145.27,71.98 146,72.71 146.39,72.71 148.23,74.56 167.49,74.56 167.75,74.81 180.75,74.81 181.07,75.14 199.74,75.14 201.39,76.79 212.69,76.79 212.94,77.04 221.83,77.04 222.95,78.16 230.01,78.16 230.4,78.55 235.98,78.55 236.11,78.42 236.11,76.63 235.49,76.01 235.49,74.31 237.46,72.34 237.46,71.58 237.97,71.08 237.97,70.82 v3(238.47,70.31)
  BOTTOM w0.097: v3(238.47,70.31) 238.93,70.31 U2.G19
  BOTTOM w0.104: v2(47.47,77.17) 47.65,77.35 47.65,77.58 C2040.1
PCIE4_TBT_TX_DN3: length 238
  IN05 w0.114: v3(237.74,74.12) 237.33,74.53 237.33,75.43 237.71,75.81 237.71,77.22 238.08,77.58 238.08,78.96 236.72,80.32 222.47,80.32 221.6,79.45 207.49,79.45 207.11,79.07 149.29,79.07 147.16,76.95 147.16,76.15 146.53,75.52 146.29,75.52 145.02,74.25 138.19,74.25 137.07,73.13 137.07,68.44 135.9,67.26 120.14,67.26 119.56,67.85 108.5,67.85 105.63,64.98 105.63,61.29 105.25,60.91 105.25,58.12 101.69,54.56 99.54,54.56 97.38,52.4 95.47,52.4 93.95,50.88 91.15,50.88 90.77,51.26 79.09,51.26 78.58,50.75 76.68,50.75 75.79,51.64 72.61,51.64 71.22,53.04 65.75,53.04 64.09,54.7 64.09,55.22 63.87,55.44 63.58,55.44 60.66,58.36 60.66,61.31 59.39,62.58 59.39,64.23 58.66,64.96 57.77,64.96 52.93,69.8 52.93,71.96 52.55,72.34 51.66,72.34 50.13,73.87 49.5,73.87 48.34,75.03 48.34,76.14 48.88,76.67 49.48,76.67 49.83,76.33 49.83,75.47 v2(50.12,75.18)
  BOTTOM w0.104: v3(237.74,74.12) 237.78,74.12 237.89,74.02 237.89,72.7 238.1,72.49 U2.B21 ; v2(50.12,75.18) 49.84,75.46 49.84,76.27 50.03,76.46 C2041.2
