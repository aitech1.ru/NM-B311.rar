# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ43: length 70.8
  TOP w0.102: v2(186.6,83.65) 186.54,83.59 186.09,83.59 185.96,83.72 185.96,85.15 184.65,86.46 JDIMM2.208
  IN03 w0.076: 183.17,123.9 178.21,128.86 178.21,130.5 v2(178.89,131.17)
  IN03 w0.13: 183.17,123.9 185.52,123.9 190.01,119.41 190.01,116.13 190.54,115.6 190.54,113.19 190.67,113.07 190.74,113.07 190.87,112.94 190.87,112.68 190.74,112.55 190.67,112.55 190.54,112.42 190.54,112.16 190.67,112.03 190.74,112.03 190.87,111.9 190.87,111.64 190.74,111.51 190.67,111.51 190.54,111.38 190.54,111.12 190.67,110.99 190.74,110.99 190.87,110.86 190.87,110.6 190.74,110.47 190.67,110.47 190.54,110.34 190.54,110.09 190.67,109.96 190.74,109.96 190.87,109.83 190.87,109.57 190.74,109.44 190.67,109.44 190.54,109.31 190.54,109.05 190.67,108.92 190.74,108.92 190.87,108.79 190.87,108.53 190.74,108.4 190.67,108.4 190.54,108.27 190.54,108.01 190.67,107.88 190.74,107.88 190.87,107.75 190.87,107.49 190.74,107.37 190.67,107.37 190.54,107.24 190.54,106.98 190.67,106.85 190.74,106.85 190.87,106.72 190.87,106.46 190.74,106.33 190.67,106.33 190.54,106.2 190.54,97.44 186.04,92.93 186.04,91.38 186.22,91.2 186.56,91.2 186.68,91.08 186.68,90.81 186.56,90.69 186.17,90.69 186.04,90.56 186.04,83.86 186.25,83.65 v2(186.6,83.65)
  BOTTOM w0.102: v2(186.6,83.65) 186.6,83.59 187.46,82.73 187.46,81.31 186.32,80.17 JDIMM1.208
  BOTTOM w0.14: U1.U2 178.56,131.47 v2(178.89,131.17)
M_A_DQ44: length 72.4
  TOP w0.102: JDIMM2.195 181.4,80.28 181.76,80.64 182.74,80.64 183.31,81.21 183.45,81.21 183.75,80.92 183.91,80.92 184.03,81.04 184.03,81.21 183.74,81.5 183.74,81.64 184.32,82.23 184.71,82.23 v2(184.94,81.99)
  IN03 w0.076: v2(177.72,127.27) 177.72,126.75 179.53,124.94 179.63,124.94
  IN03 w0.13: v2(184.94,81.99) 183.71,83.23 183.71,93.51 187.22,97.01 187.22,99.06 187.09,99.19 186.89,99.19 186.77,99.32 186.77,99.58 186.89,99.71 187.09,99.71 187.22,99.84 187.22,100.1 187.09,100.23 186.89,100.23 186.77,100.36 186.77,100.62 186.89,100.75 187.09,100.75 187.22,100.88 187.22,101.14 187.09,101.27 186.89,101.27 186.77,101.4 186.77,101.66 186.89,101.78 187.09,101.78 187.22,101.91 187.22,102.17 187.09,102.3 186.89,102.3 186.77,102.43 186.77,102.69 186.89,102.82 187.09,102.82 187.22,102.95 187.22,103.21 187.09,103.34 186.89,103.34 186.77,103.47 186.77,103.73 186.89,103.86 187.09,103.86 187.22,103.99 187.22,104.25 187.09,104.38 186.89,104.38 186.77,104.5 186.77,104.76 186.89,104.89 187.09,104.89 187.22,105.02 187.22,119.49 184.22,122.48 182.7,122.48 180.24,124.94 179.63,124.94
  BOTTOM w0.076: U1.V1 177.71,127.28 v2(177.72,127.27)
  BOTTOM w0.102: v2(184.94,81.99) 184.14,82.8 184.14,83.39 183.84,83.69 183.84,85.02 183.07,85.8 JDIMM1.195
M_A_DQ45: length 70.7
  TOP w0.102: v2(183.29,83.65) 182.86,84.08 182.86,84.44 181.15,86.15 JDIMM2.194
  IN03 w0.076: v2(176.37,128.62) 176.37,127.59 179.43,124.53 179.65,124.53
  IN03 w0.13: v2(183.29,83.65) 182.94,83.29 182.67,83.29 182.54,83.42 182.54,83.87 182.67,84 182.75,84 182.87,84.13 182.87,84.43 182.75,84.56 182.6,84.56 182.54,84.62 182.54,93.35 186.05,96.85 186.05,113.24 186.18,113.37 186.34,113.37 186.47,113.5 186.47,113.76 186.34,113.89 186.17,113.89 186.04,114.02 186.04,114.28 186.17,114.41 186.34,114.41 186.47,114.54 186.47,114.8 186.34,114.93 186.17,114.93 186.04,115.06 186.04,115.32 186.17,115.45 186.34,115.45 186.47,115.57 186.47,115.83 186.34,115.96 186.17,115.96 186.04,116.09 186.04,116.35 186.17,116.48 186.34,116.48 186.47,116.61 186.47,116.87 186.34,117 186.18,117 186.05,117.13 186.05,117.36 186.18,117.49 186.28,117.49 186.4,117.62 186.4,117.88 186.28,118.01 186.18,118.01 186.05,118.14 186.05,118.4 186.18,118.53 186.28,118.53 186.4,118.66 186.4,118.91 186.28,119.04 186.18,119.04 186.05,119.17 186.05,119.64 183.71,121.97 182.52,121.97 179.97,124.53 179.65,124.53
  BOTTOM w0.076: U1.V4 177.27,132.33 177.27,130.9 177.27,129.84 177.08,129.65 177.08,128.8 176.9,128.62 v2(176.37,128.62)
  BOTTOM w0.102: JDIMM1.194 182.82,80.17 183.18,80.53 183.18,81.16 183.7,81.68 183.7,83.24 v2(183.29,83.65)
M_A_DQ46: length 72.6
  TOP w0.102: JDIMM2.203 183.4,80.21 183.68,80.49 184.04,80.49 185.35,81.8 185.35,84.76 v2(184.94,85.17)
  IN03 w0.076: v2(178.89,133.09) 177.67,131.87 177.67,128.82 182.32,124.17
  IN03 w0.13: 182.32,124.17 183.07,123.42 184.98,123.42 189.2,119.21 189.2,115.55 189.44,115.31 189.44,115.08 189.22,114.86 189.22,114.56 189.44,114.35 189.44,114.04 189.22,113.83 189.22,113.52 189.44,113.31 189.44,97.34 185.36,93.27 185.36,88.56 185.24,88.43 185.03,88.43 184.91,88.3 184.91,88.04 185.03,87.91 185.24,87.91 185.36,87.78 185.36,87.52 185.24,87.39 185.03,87.39 184.91,87.26 184.91,87 185.03,86.87 185.24,86.87 185.36,86.74 185.36,85.4 185.13,85.17 v2(184.94,85.17)
  BOTTOM w0.102: JDIMM1.203 185.07,86.52 184.97,86.42 183.54,86.42 183.43,86.3 183.43,86.13 183.54,86.01 184.66,86.01 184.76,85.91 184.76,85.76 184.66,85.66 184.27,85.66 184.16,85.56 184.16,84.8 184.29,84.68 184.44,84.68 v2(184.94,85.17)
  BOTTOM w0.14: U1.U5 178.56,133.42 v2(178.89,133.09)
M_A_DQ47: length 72.4
  TOP w0.102: v2(186.6,82.38) 185.66,83.32 185.66,85.03 185.11,85.58 184.85,85.58 183.65,86.78 JDIMM2.204
  IN03 w0.076: v2(178.89,132.44) 177.95,131.5 177.95,128.83 183.13,123.65
  IN03 w0.13: 183.13,123.65 185.26,123.65 189.63,119.28 189.63,115.75 189.8,115.59 189.8,97.19 185.71,93.1 185.71,83.28 186.6,82.39 v2(186.6,82.38)
  BOTTOM w0.102: v2(186.6,82.38) 186.6,82.5 186.72,82.62 187.02,82.62 187.15,82.5 187.15,82.06 187.02,81.93 186.72,81.93 186.59,81.8 186.59,81.62 186.71,81.51 186.89,81.51 186.97,81.43 186.97,81.25 186.81,81.1 186.63,81.1 186.39,81.34 186.21,81.34 186.04,81.17 186.04,80.99 186.18,80.85 186.18,80.67 186.06,80.55 185.92,80.55 185.76,80.71 185.62,80.71 185.32,80.41 JDIMM1.204
  BOTTOM w0.14: U1.U4 178.56,132.77 v2(178.89,132.44)
M_A_DQ48: length 78.5
  TOP w0.102: v2(188.5,84.92) 189.23,84.19 189.23,82.09 188.61,81.47 187.7,81.47 186.4,80.17 JDIMM2.215
  IN03 w0.076: v2(180.68,128.06) 180.68,127.52 183.23,124.97
  IN03 w0.13: 183.23,124.97 183.3,124.9 186.56,124.9 188.64,122.81 189.3,122.81 191.66,120.45 191.66,117.86 193.39,116.13 193.39,109.73 193.06,109.39 192.88,109.39 192.76,109.27 192.76,109 192.88,108.88 193.06,108.88 193.19,108.75 193.19,108.52 193.06,108.39 192.89,108.39 192.76,108.26 192.76,108 192.89,107.87 193.06,107.87 193.19,107.74 193.19,107.48 193.06,107.35 192.89,107.35 192.76,107.22 192.76,106.96 192.89,106.83 193.06,106.83 193.19,106.7 193.19,106.44 193.06,106.31 192.88,106.31 192.76,106.19 192.76,105.92 192.88,105.8 193.06,105.8 193.19,105.67 193.19,105.4 193.06,105.27 192.89,105.27 192.76,105.14 192.76,104.88 192.89,104.75 193.06,104.75 193.19,104.62 193.19,104.36 193.06,104.23 192.89,104.23 192.76,104.1 192.76,103.84 192.89,103.71 193.06,103.71 193.19,103.58 193.19,103.33 193.06,103.2 192.91,103.2 192.78,103.07 192.78,102.81 192.91,102.68 193.06,102.68 193.19,102.55 193.19,102.29 193.06,102.16 192.96,102.16 192.83,102.03 192.83,101.78 192.96,101.65 193.06,101.65 193.19,101.52 193.19,101.19 193.06,101.06 192.94,101.06 192.81,100.93 192.81,100.67 192.94,100.55 193.06,100.55 193.19,100.42 193.19,97.46 189.73,94.01 189.73,92.84 188.08,91.19 188.08,88.6 188.25,88.43 188.34,88.43 188.46,88.3 188.46,88.04 188.34,87.91 188.21,87.91 188.08,87.78 188.08,87.52 188.21,87.39 188.34,87.39 188.46,87.27 188.46,87 188.34,86.88 188.21,86.88 188.08,86.75 188.08,86.48 188.21,86.36 188.34,86.36 188.46,86.23 188.46,85.97 188.34,85.84 188.24,85.84 188.11,85.71 188.11,85.04 188.24,84.92 v2(188.5,84.92)
  BOTTOM w0.076: v2(180.68,128.06) 180.78,128.06 180.92,128.2 180.92,128.55 180.03,129.44 180.03,130.56 179.93,130.66 179.93,131.18 U1.R2
  BOTTOM w0.102: v2(188.5,84.92) 188.39,85.03 188.22,85.03 188.09,84.9 188.09,83.95 187.99,83.84 187.83,83.84 187.73,83.95 187.73,84.18 187.6,84.31 187.43,84.31 187.31,84.43 187.31,84.59 187.43,84.71 187.68,84.71 187.8,84.83 187.8,85 187.68,85.12 187.42,85.12 187.31,85.23 187.31,85.37 187.52,85.59 187.52,85.79 187.44,85.88 187.2,85.88 187.09,85.99 187.09,86.15 187.46,86.52 187.81,86.52 188.07,86.78 JDIMM1.215
M_A_DQ49: length 78.8
  TOP w0.102: v2(190.15,81.99) 189.57,82.57 189.57,84.42 187.81,86.19 187.16,86.19 186.65,86.69 JDIMM2.216
  IN03 w0.076: 184.34,126.11 180.46,129.99 180.46,132.15 v2(181.4,133.09)
  IN03 w0.13: v2(190.15,81.99) 190.66,82.5 190.66,91.02 192.25,92.61 192.25,94.01 195.45,97.21 195.45,105.16 196.21,105.92 196.21,115.95 193.34,118.82 193.34,122.13 190.8,124.67 189.05,124.67 187.6,126.11 184.34,126.11
  BOTTOM w0.102: v2(190.15,81.99) 190.08,81.99 189.7,82.37 189.7,82.72 189.59,82.84 189.42,82.84 189.3,82.72 189.3,81.55 189.43,81.43 190.19,81.43 190.31,81.31 190.31,81.14 190.19,81.02 189.56,81.02 189.46,80.92 189.46,80.53 189.37,80.43 188.43,80.43 188.32,80.33 JDIMM1.216
  BOTTOM w0.14: U1.P5 v2(181.4,133.09)
M_A_DQ50: length 77.6
  TOP w0.102: v2(188.5,83.65) 188.93,83.22 188.93,82.23 188.51,81.81 187.61,81.81 186.23,80.43 185.66,80.43 185.4,80.17 JDIMM2.211
  IN03 w0.076: v2(179.78,128.96) 179.78,128.16 183.3,124.64
  IN03 w0.13: v2(188.5,83.65) 188.22,83.37 187.93,83.37 187.75,83.55 187.75,91.36 189.38,92.99 189.38,94.16 192.75,97.53 192.75,100.04 192.4,100.39 192.4,110.04 192.53,110.17 192.78,110.17 192.91,110.3 192.91,110.56 192.78,110.69 192.53,110.69 192.4,110.82 192.4,111.08 192.53,111.2 192.78,111.2 192.91,111.33 192.91,111.59 192.78,111.72 192.53,111.72 192.4,111.85 192.4,112.11 192.53,112.24 192.78,112.24 192.91,112.37 192.91,112.63 192.78,112.76 192.53,112.76 192.4,112.89 192.4,113.15 192.53,113.28 192.78,113.28 192.91,113.41 192.91,113.67 192.78,113.8 192.53,113.8 192.4,113.93 192.4,114.18 192.53,114.31 192.78,114.31 192.91,114.44 192.91,114.7 192.78,114.83 192.53,114.83 192.4,114.96 192.4,115.19 192.53,115.32 192.75,115.32 192.88,115.45 192.88,115.71 192.75,115.84 192.53,115.84 191.31,117.06 191.31,120.25 189.12,122.43 188.46,122.43 186.25,124.64 183.3,124.64
  BOTTOM w0.076: U1.R4 179.93,132.47 179.93,131.61 179.78,131.46 179.78,128.96 v2(179.78,128.96)
  BOTTOM w0.102: JDIMM1.211 187.07,86.62 186.97,86.52 186.54,86.52 186.43,86.41 186.43,86.25 186.54,86.13 186.66,86.13 186.79,86.01 186.79,85.82 186.66,85.69 186.54,85.69 186.43,85.58 186.43,85.43 186.54,85.32 186.9,85.32 187,85.22 187,84.24 187.85,83.4 188.37,83.4 188.5,83.52 v2(188.5,83.65)
M_A_DQ51: length 76.6
  TOP w0.102: v2(191.8,82.38) 191.8,82.5 191.68,82.62 191.45,82.62 191.32,82.5 191.32,82.21 191.56,81.97 191.56,81.82 190.58,80.83 190.11,80.83 189.7,80.43 189.03,80.43 188.9,80.3 JDIMM2.225
  IN03 w0.076: 184.38,126.37 180.67,130.08 180.67,131.7 v2(181.4,132.44)
  IN03 w0.13: 184.38,126.37 187.85,126.37 189.15,125.07 190.93,125.07 193.69,122.3 193.69,119.03 196.57,116.16 196.57,105.64 195.83,104.91 195.83,97.08 192.58,93.83 192.58,92.47 191.05,90.94 191.05,81.82 191.18,81.69 191.92,81.69 192.04,81.82 192.04,82.13 v2(191.8,82.38)
  BOTTOM w0.102: JDIMM1.225 190.57,86.69 191.07,86.19 191.07,83.11 v2(191.8,82.38)
  BOTTOM w0.14: U1.P4 181.08,132.77 v2(181.4,132.44)
M_A_DQ52: length 77.5
  TOP w0.102: v2(188.5,82.38) 188.09,82.78 188.09,84.82 186.39,86.52 185.91,86.52 185.65,86.78 JDIMM2.212
  IN03 w0.076: v2(179.33,129.41) 179.33,128.32 183.25,124.4
  IN03 w0.13: v2(188.5,82.38) 188.5,82.19 188.13,81.82 187.45,81.82 187.32,81.94 187.32,82.32 187.45,82.45 187.93,82.45 188.06,82.58 188.06,82.83 187.93,82.96 187.57,82.96 187.41,83.12 187.41,91.54 188.06,92.18 188.06,93.04 188.28,93.27 188.64,93.27 189.02,93.65 189.02,94.31 192.02,97.31 192.02,99.03 192.15,99.16 192.26,99.16 192.39,99.29 192.39,99.55 192.26,99.68 192.15,99.68 192.02,99.81 192.02,115.57 190.95,116.64 190.95,119.94 188.89,122 188.44,122 186.04,124.4 183.25,124.4
  BOTTOM w0.076: U1.R5 179.62,132.82 179.62,131.48 179.63,131.48 179.63,130.16 179.33,129.87 v2(179.33,129.41)
  BOTTOM w0.102: JDIMM1.212 187.32,80.31 187.45,80.44 187.98,80.44 188.34,80.8 188.99,80.8 189.11,80.92 189.11,81.31 188.99,81.44 188.33,81.44 188.22,81.56 188.22,81.72 188.33,81.84 188.87,81.84 189,81.97 189,82.5 188.87,82.62 188.63,82.62 188.5,82.5 v2(188.5,82.38)
M_A_DQ53: length 76.7
  TOP w0.102: JDIMM2.229 189.9,80.2 190.18,80.47 190.65,80.47 192.21,82.03 192.21,83.24 v2(191.8,83.65)
  IN03 w0.076: v2(181.4,131.14) 180.92,130.66 180.92,130.12 184.39,126.65
  IN03 w0.13: v2(191.8,83.65) 191.61,83.65 191.38,83.88 191.38,90.8 192.91,92.33 192.91,93.66 196.23,96.98 196.23,102.44 196.36,102.57 196.89,102.57 197.02,102.7 197.02,103.02 196.89,103.15 196.31,103.15 196.19,103.27 196.19,103.54 196.31,103.66 197.02,103.66 197.15,103.79 197.15,104.06 197.02,104.18 196.46,104.18 196.34,104.31 196.34,104.57 196.46,104.7 196.92,104.7 197.15,104.92 197.15,105.18 196.93,105.4 196.93,105.7 197.15,105.92 197.15,106.22 196.93,106.44 196.93,106.74 197.15,106.96 197.15,107.25 196.93,107.47 196.93,107.77 197.15,107.99 197.15,108.29 196.93,108.51 196.93,108.81 197.15,109.03 197.15,109.33 196.93,109.55 196.93,109.84 197.15,110.07 197.15,110.32 196.95,110.52 196.95,110.84 197.15,111.04 197.15,111.36 196.95,111.56 196.95,111.88 197.15,112.08 197.15,112.39 196.95,112.6 196.95,112.91 197.15,113.11 197.15,116.16 194.08,119.23 194.08,122.48 191.1,125.45 189.27,125.45 188.08,126.65 184.39,126.65
  BOTTOM w0.102: v2(191.8,83.65) 191.68,83.52 191.5,83.52 191.38,83.65 191.38,85.6 191.51,85.73 191.98,85.73 192.09,85.85 192.09,86.02 191.98,86.14 191.52,86.14 191.38,86.28 191.38,86.47 191.57,86.66 JDIMM1.229
  BOTTOM w0.14: U1.P2 181.08,131.47 v2(181.4,131.14)
M_A_DQ54: length 76.9
  TOP w0.102: JDIMM2.224 188.65,86.76 188.29,86.4 188.29,86.22 188.45,86.05 188.59,86.05 188.96,86.42 189.1,86.42 189.25,86.27 189.25,86.13 188.88,85.77 188.88,85.62 189.03,85.48 189.17,85.48 189.41,85.72 189.58,85.72 189.7,85.6 189.7,85.43 189.46,85.19 189.46,85.05 189.64,84.86 189.79,84.86 190.1,85.17 v2(190.15,85.17)
  IN03 w0.076: 184.33,125.84 182.52,127.64 v2(181.16,127.64)
  IN03 w0.13: 184.33,125.84 187.37,125.84 188.97,124.23 190.75,124.23 192.98,122 192.98,118.65 195.75,115.88 195.75,109.44 195.58,109.27 195.24,109.27 195.07,109.1 195.07,108.87 195.2,108.74 195.68,108.74 195.8,108.61 195.8,108.34 195.68,108.22 195.2,108.22 195.07,108.09 195.07,107.83 195.2,107.7 195.7,107.7 195.83,107.57 195.83,107.31 195.7,107.18 195.2,107.18 195.07,107.05 195.07,106.64 195.2,106.51 195.47,106.51 195.6,106.38 195.6,106.12 195.47,105.99 195.2,105.99 195.07,105.86 195.07,97.39 191.31,93.63 191.31,92.14 189.73,90.57 189.73,88.56 189.86,88.43 190.2,88.43 190.33,88.3 190.33,88.04 190.2,87.91 189.86,87.91 189.73,87.78 189.73,87.52 189.86,87.39 190.2,87.39 190.33,87.27 190.33,87 190.2,86.88 189.86,86.88 189.73,86.75 189.73,86.47 189.86,86.34 190.2,86.34 190.33,86.21 190.33,85.93 190.2,85.8 189.83,85.8 189.71,85.68 189.71,85.27 189.83,85.14 190.13,85.14 v2(190.15,85.17)
  BOTTOM w0.076: v2(181.16,127.64) 181.16,128.62 180.22,129.56 U1.R1
  BOTTOM w0.102: v2(190.15,85.17) 190.61,84.71 190.61,80.93 190.32,80.64 JDIMM1.224
M_A_DQ55: length 77.3
  TOP w0.102: JDIMM2.228 189.65,86.24 190.78,85.12 190.92,85.12 191.04,85 191.04,84.82 190.92,84.7 190.75,84.7 190.61,84.56 190.61,84.28 190.74,84.15 191.23,84.15 191.36,84.28 191.36,84.79 191.48,84.92 v2(191.8,84.92)
  IN03 w0.076: v2(181.4,130.5) 181.4,129.92 184.45,126.88
  IN03 w0.13: v2(191.8,84.92) 191.71,85 191.71,88.3 192.22,88.81 192.22,90.71 192.22,90.71 192.22,91.17 193.24,92.2 193.24,93.48 196.62,96.86 196.62,97.36 196.74,97.49 197.38,97.49 197.5,97.62 197.5,97.85 197.38,97.98 196.72,97.98 196.59,98.11 196.59,98.37 196.72,98.5 197.38,98.5 197.5,98.63 197.5,98.88 197.38,99.01 196.72,99.01 196.59,99.14 196.59,99.4 196.72,99.53 197.38,99.53 197.5,99.66 197.5,99.92 197.38,100.05 196.72,100.05 196.59,100.17 196.59,100.44 196.72,100.57 197.38,100.57 197.5,100.7 197.5,100.95 197.38,101.08 196.72,101.08 196.59,101.21 196.59,101.48 196.72,101.6 197.38,101.6 197.5,101.73 197.5,116.31 194.46,119.36 194.46,122.63 191.23,125.86 189.38,125.86 188.36,126.88 184.45,126.88
  BOTTOM w0.076: v2(181.4,130.5) 181.08,130.82 U1.P1
  BOTTOM w0.102: JDIMM1.228 191.32,81.32 192.21,82.21 192.21,84.51 v2(191.8,84.92)
M_A_DQ56: length 82.2
  TOP w0.102: v2(193.71,84.92) 194.13,84.49 194.13,82.2 193.23,81.3 192.52,81.3 191.67,80.45 191.18,80.45 190.9,80.17 JDIMM2.233
  IN03 w0.13: v2(182.75,129.14) 184.22,129.14 185.39,127.97 188.87,127.97 189.83,127 192.45,127 195.57,123.88 195.57,119.89 199.1,116.36 199.1,111.46 199.54,111.03 199.54,96.32 198,94.78 197.81,94.78 197.65,94.94 197.47,94.94 197.29,94.76 197.29,94.57 197.45,94.41 197.45,94.23 197.26,94.05 197.08,94.05 196.92,94.21 196.74,94.21 196.55,94.02 196.55,93.84 196.71,93.68 196.71,93.5 196.53,93.31 196.35,93.31 196.19,93.47 196,93.47 195.82,93.29 195.82,93.11 195.98,92.95 195.98,92.76 193.29,90.07 193.29,88.47 193.42,88.34 193.67,88.34 193.79,88.21 193.79,87.95 193.67,87.82 193.42,87.82 193.29,87.69 193.29,87.43 193.42,87.3 193.67,87.3 193.79,87.18 193.79,86.91 193.67,86.79 193.42,86.79 193.29,86.66 193.29,86.4 193.42,86.27 193.67,86.27 193.79,86.14 193.79,85.88 193.67,85.75 193.42,85.75 193.29,85.62 193.29,85.12 193.49,84.92 v2(193.71,84.92)
  BOTTOM w0.076: v2(182.75,129.14) 182.75,129.75 182.51,129.99 182.51,130.25 182.3,130.45 182.3,132.33 U1.M4
  BOTTOM w0.102: v2(193.71,84.92) 193.61,85.02 193.42,85.02 193.29,84.89 193.29,83.97 193.19,83.87 193.05,83.87 192.95,83.97 192.95,85.17 193.07,85.3 193.48,85.3 193.59,85.41 193.59,85.57 193.48,85.68 192.97,85.68 192.86,85.79 192.86,85.95 192.97,86.06 193.36,86.06 193.46,86.17 193.46,86.32 193.36,86.42 192.77,86.42 192.57,86.63 JDIMM1.233
M_A_DQ57: length 81.3
  TOP w0.102: v2(193.71,82.38) 193,83.09 193,84.43 190.65,86.78 JDIMM2.232
  IN03 w0.13: v2(193.71,82.38) 194.08,82.01 194.08,81.69 193.95,81.56 193.38,81.56 193.25,81.69 193.25,82.21 193.16,82.3 192.75,82.3 192.63,82.43 192.63,82.68 192.75,82.81 193.16,82.81 193.29,82.93 193.29,83.16 193.16,83.29 192.88,83.29 192.62,83.55 192.62,90.37 194.56,92.31 194.56,93.55 198.29,97.29 198.29,105.61 198.42,105.74 198.67,105.74 198.8,105.87 198.8,106.13 198.67,106.26 198.42,106.26 198.29,106.39 198.29,106.65 198.42,106.78 198.67,106.78 198.8,106.91 198.8,107.17 198.67,107.3 198.42,107.3 198.29,107.43 198.29,107.69 198.42,107.82 198.67,107.82 198.8,107.95 198.8,108.2 198.67,108.33 198.42,108.33 198.29,108.46 198.29,108.72 198.42,108.85 198.67,108.85 198.8,108.98 198.8,109.24 198.67,109.37 198.42,109.37 198.29,109.5 198.29,109.76 198.42,109.89 198.67,109.89 198.8,110.01 198.8,110.28 198.67,110.4 198.42,110.4 198.29,110.53 198.29,116.16 194.86,119.59 194.86,123.32 191.97,126.22 189.73,126.22 188.61,127.33 185.11,127.33 184.65,127.79 v2(184.09,127.79)
  BOTTOM w0.076: v2(184.09,127.79) 184.09,128.63 183.18,129.54 183.18,129.87 182.81,130.23 182.81,130.52 182.73,130.6 U1.M1
  BOTTOM w0.102: v2(193.71,82.38) 193.58,82.25 193.43,82.25 193.3,82.38 193.3,83.47 193.2,83.57 193.05,83.57 192.95,83.47 192.95,81.93 192.32,81.3 192.32,81.07 192.22,80.97 192.22,80.53 192.32,80.44 JDIMM1.232
M_A_DQ58: length 80.2
  TOP w0.102: v2(196.98,83.65) 197.41,83.22 197.41,82.18 196.44,81.21 196.26,81.21 195.61,80.57 195.17,80.57 194.9,80.29 JDIMM2.249
  IN03 w0.13: v2(183.92,132.44) 184.4,132.44 184.63,132.21 184.63,131.47 185.08,131.02 189.3,131.02 189.76,130.56 193.26,130.56 198.11,125.71 199.97,125.71 203.19,122.48 203.19,107.87 203,107.68 203,99.46 203.19,99.27 203.19,95.81 201.82,94.44 201.82,94.25 201.97,94.11 201.97,93.93 201.78,93.74 201.6,93.74 201.45,93.89 201.27,93.89 201.09,93.7 201.09,93.52 201.28,93.32 201.28,93.14 201.1,92.96 200.92,92.96 200.72,93.16 200.54,93.16 200.35,92.97 200.35,92.79 200.55,92.59 200.55,92.41 200.37,92.22 200.18,92.22 199.99,92.42 199.8,92.42 198.14,90.76 198.14,86.82 196.56,85.24 196.56,84.07 v2(196.98,83.65)
  BOTTOM w0.102: v2(196.98,83.65) 196.7,83.65 196.57,83.77 196.57,85.91 196.67,86.01 197.37,86.01 197.49,86.13 197.49,86.3 197.37,86.42 196.67,86.42 196.57,86.52 JDIMM1.249
  BOTTOM w0.14: v2(183.92,132.44) 183.59,132.77 U1.L4
M_A_DQ59: length 81.4
  TOP w0.102: v2(196.98,82.38) 196.54,82.82 196.54,85.29 195.81,86.02 194.77,86.02 194.15,86.63 JDIMM2.246
  IN03 w0.13: v2(196.98,82.38) 196.26,82.38 196.13,82.5 196.13,82.71 196.26,82.83 196.39,82.83 196.51,82.96 196.51,83.19 196.21,83.49 196.21,85.53 197.78,87.1 197.78,90.94 202.79,95.94 202.79,98.05 202.51,98.33 202.51,98.55 202.79,98.83 202.79,99.09 202.51,99.37 202.51,107.88 202.79,108.16 202.79,122.38 199.84,125.33 197.81,125.33 193.49,129.65 190.16,129.65 189.12,130.69 184.83,130.69 184.4,131.12 183.94,131.12 v2(183.92,131.14)
  BOTTOM w0.102: JDIMM1.246 195.82,80.48 195.72,80.57 195.42,80.57 195.29,80.7 195.29,80.87 195.42,81 195.95,81 196.21,81.25 196.21,83.05 196.3,83.15 196.42,83.15 196.51,83.05 196.51,82.08 196.63,81.97 196.87,81.97 197,82.1 197,82.36 v2(196.98,82.38)
  BOTTOM w0.14: v2(183.92,131.14) 183.59,131.47 U1.L2
M_A_DQ60: length 80.6
  TOP w0.102: JDIMM2.245 193.9,80.28 194.79,81.18 195.78,81.18 196.5,81.9 196.5,82.24 196.38,82.37 196.04,82.37 195.91,82.24 195.91,81.95 195.71,81.74 v2(195.36,81.74)
  IN03 w0.13: v2(195.36,81.74) 195.04,81.74 194.13,82.65 194.13,87.56 194.69,88.12 194.69,90.94 199.92,96.17 199.92,112.98 199.79,113.11 199.62,113.11 199.49,113.24 199.49,115.15 199.62,115.28 199.77,115.28 199.89,115.41 199.89,115.67 199.77,115.8 199.62,115.8 199.49,115.93 199.49,116.19 199.62,116.32 199.64,116.32 199.77,116.45 199.77,116.67 199.64,116.79 199.23,116.79 196.03,119.99 196.03,124.13 192.7,127.46 189.88,127.46 189.05,128.3 185.52,128.3 184.22,129.59 v2(182.3,129.59)
  BOTTOM w0.076: v2(182.3,129.59) 182.3,130.15 182.15,130.3 182.15,132.83 U1.M5
  BOTTOM w0.102: JDIMM1.245 195.57,86.1 195.87,85.8 195.87,82.25 v2(195.36,81.74)
M_A_DQ61: length 80.3
  TOP w0.102: JDIMM2.236 191.65,86.67 191.57,86.59 191.57,86.49 191.7,86.36 192.31,86.36 192.33,86.39 192.49,86.39 192.61,86.27 192.61,86.1 192.54,86.03 192.54,85.86 192.66,85.74 192.83,85.74 192.88,85.79 193.05,85.79 193.17,85.67 193.17,85.5 193.11,85.44 193.11,85.3 193.3,85.1 193.3,84.05 v2(193.71,83.65)
  IN03 w0.13: v2(183.64,128.24) 184.66,128.24 185.26,127.64 188.74,127.64 189.83,126.55 192.17,126.55 195.22,123.5 195.22,119.74 198.65,116.31 198.65,111.28 199.16,110.77 199.16,105.37 199.03,105.24 198.78,105.24 198.65,105.11 198.65,104.85 198.78,104.72 199.03,104.72 199.16,104.59 199.16,104.33 199.07,104.25 199.03,104.2 198.78,104.2 198.65,104.07 198.65,103.81 198.78,103.69 199.03,103.69 199.16,103.56 199.16,103.3 199.03,103.17 198.78,103.17 198.65,103.04 198.65,102.78 198.78,102.65 199.03,102.65 199.16,102.52 199.16,102.26 199.03,102.13 198.78,102.13 198.65,102 198.65,101.74 198.78,101.61 199.03,101.61 199.16,101.49 199.16,101.23 199.03,101.1 198.78,101.1 198.65,100.97 198.65,100.71 198.78,100.58 199.03,100.58 199.16,100.45 199.16,100.19 199.03,100.06 198.78,100.06 198.65,99.93 198.65,99.67 198.78,99.54 199.03,99.54 199.16,99.41 199.16,99.15 199.03,99.02 198.78,99.02 198.65,98.89 198.65,98.64 198.78,98.51 199.03,98.51 199.16,98.38 199.16,98.12 199.03,97.99 198.78,97.99 198.65,97.86 198.65,97.6 198.78,97.47 199.03,97.47 199.16,97.34 199.16,97.18 198.82,96.85 198.82,96.67 198.96,96.53 198.96,96.35 198.77,96.17 198.59,96.17 198.46,96.3 198.27,96.3 198.09,96.12 198.09,95.93 198.22,95.8 198.22,95.62 198.04,95.43 197.86,95.43 197.72,95.57 197.54,95.57 194.91,92.94 194.91,92.18 192.95,90.22 192.95,84.08 193.42,83.62 193.68,83.62 v2(193.71,83.65)
  BOTTOM w0.076: v2(183.64,128.24) 183.64,128.8 182.98,129.47 182.98,129.82 182.66,130.13 182.66,130.37 182.46,130.58 182.46,131.19 U1.M2
  BOTTOM w0.102: JDIMM1.236 193.32,80.3 193.19,80.43 192.81,80.43 192.68,80.56 192.68,81.23 193.39,81.94 193.87,81.94 194.11,82.19 194.11,83.18 193.71,83.59 v2(193.71,83.65)
M_A_DQ62: length 80.3
  TOP w0.102: v2(196.98,84.92) 197.47,84.43 197.65,84.43 197.87,84.65 197.87,84.83 196.36,86.34 195.22,86.34 195.1,86.45 195.1,86.65 195.15,86.69 JDIMM2.250
  IN03 w0.13: v2(196.98,84.92) 196.98,85.18 198.5,86.69 198.5,88.81 198.62,88.94 199,88.94 199.13,89.07 199.13,89.33 199,89.46 198.62,89.46 198.5,89.59 198.5,89.84 199.01,90.36 199.01,90.54 198.83,90.73 198.83,90.91 199.01,91.09 199.19,91.09 199.38,90.91 199.56,90.91 199.74,91.09 199.74,91.28 199.56,91.46 199.56,91.64 199.74,91.83 199.93,91.83 200.11,91.64 200.29,91.64 203.58,94.92 203.58,100.74 203.45,100.87 203.45,101.26 203.58,101.39 203.58,101.78 203.45,101.91 203.45,102.3 203.58,102.43 203.58,102.82 203.45,102.95 203.45,103.33 203.58,103.46 203.58,122.61 200.09,126.09 198.5,126.09 193.64,130.94 189.94,130.94 189.53,131.35 185.39,131.35 185.13,131.6 185.13,132.64 184.65,133.12 183.95,133.12 v2(183.92,133.09)
  BOTTOM w0.102: JDIMM1.250 196.82,81.42 197.41,82.01 197.41,84.49 v2(196.98,84.92)
  BOTTOM w0.14: U1.L5 183.59,133.42 v2(183.92,133.09)
M_A_DQ63: length 82
  TOP w0.102: JDIMM2.237 191.9,80.2 192.56,80.85 193.27,80.85 194.91,82.49 194.91,84.46 v2(195.36,84.92)
  IN03 w0.13: v2(195.36,84.92) 195.65,84.92 195.85,85.12 195.85,86.06 195.54,86.37 195.54,86.55 195.72,86.74 195.9,86.74 196.33,86.31 196.51,86.31 196.7,86.5 196.7,86.68 196.23,87.15 196.23,87.32 196.42,87.51 196.6,87.51 197.06,87.05 197.25,87.05 197.43,87.23 197.43,87.51 197.02,87.91 197.02,88.19 197.43,88.6 197.43,91.09 202.41,96.07 202.41,97.51 202.15,97.76 202.15,109.13 202.41,109.39 202.41,109.65 202.15,109.91 202.15,110.17 202.41,110.42 202.41,110.69 202.15,110.94 202.15,111.21 202.41,111.46 202.41,111.72 201.83,112.29 201.83,114.19 202.41,114.76 202.41,122.23 199.69,124.95 197.48,124.95 193.24,129.19 190.11,129.19 188.89,130.41 184.7,130.41 184.63,130.48 183.92,130.48 v2(183.92,130.49)
  BOTTOM w0.102: v2(195.36,84.92) 195.36,84.89 195.23,84.76 194.84,84.76 194.71,84.89 194.71,85.12 194.84,85.25 195.04,85.25 195.19,85.4 195.19,85.55 195.09,85.65 194.12,85.65 194,85.77 194,85.94 194.12,86.06 195.09,86.06 195.19,86.16 195.19,86.39 195.07,86.52 193.7,86.52 193.57,86.64 JDIMM1.237
  BOTTOM w0.14: v2(183.92,130.49) 183.59,130.82 U1.L1
M_A_DQS_DN0: length 84.5
  TOP w0.102: v2(134.27,84.53) 134.09,84.35 133.64,84.35 133.4,84.11 JDIMM2.11
  IN03 w0.076: v2(147.62,132.04) 147.62,132.16 147.52,132.26 147.34,132.26 146.68,131.6 146.68,131.5 146.83,131.35 146.83,131.24 146.76,131.17 146.65,131.17 146.51,131.32 146.4,131.32 146.32,131.24 146.32,131.13 146.45,131 146.45,130.89 146.38,130.82 146.27,130.82 146.12,130.97 146.04,130.97 145.87,130.79 145.22,130.79 145.21,130.78 145.21,130.73 145.2,130.72 145.19,130.72
  IN03 w0.145: v2(134.27,84.53) 134.27,84.44 134.14,84.31 133.83,84.31 133.7,84.44 133.7,86.49 132.53,87.66 130.78,87.66 130.01,88.43 130.01,89.27 130.47,89.72 130.47,90.47 130.02,90.92 129.59,90.92 128.99,90.31 128.81,90.31 128.37,90.75 128.37,90.93 128.99,91.54 128.99,91.97 128.38,92.58 127.95,92.58 127.43,92.05 127.12,92.05 126.91,92.26 126.91,93.11 127.06,93.25 127.89,93.25 128.21,93.57 128.21,94.45 127.95,94.72 127.06,94.72 126.91,94.86 126.91,111.04 128.66,112.8 128.66,113.8 135.19,120.33 135.19,121.13 144.78,130.72 145.19,130.72
  BOTTOM w0.076: v2(147.62,132.04) 147.62,132.04 147.73,132.15 147.73,132.78 148.02,133.08 148.18,133.08 148.43,133.32 149.74,133.32 149.84,133.42 150.01,133.42 150.12,133.3 150.12,133.14 U1.BR5
  BOTTOM w0.102: JDIMM1.11 135.07,87.57 135.07,86.59 135.12,86.54 135.3,86.54 135.37,86.48 135.37,86.03 135.24,85.91 134.92,85.91 134.68,85.66 134.68,85.14 134.92,84.89 135.3,84.89 135.43,84.76 135.43,84.41 135.3,84.29 134.4,84.29 134.27,84.41 v2(134.27,84.53)
M_A_DQS_DN1: length 78.4
  TOP w0.102: v2(140.37,83.9) 140.18,84.08 139.18,84.08 138.93,84.33 138.93,84.92 139.18,85.17 139.34,85.17 139.47,85.3 139.47,85.7 139.34,85.83 138.96,85.83 138.65,86.14 JDIMM2.32
  IN03 w0.076: v2(149.15,127.99) 149.06,128.07 148.76,128.07 148.57,128.26 148.22,128.26 147.1,127.14 147.02,127.07 146.92,127.07 146.91,127.05
  IN03 w0.145: 146.91,127.05 146.4,126.55 145.87,126.55 139.57,120.25 139.57,119.11 133.24,112.78 133.24,106.72 133.07,106.55 132.7,106.55 132.3,106.15 132.3,105.61 132.62,105.29 132.88,105.29 133.02,105.14 133.02,104.56 132.88,104.42 132.62,104.42 132.3,104.1 132.3,103.29 132.66,102.93 133.09,102.93 133.24,102.78 133.24,96.35 136.6,92.98 136.6,92.36 136.46,92.22 136.22,92.22 135.92,91.92 135.92,91.31 136.22,91.01 136.46,91.01 136.6,90.86 136.6,88.39 138.31,86.68 138.54,86.68 139.27,85.95 139.27,84.09 139.67,83.7 140.16,83.7 v2(140.37,83.9)
  BOTTOM w0.076: 150.84,128.43 150.86,128.44 150.97,128.44 151.24,128.71 151.45,128.71 153.23,130.48 153.23,130.92 152.9,131.25 152.9,131.78 152.57,132.12 U1.BL3
  BOTTOM w0.102: v2(140.37,83.9) 140.37,84.02 140.49,84.15 140.74,84.15 140.89,84 140.89,81.21 140.62,80.94 140.62,80.45 140.56,80.39 140.38,80.39 140.32,80.33 JDIMM1.32
  BOTTOM w0.147: v2(149.15,127.99) 149.12,127.96 149.12,127.74 149.36,127.5 149.92,127.5 150.02,127.6 150.02,127.79 149.91,127.89 149.91,128.08 150.04,128.21 150.22,128.21 150.33,128.1 150.51,128.1 150.84,128.43
M_A_DQS_DN2: length 74.6
  TOP w0.102: JDIMM2.53 143.9,80.79 144.11,81 144.66,81 145.33,81.67 145.33,82.99 145.8,83.46 146.03,83.46 v2(146.21,83.65)
  IN03 w0.076: v2(151.23,126.94) 151.12,126.83 151.12,126.65 151.3,126.47 151.3,126.12 151.3,126.12 151.17,125.99 151.17,125.89 151.16,125.88 151.16,125.87
  IN03 w0.145: v2(146.21,83.65) 146.21,83.61 145.99,83.39 145.69,83.39 145.55,83.53 145.55,85.92 144.23,87.24 143.87,87.24 142.59,88.52 142.08,88.52 141.84,88.76 141.84,90.45 141.97,90.58 142.26,90.58 142.56,90.88 142.56,91.77 142.28,92.04 141.97,92.04 141.84,92.17 141.84,94.02 139.62,96.24 139.62,106.13 139.34,106.41 139.34,107.22 139.62,107.5 139.62,108.47 139.34,108.74 139.34,109.55 139.62,109.83 139.62,110.8 139.34,111.07 139.34,111.88 139.62,112.16 139.62,112.69 144.39,117.46 144.39,119.1 151.16,125.87
  BOTTOM w0.076: 153.88,128.05 153.89,128.06 154.01,128.06 154.17,128.22 154.32,128.22 155.63,129.52 155.63,130.37 155.37,130.63 155.37,131.67 155.47,131.77 155.47,132.25 155.35,132.36 155.19,132.36 155.07,132.25 U1.BG3
  BOTTOM w0.102: v2(146.21,83.65) 146.21,83.52 146.34,83.4 146.56,83.4 146.86,83.7 146.86,85.58 146.44,86 146.08,86 145.87,86.21 145.87,86.5 145.8,86.56 145.62,86.56 145.57,86.61 JDIMM1.53
  BOTTOM w0.147: v2(151.23,126.94) 151.23,126.72 151.41,126.54 152.37,126.54 153.82,128 153.88,128.05
M_A_DQS_DN3: length 74.2
  TOP w0.102: JDIMM2.74 149.15,85.82 149.4,85.58 149.54,85.58 149.66,85.45 149.66,85.07 149.54,84.94 149.33,84.94 149.08,84.7 149.08,84.01 149.4,83.7 149.84,83.7 149.95,83.81 150.11,83.81 v2(150.27,83.65)
  IN03 w0.076: 155.83,125.45 155.84,125.46 155.84,125.56 156.04,125.76 156.63,126.35 156.63,127.23 156.39,127.46 156.39,127.66 v2(156.5,127.77)
  IN03 w0.145: 155.83,125.45 154.22,123.83 148.89,118.51 148.89,116.03 145.87,113.01 145.87,108.63 145.55,108.31 145.22,108.31 145.05,108.14 145.05,107.61 145.22,107.44 145.55,107.44 145.87,107.12 145.87,106.3 145.55,105.98 145.22,105.98 145.05,105.81 145.05,105.28 145.22,105.11 145.55,105.11 145.87,104.79 145.87,104.25 145.53,103.91 145.53,103.21 145.87,102.87 145.87,96.16 147.77,94.25 147.77,92.27 147.92,92.13 148.61,92.13 148.91,91.83 148.91,90.96 148.61,90.66 147.89,90.66 147.77,90.54 147.77,88.97 148.28,88.46 148.45,88.46 151,85.92 151,84.18 150.63,83.81 150.44,83.81 v2(150.27,83.65)
  BOTTOM w0.076: U1.BD3 157.59,132.32 157.71,132.44 157.88,132.44 158.01,132.32 158.01,132.02 157.88,131.89 157.88,130.45 158.06,130.27 158.06,130.09 157.97,130.01 157.97,130
  BOTTOM w0.102: JDIMM1.74 150.82,80.42 150.87,80.47 151.06,80.47 151.12,80.52 151.12,83.7 150.93,83.88 150.37,83.88 150.27,83.79 v2(150.27,83.65)
  BOTTOM w0.147: 157.97,130 157.97,127.88 157.47,127.38 156.68,127.38 156.5,127.55 v2(156.5,127.77)
M_A_DQS_DN4: length 72.1
  TOP w0.102: JDIMM2.177 176.9,80.17 177.18,80.45 177.39,80.45 178.58,81.64 179.95,81.64 180.28,81.97 180.28,83.54 180.18,83.64 179.86,83.64 179.74,83.51 v2(179.74,83.39)
  IN03 w0.076: 176.75,124.74 176.73,124.75 176.73,124.85 176.49,125.1 176.49,125.46 175.8,126.14 175.69,126.14 175.53,125.99 175.53,125.86 v2(175.65,125.75)
  IN03 w0.145: 176.75,124.74 181.96,119.52 181.96,119.24 182.28,118.92 182.48,118.92 182.62,118.78 182.62,118.2 182.48,118.05 182.28,118.05 181.96,117.73 181.96,116.91 182.28,116.59 182.48,116.59 182.62,116.44 182.62,115.86 182.48,115.72 182.28,115.72 181.96,115.4 181.96,114.58 182.28,114.26 182.48,114.26 182.62,114.11 182.62,113.53 182.48,113.39 182.28,113.39 181.96,113.07 181.96,112.24 182.28,111.93 182.48,111.93 182.65,111.76 182.65,111.23 182.48,111.06 182.28,111.06 181.96,110.74 181.96,96.99 178.98,94.02 178.98,83.85 179.28,83.55 179.58,83.55 v2(179.74,83.39)
  BOTTOM w0.076: U1.AA3 175.92,132.12 175.64,131.83 175.64,130.66 175.86,130.43 175.86,130.25 175.95,130.16 175.95,130.15
  BOTTOM w0.102: JDIMM1.177 178.57,86.78 178.64,86.71 178.64,86.35 178.57,86.28 178.48,86.28 178.3,86.1 178.3,85.74 178.56,85.47 179,85.47 179.13,85.35 179.13,84.31 179.03,84.21 178.71,84.21 178.44,83.93 178.44,83.23 178.69,82.99 179.14,82.99 179.39,83.23 179.39,83.33 179.45,83.39 v2(179.74,83.39)
  BOTTOM w0.147: v2(175.65,125.75) 175.65,125.97 175.95,126.26 175.95,130.15
M_A_DQS_DN5: length 71.8
  TOP w0.102: v2(184.94,83.26) 184.76,83.45 184.6,83.45 184.25,83.8 184.25,84.54 183.03,85.75 182.66,85.75 182.15,86.26 JDIMM2.198
  IN03 w0.076: 179.68,125.95 179.67,125.96 179.67,126.07 179.37,126.37 179.18,126.37 179.07,126.26 v2(179.07,125.92)
  IN03 w0.145: 179.68,125.95 182.79,122.84 184.5,122.84 187.99,119.35 187.99,112.57 188.32,112.23 188.57,112.23 188.7,112.1 188.7,111.49 188.57,111.36 188.24,111.36 187.94,111.06 187.94,110.2 188.24,109.9 188.5,109.9 188.62,109.77 188.62,109.16 188.5,109.03 188.26,109.03 187.95,108.73 187.95,108.15 188.26,107.85 188.5,107.85 188.62,107.72 188.62,107.11 188.5,106.98 188.32,106.98 188,106.66 188,97.06 184.14,93.2 184.14,91.91 184.55,91.5 184.55,90.82 184.14,90.41 184.14,83.78 184.48,83.43 184.78,83.43 v2(184.94,83.26)
  BOTTOM w0.076: 178.52,129.54 178.43,129.63 178.43,130.39 178.15,130.67 178.15,131.82 U1.U3
  BOTTOM w0.102: v2(184.94,83.26) 184.94,83.39 185.07,83.51 185.38,83.51 185.5,83.39 185.5,81.98 184.96,81.44 184.67,81.44 184.12,80.88 184.12,80.52 184.06,80.47 183.87,80.47 183.82,80.42 JDIMM1.198
  BOTTOM w0.147: v2(179.07,125.92) 179.07,126.09 179.29,126.31 179.29,128.53 178.52,129.31 178.52,129.54
M_A_DQS_DN6: length 78.8
  TOP w0.102: JDIMM2.219 187.4,80.35 187.44,80.39 187.64,80.39 187.7,80.45 187.7,80.72 188,81.03 189.3,81.03 189.78,81.51 190.24,81.51 190.65,81.92 190.65,83.39 190.52,83.51 190.28,83.51 190.15,83.39 v2(190.15,83.26)
  IN03 w0.076: v2(182.48,126.26) 182.36,126.38 182.36,126.55 182.48,126.66 182.65,126.66 182.92,126.39
  IN03 w0.145: 182.92,126.39 184.09,125.23 186.91,125.23 188.71,123.43 189.62,123.43 192.17,120.88 192.17,118.22 194.66,115.73 194.66,114.55 194.54,114.42 194.28,114.42 193.93,114.07 193.93,113.44 194.23,113.14 194.75,113.14 194.87,113.01 194.87,112.47 194.75,112.34 194.26,112.34 193.96,112.04 193.96,111.38 194.26,111.08 194.66,111.08 194.79,110.95 194.79,110.34 194.66,110.21 194.3,110.21 194.02,109.94 193.98,109.89 193.98,97.5 190.66,94.17 190.66,92.69 190.02,92.05 189.68,92.05 188.93,91.3 188.93,83.79 189.28,83.43 189.98,83.43 v2(190.15,83.26)
  BOTTOM w0.076: 180.92,130.29 180.79,130.29 180.66,130.42 180.66,131.65 180.77,131.75 180.77,131.93 U1.P3
  BOTTOM w0.102: JDIMM1.219 189.07,86.42 188.99,86.34 188.58,86.34 188.34,86.09 188.34,85.59 188.58,85.35 189.41,85.35 189.54,85.22 189.54,84.81 189.41,84.69 189.15,84.69 188.91,84.44 188.91,83.72 189.18,83.45 189.97,83.45 v2(190.15,83.26)
  BOTTOM w0.147: 180.92,130.29 180.99,130.21 182.69,128.52 182.69,126.69 182.48,126.48 v2(182.48,126.26)
M_A_DQS_DN7: length 81.9
  TOP w0.102: v2(195.36,83.65) 195.61,83.39 195.82,83.39 195.96,83.53 195.96,84.93 195.57,85.32 194.02,85.32 193.75,85.6 193.75,85.9 193.12,86.52 192.82,86.52 192.65,86.68 JDIMM2.240
  IN03 w0.076: v2(184.82,129.59) 185.16,129.59 185.34,129.77 185.7,129.77 185.77,129.84
  IN03 w0.145: 185.77,129.84 188.65,129.84 190.17,128.32 193.14,128.32 197.08,124.38 199.5,124.38 201.82,122.06 201.82,115.28 201.05,114.51 201.05,111.58 201.3,111.33 201.3,111.33 201.3,96.01 196.81,91.52 196.81,91.5 196.18,90.86 196.18,88.22 194.9,86.95 194.9,83.57 195,83.48 195.19,83.48 v2(195.36,83.65)
  BOTTOM w0.076: 183.89,129.8 183.88,129.82 183.83,129.82 183.43,130.22 183.43,130.45 183.18,130.7 183.18,131.64 183.09,131.73 183.09,132.28 183.2,132.39 183.36,132.39 183.47,132.28 U1.L3
  BOTTOM w0.102: JDIMM1.240 194.32,80.31 194.2,80.42 194.2,80.59 194.12,80.67 193.48,80.67 193.24,80.92 193.24,81.29 193.48,81.54 194.26,81.54 194.44,81.36 194.61,81.36 194.75,81.5 194.75,81.92 194.48,82.19 194.48,82.72 194.72,82.96 194.72,83.28 194.91,83.46 195.18,83.46 v2(195.36,83.65)
  BOTTOM w0.147: 183.89,129.8 184.47,129.23 184.67,129.23 184.82,129.37 v2(184.82,129.59)
M_A_DQS_DP0: length 84.6
  TOP w0.102: JDIMM2.13 133.9,79.38 133.9,80.34 133.85,80.4 133.66,80.4 133.61,80.45 133.61,84.03 133.73,84.15 134.14,84.15 134.27,84.02 v2(134.27,83.9)
  IN03 w0.076: v2(148.11,132.45) 148.07,132.41 147.27,132.41 145.8,130.94 145.28,130.94 145.2,131.02 145.19,131.02
  IN03 w0.145: v2(134.27,83.9) 134.27,83.92 134.17,84.01 133.7,84.01 133.4,84.31 133.4,86.37 132.41,87.36 130.66,87.36 129.71,88.3 129.71,89.39 130.17,89.85 130.17,90.35 129.9,90.62 129.72,90.62 129.11,90.02 128.69,90.02 128.08,90.63 128.08,91.05 128.69,91.66 128.69,91.84 128.25,92.28 128.07,92.28 127.55,91.76 127,91.76 126.61,92.14 126.61,93.23 126.93,93.55 127.77,93.55 127.92,93.7 127.92,94.28 127.77,94.42 126.93,94.42 126.61,94.74 126.61,111.17 128.37,112.92 128.37,113.92 134.89,120.45 134.89,121.25 144.66,131.02 145.19,131.02
  BOTTOM w0.076: U1.BP5 150.6,133.18 150.08,132.67 149.83,132.67 149.68,132.82 149.68,133.07 149.59,133.16 148.49,133.16 148.25,132.92 148.08,132.92 147.88,132.72 147.88,132.59 148.02,132.45 v2(148.11,132.45)
  BOTTOM w0.102: v2(134.27,83.9) 134.45,84.08 135.38,84.08 135.63,84.33 135.63,84.85 135.38,85.09 135.01,85.09 134.88,85.22 134.88,85.58 135.01,85.7 135.32,85.7 135.57,85.95 JDIMM1.13
M_A_DQS_DP1: length 78.4
  TOP w0.102: JDIMM2.34 139.15,86.61 139.09,86.55 138.92,86.55 138.86,86.48 138.86,86.22 139.04,86.03 139.42,86.03 139.67,85.79 139.67,85.21 139.42,84.97 139.26,84.97 139.14,84.84 139.14,84.41 139.26,84.29 140.24,84.29 140.37,84.41 v2(140.37,84.53)
  IN03 w0.076: 147.12,126.84 147.13,126.86 147.13,126.96 147.21,127.04 147.3,127.13 147.57,127.13 147.64,127.21 147.64,127.31 147.64,127.31 147.64,127.47 147.76,127.59 147.95,127.59 148.08,127.46 148.2,127.46 148.28,127.54 148.28,127.61 148.09,127.8 148.09,127.92 148.28,128.11 148.51,128.11 148.77,127.84 148.77,127.61 v2(148.7,127.54)
  IN03 w0.145: 147.12,126.84 146.52,126.25 145.99,126.25 139.86,120.12 139.86,118.98 133.54,112.66 133.54,106.6 133.19,106.25 132.82,106.25 132.6,106.03 132.6,105.73 132.74,105.59 133,105.59 133.32,105.27 133.32,104.44 133,104.12 132.74,104.12 132.6,103.98 132.6,103.41 132.79,103.23 133.22,103.23 133.54,102.91 133.54,96.47 136.9,93.11 136.9,92.24 136.58,91.92 136.34,91.92 136.21,91.79 136.21,91.43 136.34,91.31 136.58,91.31 136.9,90.99 136.9,88.51 138.44,86.97 138.66,86.97 139.57,86.07 139.57,84.22 139.74,84.05 139.91,84.05 140.37,84.51 v2(140.37,84.53)
  BOTTOM w0.076: U1.BK3 153.06,131.82 153.06,131.32 153.38,130.99 153.38,130.42 151.52,128.55 151.3,128.55 151.1,128.35 151.1,128.22 151.07,128.2
  BOTTOM w0.102: JDIMM1.34 140.82,80.85 141.09,81.12 141.09,84.08 140.82,84.35 140.55,84.35 v2(140.37,84.53)
  BOTTOM w0.147: 151.07,128.2 150.05,127.18 149.22,127.18 148.86,127.54 v2(148.7,127.54)
M_A_DQS_DP2: length 74.7
  TOP w0.102: v2(146.21,83.01) 146.21,83.13 146.08,83.26 145.89,83.26 145.54,82.91 145.54,81.59 144.75,80.8 144.2,80.8 144.11,80.71 144.11,80.48 144.16,80.42 144.35,80.42 144.4,80.37 JDIMM2.55
  IN03 w0.076: v2(150.78,126.49) 150.99,126.49 151.1,126.38 151.1,126.23 150.95,126.08
  IN03 w0.145: v2(146.21,83.01) 146.13,83.09 145.57,83.09 145.26,83.4 145.26,85.8 144.11,86.95 143.74,86.95 142.47,88.23 141.96,88.23 141.55,88.64 141.55,90.57 141.85,90.87 142.13,90.87 142.26,91 142.26,91.62 142.13,91.74 141.85,91.74 141.55,92.05 141.55,93.89 139.32,96.12 139.32,106.01 139.04,106.29 139.04,107.34 139.32,107.62 139.32,108.34 139.04,108.62 139.04,109.67 139.32,109.95 139.32,110.67 139.04,110.95 139.04,112.01 139.32,112.28 139.32,112.81 144.09,117.58 144.09,119.22 144.75,119.88 150.95,126.08
  BOTTOM w0.076: 154.11,127.82 154.12,127.83 154.12,127.96 154.24,128.07 154.39,128.07 155.78,129.46 155.78,130.44 155.52,130.69 155.52,131.61 155.62,131.71 155.62,131.93 U1.BF3
  BOTTOM w0.102: JDIMM1.55 146.07,86.3 146.17,86.2 146.52,86.2 147.06,85.66 147.06,83.61 146.64,83.19 146.39,83.19 v2(146.21,83.01)
  BOTTOM w0.147: v2(150.78,126.49) 151,126.49 151.28,126.22 152.5,126.22 154.11,127.82
M_A_DQS_DP3: length 74.1
  TOP w0.102: JDIMM2.76 149.65,86.62 149.59,86.56 149.41,86.56 149.36,86.5 149.36,85.91 149.48,85.78 149.62,85.78 149.87,85.53 149.87,84.98 149.62,84.74 149.41,84.74 149.28,84.61 149.28,84.1 149.48,83.9 149.75,83.9 149.87,84.02 150.1,84.02 150.27,84.18 v2(150.27,84.28)
  IN03 w0.076: v2(156.05,127.32) 156.32,127.32 156.48,127.17 156.48,127.08 156.35,126.95 156.27,126.95 156.18,126.86 156.18,126.74 156.27,126.65 156.41,126.65 156.48,126.58 156.48,126.41 156.41,126.34 156,126.34 155.9,126.24 155.9,126.09 155.98,126.01 155.98,125.91 155.74,125.67 155.63,125.67 155.62,125.66
  IN03 w0.145: v2(150.27,84.28) 150.37,84.18 150.58,84.18 150.7,84.3 150.7,85.8 148.33,88.17 148.16,88.17 147.47,88.85 147.47,90.67 147.77,90.96 148.48,90.96 148.61,91.09 148.61,91.7 148.48,91.83 147.79,91.83 147.47,92.15 147.47,94.13 145.57,96.03 145.57,102.75 145.23,103.08 145.23,104.03 145.57,104.37 145.57,104.67 145.42,104.81 145.09,104.81 144.75,105.16 144.75,105.93 145.09,106.28 145.42,106.28 145.57,106.42 145.57,107 145.42,107.15 145.09,107.15 144.75,107.49 144.75,108.26 145.09,108.61 145.42,108.61 145.57,108.75 145.57,113.13 148.59,116.15 148.59,118.63 154.01,124.04 155.62,125.66
  BOTTOM w0.076: 158.3,130 158.21,130.09 158.21,130.33 158.03,130.51 158.03,131.83 158.32,132.12 U1.BC3
  BOTTOM w0.102: v2(150.27,84.28) 150.47,84.08 151.02,84.08 151.32,83.78 JDIMM1.76
  BOTTOM w0.147: v2(156.05,127.32) 156.27,127.32 156.54,127.05 157.6,127.05 158.17,127.62 158.3,127.75 158.3,130
M_A_DQS_DP4: length 72
  TOP w0.102: v2(179.74,84.03) 179.92,83.84 180.26,83.84 180.49,83.62 180.49,81.89 180.04,81.44 178.67,81.44 177.4,80.17 JDIMM2.179
  IN03 w0.076: 176.96,124.95 176.94,124.96 176.84,124.96 176.64,125.16 176.64,125.52 175.87,126.29 175.62,126.29 175.42,126.09 175.31,126.09 v2(175.2,126.2)
  IN03 w0.145: 176.96,124.95 182.26,119.65 182.26,119.36 182.4,119.22 182.6,119.22 182.92,118.9 182.92,118.07 182.6,117.75 182.4,117.75 182.26,117.61 182.26,117.03 182.4,116.89 182.6,116.89 182.92,116.57 182.92,115.74 182.6,115.42 182.4,115.42 182.26,115.28 182.26,114.7 182.4,114.55 182.6,114.55 182.92,114.24 182.92,113.41 182.6,113.09 182.4,113.09 182.26,112.95 182.26,112.37 182.4,112.22 182.6,112.22 182.95,111.88 182.95,111.1 182.6,110.76 182.4,110.76 182.26,110.61 182.26,96.87 179.28,93.89 179.28,83.98 179.41,83.85 179.56,83.85 v2(179.74,84.03)
  BOTTOM w0.076: U1.AB3 175.29,132.21 175.38,132.21 175.48,132.11 175.48,130.6 175.71,130.37 175.71,130.19 175.69,130.17 175.63,130.17 175.62,130.16 175.62,130.15
  BOTTOM w0.102: JDIMM1.179 179.07,86.78 178.84,86.55 178.84,86.27 178.65,86.08 178.57,86.08 178.5,86.01 178.5,85.82 178.65,85.68 179.08,85.68 179.33,85.43 179.33,84.22 179.11,84 178.8,84 178.65,83.85 178.65,83.32 178.77,83.19 179.06,83.19 179.18,83.32 179.18,83.41 179.56,83.79 179.67,83.79 179.74,83.86 v2(179.74,84.03)
  BOTTOM w0.147: 175.62,130.15 175.62,126.4 175.42,126.2 v2(175.2,126.2)
M_A_DQS_DP5: length 71.8
  TOP w0.102: v2(184.94,83.9) 184.94,83.78 184.82,83.65 184.68,83.65 184.45,83.88 184.45,84.62 183.11,85.96 182.75,85.96 182.36,86.35 182.36,86.5 182.42,86.56 182.59,86.56 182.67,86.64 182.67,87.56 JDIMM2.200
  IN03 w0.076: 179.89,126.16 179.88,126.17 179.79,126.17 179.44,126.52 179.11,126.52 178.96,126.37 v2(178.62,126.37)
  IN03 w0.145: 179.89,126.16 182.79,123.26 182.91,123.14 184.62,123.14 188.28,119.47 188.28,112.69 188.45,112.53 188.69,112.53 189,112.23 189,111.36 188.69,111.06 188.37,111.06 188.24,110.94 188.24,110.32 188.37,110.19 188.62,110.19 188.92,109.89 188.92,109.03 188.62,108.73 188.38,108.73 188.25,108.6 188.25,108.27 188.38,108.14 188.62,108.14 188.92,107.84 188.92,106.98 188.62,106.68 188.45,106.68 188.3,106.54 188.3,96.94 184.44,93.07 184.44,92.04 184.85,91.62 184.85,90.69 184.44,90.28 184.44,83.9 184.61,83.73 184.78,83.73 v2(184.94,83.9)
  BOTTOM w0.076: 178.19,129.54 178.19,129.56 178.28,129.65 178.28,130.33 178,130.61 178,132.13 177.91,132.22 177.8,132.22 177.71,132.12 U1.V3
  BOTTOM w0.102: v2(184.94,83.9) 185.13,83.72 185.46,83.72 185.71,83.47 185.71,81.89 185.04,81.23 184.75,81.23 184.32,80.8 JDIMM1.200
  BOTTOM w0.147: v2(178.62,126.37) 178.89,126.37 178.97,126.45 178.97,128.4 178.19,129.17 178.19,129.54
M_A_DQS_DP6: length 78.8
  TOP w0.102: v2(190.15,83.9) 190.33,83.72 190.6,83.72 190.85,83.47 190.85,81.83 190.33,81.31 189.87,81.31 189.38,80.83 188.09,80.83 187.9,80.64 JDIMM2.221
  IN03 w0.076: v2(182.03,126.71) 182.17,126.85 182.87,126.85 183.11,126.61 183.12,126.61 183.13,126.6
  IN03 w0.145: v2(190.15,83.9) 189.98,83.73 189.41,83.73 189.23,83.91 189.23,91.18 189.81,91.76 190.15,91.76 190.96,92.57 190.96,94.05 194.28,97.37 194.28,109.77 194.42,109.91 194.78,109.91 195.08,110.22 195.08,111.08 194.78,111.38 194.38,111.38 194.25,111.5 194.25,111.92 194.38,112.05 194.87,112.05 195.17,112.35 195.17,113.13 194.87,113.43 194.35,113.43 194.23,113.56 194.23,113.95 194.41,114.13 194.66,114.13 194.96,114.42 194.96,115.85 192.47,118.34 192.47,121.01 189.75,123.73 188.83,123.73 187.04,125.52 184.21,125.52 183.13,126.6
  BOTTOM w0.076: 180.69,130.06 180.68,130.07 180.68,130.15 180.63,130.2 180.49,130.35 180.49,131.73 180.59,131.83 180.59,132 180.61,132.02 180.61,132.16 180.54,132.24 180.34,132.24 U1.R3
  BOTTOM w0.102: v2(190.15,83.9) 190.15,83.78 190.02,83.65 189.26,83.65 189.11,83.8 189.11,84.36 189.24,84.48 189.5,84.48 189.74,84.73 189.74,85.3 189.5,85.55 188.67,85.55 188.54,85.68 188.54,86.01 188.67,86.13 189.07,86.13 189.27,86.34 189.27,86.49 189.33,86.55 189.52,86.55 189.57,86.6 JDIMM1.221
  BOTTOM w0.147: 180.69,130.06 180.76,129.98 182.37,128.38 182.37,126.83 182.25,126.71 v2(182.03,126.71)
M_A_DQS_DP7: length 81.8
  TOP w0.102: JDIMM2.242 193.15,86.78 193.95,85.98 193.95,85.69 194.11,85.53 195.65,85.53 196.16,85.02 196.16,83.44 195.9,83.19 195.54,83.19 v2(195.36,83.01)
  IN03 w0.076: v2(185.27,129.14) 185.17,129.23 185.17,129.39 185.4,129.62 185.69,129.62 185.77,129.54 185.78,129.54
  IN03 w0.145: v2(195.36,83.01) 195.19,83.18 194.88,83.18 194.61,83.45 194.61,87.07 195.88,88.35 195.88,90.99 196.52,91.63 196.52,91.64 201.01,96.13 201.01,111.2 200.76,111.46 200.76,114.63 201.53,115.4 201.53,121.93 199.38,124.08 196.96,124.08 193.02,128.02 190.05,128.02 188.52,129.54 185.78,129.54
  BOTTOM w0.076: 183.66,129.57 183.61,129.62 183.61,129.82 183.28,130.15 183.28,130.38 183.03,130.63 183.03,131.57 182.93,131.67 182.93,131.92 U1.M3
  BOTTOM w0.102: JDIMM1.242 194.82,80.29 194.68,80.43 194.48,80.43 194.41,80.51 194.41,80.67 194.2,80.88 193.57,80.88 193.44,81 193.44,81.21 193.57,81.33 194.17,81.33 194.35,81.15 194.69,81.15 194.95,81.42 194.95,82 194.69,82.27 194.69,82.63 194.93,82.88 194.93,83.19 194.99,83.26 195.23,83.26 195.36,83.13 v2(195.36,83.01)
  BOTTOM w0.147: 183.66,129.57 184.33,128.9 184.81,128.9 185.05,129.14 v2(185.27,129.14)
M_B_A0: length 88.3
  TOP w0.102: JDIMM4.144 166.85,73.61 167,73.46 168.42,73.46 169.04,72.84 169.04,70.46 v2(169.45,70.06)
  IN10 w0.076: 170.15,120.2 170.15,121.95 170.53,122.33 170.53,130.72 170.02,131.23 170.02,134.59 169.84,134.78 169.84,135.97 v2(169.46,136.35)
  IN10 w0.175: 170.15,120.2 169.97,120.02 169.97,107.37 169.26,106.66 169.26,106.27 169.44,106.09 169.84,106.09 170.01,105.92 170.01,105.57 169.84,105.39 168.83,105.39 168.65,105.22 168.65,104.87 168.83,104.69 169.84,104.69 170.01,104.52 170.01,104.17 169.84,103.99 169.44,103.99 169.26,103.82 169.26,95.71 169.08,95.54 168.78,95.54 168.66,95.41 168.66,94.97 168.78,94.84 169.08,94.84 169.26,94.66 169.26,94.31 169.08,94.14 168.71,94.14 168.58,94.01 168.58,93.56 168.71,93.44 169.08,93.44 169.26,93.26 169.26,92.18 167.53,90.45 167.53,88.29 167.2,87.96 167.2,85.98 167.53,85.65 167.53,81.39 167.25,81.11 167.25,78.46 167.53,78.18 167.53,74.53 168.63,73.43 168.63,70.03 168.86,69.8 169.2,69.8 v2(169.45,70.06)
  BOTTOM w0.076: U1.AJ9 169.13,136.03 v2(169.46,136.35)
  BOTTOM w0.102: v2(169.45,70.06) 169.9,69.6 169.9,66.81 169.78,66.68 169.51,66.68 169.39,66.81 169.39,67.14 169.26,67.26 168.8,67.26 168.55,67.01 JDIMM3.144
M_B_A1: length 86.7
  TOP w0.102: v2(164.5,72.29) 164.07,71.87 164.07,68.2 164.1,68.17 JDIMM4.133
  IN10 w0.076: v2(168.83,133.74) 168.5,133.41 168.5,132.24 168.19,131.93 168.19,131.17 168.02,130.99 168.02,121.69 166.14,119.82
  IN10 w0.175: v2(164.5,72.29) 164.5,73.22 163.7,74.02 163.7,75.01 163.93,75.24 163.93,92.06 164.23,92.36 164.23,93.07 163.93,93.37 163.93,93.88 164.06,94.01 164.38,94.01 164.54,94.16 164.54,108.98 164.71,109.15 166,109.15 166.18,109.33 166.18,109.68 166,109.85 164.71,109.85 164.54,110.03 164.54,110.38 164.71,110.55 166,110.55 166.18,110.73 166.18,111.08 166,111.26 164.71,111.26 164.54,111.43 164.54,111.78 164.71,111.96 166,111.96 166.18,112.13 166.18,112.48 166,112.66 164.71,112.66 164.54,112.83 164.54,113.14 164.79,113.39 165.86,113.39 166.14,113.67 166.14,119.82
  BOTTOM w0.102: v2(164.5,72.29) 164.78,72.29 164.9,72.16 164.9,70.87 165.03,70.74 165.25,70.74 165.37,70.87 165.37,72.44 165.16,72.66 165.16,72.83 165.28,72.95 165.5,72.95 165.8,73.25 JDIMM3.133
  BOTTOM w0.198: v2(168.83,133.74) U1.AK6
M_B_A2: length 89.1
  TOP w0.102: JDIMM4.132 163.85,73.56 162.29,72.01 162.29,70.74 162.59,70.44 163.24,70.44 163.35,70.32 163.35,68.6 163.24,68.48 v2(162.72,68.48)
  IN10 w0.076: v2(168.87,133.11) 168.87,132.35 168.37,131.85 168.37,131.07 168.18,130.88 168.18,121.5 166.69,120.02
  IN10 w0.175: v2(162.72,68.48) 162.72,67.83 163.54,67.01 165.2,67.01 166.09,67.9 166.09,70.71 165.04,71.76 165.04,73.49 164.31,74.22 164.31,91.29 165.25,92.23 165.25,93.5 165.14,93.6 165.14,107.5 166.69,109.05 166.69,120.02
  BOTTOM w0.076: v2(168.87,133.11) 168.56,133.42 U1.AK5
  BOTTOM w0.102: JDIMM3.132 165.55,67 165.3,67.25 164.7,67.25 163.87,68.08 163.87,69.41 163.13,70.16 162.55,70.16 162.25,69.86 162.25,68.95 v2(162.72,68.48)
