# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VBAT: length 90.8
  TOP w0.254: v2(111.09,22.3) 111.09,22.43 110.57,22.95 PR207.2 ; v2(87.13,3) 87.13,3.57 PR212.2
  TOP w0.508: v2(88.23,13.54) 88.23,14.49 PR205.1
  IN05 w0.254: v2(111.09,22.3) 110.97,22.18 106.24,22.18 105.86,21.8 98.27,21.8 95.4,18.93 95.4,15.56 93.92,14.07 93.92,11.01 94.81,10.12 94.81,8.48 93.95,7.62 90.39,7.62 87.28,4.5 87.28,3.15 v2(87.13,3)
  IN05 w0.508: v2(96.49,6.05) 97.71,7.27 97.71,18.58 99.02,19.89 105.25,19.89 105.89,20.53 111.6,20.53 112.24,21.16 112.24,22.81 110.71,24.34 v2(109.57,24.34)
  IN08 w0.508: v2(88.23,13.54) 90.17,15.48 90.17,21.83 v2(91.41,23.07)
  BOTTOM w0.508: PD202.2 95.6,6.3 95.85,6.05 v2(96.49,6.05)
  vias: v1(110.46,24.34) v2(100.68,25.1) v2(100.68,24.34) v2(101.44,25.1) v2(101.44,24.34) v2(102.46,25.1) v2(102.46,24.34) v2(103.22,25.1) v2(103.22,24.34) v2(104.11,25.1) v2(104.11,24.34) v2(104.87,25.1) v2(104.87,24.34) v2(105.63,25.1) v2(105.63,24.34) v2(106.39,25.1) v2(106.39,24.34) v2(107.16,25.1) v2(107.16,24.34) v2(107.92,25.1) v2(107.92,24.34) v2(108.81,25.1) v2(108.81,24.34) v2(109.57,25.1)
VCC0V9_CIO: length 1.8
  BOTTOM w0.203: v1(52.52,86.38) 52.2,86.06 U2005.R12 52.19,86.06 v1(51.87,86.38) ; U2005.R9 52.2,87.41 v1(52.5,87.71) 52.2,88.01 U2005.R8
VCC0V9_DP: length 6
  TOP w0.254: C2076.1 50.66,88.42 v1(50.57,88.33)
  TOP w0.305: v1(49.92,86.38) 49.79,86.52 C2074.1
  BOTTOM w0.203: U2005.L12 50.24,86.06 v1(49.92,86.38) 50.15,86.61 50.15,86.61 U2005.L11 ; U2005.M8 v1(50.57,87.68) ; U2005.T12 52.85,86.06 v1(53.17,86.38) U2005.V12 53.31,85.87 53.31,85.6 U2005.V13 ; U2005.M6 v1(50.57,88.33) U2005.L6 ; U2005.V11 v1(53.17,87.03) 52.85,86.71 U2005.T11
  vias: v1(49.92,87.68)
VCC0V9_LVR_OUT: length 10.3
  TOP w0.305: C2110.1 46.15,87.48 47.19,87.48 47.53,87.14 C2111.1 49.16,87.14 v1(49.27,87.03)
  TOP w0.356: C2110.1 45.54,87.51 45.21,87.18 v1(45.21,85.6) 45.21,84.2 C2109.1
  BOTTOM w0.178: 48.62,83.13 U2005.H18 ; U2005.F18 v1(47.97,83.13) ; v1(49.27,87.03) 49.59,86.71 U2005.J11
  BOTTOM w0.203: U2005.H11 v1(49.27,87.03)
VCC0V9_PCIE:
  vias: v1(49.92,82.48) v1(49.92,82.48) v1(50.57,84.43) v1(50.57,83.78) v1(50.57,83.13)
VCC0V9_SVR: length 2.1
  TOP w0.305: C2091.1 48.79,88.16 v1(49.27,87.68)
  BOTTOM w0.203: U2005.L9 v1(50.57,87.03) U2005.M9 ; v1(49.27,87.68) 49.59,87.36 U2005.J9
  vias: v1(47.97,85.73) v1(47.97,85.08) v1(48.62,85.73) v1(48.62,85.08) v2(40.48,97.11) v2(40.48,96.47) v2(40.48,95.84) v2(41.12,97.11) v2(41.12,96.47) v2(41.12,95.84)
VCC0V9_USB: length 2.4
  TOP w0.254: C2073.1 51.94,83.85 v1(51.87,83.78) 51.87,83.37 C2072.1
  BOTTOM w0.203: v1(51.87,83.78) 52.2,84.11 U2005.R16 52.04,84.27 52.04,84.6 U2005.R15
VCC1V8A_TBTA_LDO: length 5
  BOTTOM w0.254: C2121.1 28.54,69.96 v1(28.67,70.08) 29.79,71.2 30.32,71.2 30.96,71.83 31.2,71.83 U2007.K1
VCC1V8D_TBTA_LDO: length 12.8
  TOP w0.203: C2118.1 36.96,71.87 v1(36.93,71.83)
  TOP w0.254: R2077.1 33.5,80.06 v1(33.78,80.06)
  IN10 w0.203: v1(33.78,80.06) 34.72,80.06 35.1,79.68 35.1,77.85 36.29,76.66 36.29,72.72 36.93,72.09 v1(36.93,71.83)
  BOTTOM w0.203: v1(36.93,71.83) 36.93,72.22 36.26,72.88 U2007.A2
VCC3V3_ANA_PCIE: length 1
  TOP w0.305: C2107.1 49.89,83.81 v1(49.92,83.78)
  BOTTOM w0.203: U2005.L16 50.25,84.11 v1(49.92,83.78)
VCC3V3_ANA_USB2: length 1
  TOP w0.305: v1(49.92,84.43) 49.61,84.43 C2108.1
  BOTTOM w0.178: U2005.J16 49.6,84.11 v1(49.92,84.43)
VCC3V3_FLASH: length 59.3
  TOP w0.305: v1(32.86,71.45) 33.29,71.02 C2127.1 33.48,71.26 33.7,71.48 33.8,71.48 R2068.2 R2070.2
  TOP w0.356: v2(52.88,99.14) 53.05,98.96 R2019.2 R2018.2 R2017.2 ; v2(52.88,99.14) R2020.2 ; v2(52.88,99.14) 53.73,99.14 C2055.1 54.36,99.05 C2100.1 ; v1(33.73,78.82) 33.67,78.77 R2078.1
  IN03 w0.508: v2(39.72,98.89) 38.83,98 38.83,85.68 37.56,84.41 35.02,84.41 32.86,82.25 32.86,79.58 33.62,78.82 v1(33.73,78.82)
  IN08 w0.508: v2(52.88,99.14) 52.88,99.32 52.42,99.77 40.61,99.77 v2(39.72,98.89)
  IN10 w0.508: v1(33.73,78.82) 31.59,76.69 31.59,73.1 32.86,71.83 v1(32.86,71.45)
  BOTTOM w0.178: v1(32.86,71.45) 33.22,71.81 33.22,72.35 U2007.G1
  BOTTOM w0.508: U2012.8 53.05,99.32 v2(52.88,99.14)
VCC3V3_LC: length 12
  TOP w0.356: C2081.1 v1(52.52,88.33) ; v2(53.82,94.72) 53.84,94.69 53.84,93.78 R2013.2 R2012.2 R2014.2 R2011.2
  IN08 w0.254: v1(52.52,88.33) 52.52,89.59 53.05,90.12
  IN08 w0.356: v2(53.82,94.72) 53.82,93.3 52.55,92.03 52.55,91.27 53.05,90.76 53.05,90.12
  BOTTOM w0.178: U2005.R6 v1(52.52,88.33)
VCC3V3_S0: length 1
  TOP w0.356: C2151.1 51.89,85.72 v1(51.87,85.73)
  BOTTOM w0.254: v1(51.87,85.73) 52.19,85.41 U2005.R13
  vias: v1(54.45,85.12) v1(55.34,85.09)
VCC3V3_S0_SYS: length 2.1
  TOP w0.305: v1(48.63,87.69) 48.48,87.84 C2084.1
  TOP w0.356: C2083.1 42.29,90.72 v2(42.29,89.74)
  BOTTOM w0.254: U2005.H9 48.95,87.37 v1(48.63,87.69)
  vias: v1(51.25,84.43) v1(53.18,83.19) v1(53.78,83.78) v2(41.12,89.61) v2(41.62,90) v2(41.75,89.36) v2(43.02,90) v2(43.53,89.61) v2(43.73,75.01) v2(43.73,74.37) v2(43.73,73.74) v2(44.37,75.01) v2(44.37,74.37) v2(44.37,73.74) v2(60.8,82.5) v2(61.44,81.87)
VCC3V3_SX_SYS: length 21.7
  TOP w0.203: 27.37,78.09 U2011.6
  TOP w0.305: v1(27.37,76.25) v1(27.37,77.8) 27.37,78.09
  TOP w0.356: R2098.2 35.83,70.18 v1(35.71,70.31) 35.38,70.31 34.89,69.83 32.96,69.83 32.1,70.69 v1(32.1,71.45) 31.64,71 R2091.2
  IN10 w0.305: v1(27.37,76.25) 28.16,75.46 28.16,72.72 29.43,71.45 v1(32.1,71.45)
  BOTTOM w0.254: U2007.B1 35.75,72.38 35.68,72.32 35.68,71.05 36.29,70.44 C2124.1 ; v1(32.1,71.45) 32.1,71.61 32.63,72.14 32.63,72.27 U2007.H1
  BOTTOM w0.356: C2124.1 35.91,70.13 35.73,70.31 v1(35.71,70.31)
VCC3V3_SX_SYS_AR: length 44.1
  TOP w0.254: v1(60.93,95.96) 60.93,95.02 R2282.2
  TOP w0.305: v1(47.97,88.33) 47.78,88.52 C2082.1
  TOP w0.356: R2034.2 R2036.2 51.73,94.06 R2037.2 R2026.2 52.93,95.08 v2(53.18,95.33) ; R2024.2 v2(63.42,95.46) 63.42,95.71 63.11,96.02 60.98,96.02 v1(60.93,95.96) 60.55,96.35 57.94,96.35 ; R2056.2 57.94,94.89 58.13,94.69 R2023.2
  TOP w0.508: v2(53.18,95.33) 53.69,95.84 R2028.2 54.25,96.27 54.71,96.73 55.47,96.73 55.92,97.18 56.53,97.18 57.11,96.6 57.69,96.6 57.94,96.35 R2056.2
  IN03 w0.305: v2(63.42,95.46) 62.72,94.76 62.72,91.38 62.33,90.99 62.33,89.11 v2(62.96,88.47)
  IN05 w0.508: v2(51.91,91.9) 51.91,91.01
  IN08 w0.508: v2(53.18,95.33) 53.18,93.81 51.91,92.54 v2(51.91,91.9)
  BOTTOM w0.203: v1(47.97,88.33) 47.99,88.33 48.3,88.02 U2005.F8
  BOTTOM w0.254: v2(62.96,88.47) 62.83,88.47 62.33,88.98 62.33,91.22 62.03,91.52 60.62,91.52 R2066.2
  BOTTOM w0.356: R2053.2 54.02,96.8 53.18,95.96 v2(53.18,95.33)
VCC3V3_TBT_SX: length 9.9
  TOP w0.356: v1(32.23,73.36) 32.14,73.45 C2128.1 ; R2069.1 29.23,68.41 28.67,67.85 v2(28.67,67.77)
  IN08 w0.508: v1(32.23,73.36) 32.23,72.85 30.45,71.07 29.56,71.07 28.67,70.18 v2(28.67,67.77)
  BOTTOM w0.254: v1(32.23,73.36) 32.33,73.36 32.75,72.94 U2007.H2
VCC5V0_SYS: length 10
  IN08 w0.508: v1(32.75,76.41) 32.75,77.44 33.37,78.06 39.97,78.06 40.48,78.57 v2(40.48,78.82)
  BOTTOM w0.254: U2007.H10 v1(32.75,76.41)
  vias: v1(35.5,79.2) v1(35.5,78.64) v1(39.01,80.14) v1(39.08,79.3) v1(39.67,79.3) v1(39.67,78.74) v2(40.48,80.09) v2(40.48,79.45) v2(41.62,80.12) v2(41.62,79.48) v2(41.62,78.85)
VCC20V0_SYS: length 1.6
  BOTTOM w0.089: C2119.1 38.4,75.33
  BOTTOM w0.097: v1(39.85,75.26) 39.78,75.33 38.4,75.33
VCC_BOOT: length 2.8
  TOP w0.203: PR1189.2 131.16,188.42 129.98,189.6 PU1101.28
VCC_EN: length 4.2
  TOP w0.097: v2(121.38,194.77) 121.38,194.64 v1(121.76,194.26) 121.89,194.26 122.56,193.6 PU1101.2
  BOTTOM w0.097: v2(121.38,194.77) 121.11,194.5 PC1159.2 120.56,195.4 PR1242.1
VCC_ICCMAX: length 3.5
  TOP w0.203: PU1101.36 130.02,192.8
  TOP w0.254: 130.02,192.8 130.51,192.8 131.24,193.53 v1(131.74,193.53) 132.61,193.53 PR1191.2
VCC_PROG: length 3.8
  TOP w0.203: PU1101.10 122.48,190.4 121.15,189.07 121.15,188.52 120.92,188.29 PR1187.2
VCC_RTCEXT_CAP: length 2.4
  TOP w0.254: C209.2 235.22,52.4 235.43,52.61 235.43,53.34 235.1,53.67 v3(234.92,53.67)
  BOTTOM w0.254: v3(234.92,53.67) 235.1,53.67 235.47,53.3 U2.BA26
VCCIO_BST: length 3.5
  BOTTOM w0.203: 132.38,150.17 132.25,150.3 PU1204.5
  BOTTOM w0.381: 132.38,150.17 133.04,149.51 133.7,149.51 133.92,149.72 PR1225.1
VCCIO_EN: length 213.4
  IN05 w0.091: v2(50.9,47.2) 51.53,47.2 52.57,46.16 52.57,44 54.73,41.84 54.73,37.77 58.77,33.73 60.04,33.73 61.31,35 75.15,35 76.11,34.04 83.59,34.04 v2(84.17,34.62)
  IN08 w0.091: v2(84.17,34.62) 82.01,36.78 82.01,48.47 81.25,49.23 81.25,52.02 79.98,53.29 79.98,60.53 78.96,61.55 78.96,65.48 78.33,66.12 77.69,66.12 76.3,67.52 76.3,69.83 76.98,70.51 76.98,77.01 77.36,77.39 77.36,81.54 77.95,82.12 77.95,89.23 79.06,90.35 79.32,90.35 80.23,91.27 80.23,98.56 81.5,99.83 87.22,99.83 97.33,109.93 101.44,109.93 103.35,111.84 103.35,114 109.7,120.35 109.7,125.43 111.86,127.59 v2(114.78,127.59)
  IN10 w0.091: v2(114.78,127.59) 131.29,127.59 134.65,130.95 134.65,132.22 139.67,137.24 139.67,140.85 v2(135.4,145.11)
  BOTTOM w0.097: PU1204.28 135.36,152.16 135.48,152.28 PC1225.1 R520.2 R537.2 136.09,150.22 135.78,149.91 R51.1 136.24,149.15 136.24,148.03 136.11,147.91 136.11,145.82 v2(135.4,145.11) ; R841.1 51.23,47.53 v2(50.9,47.2)
VCCIO_GND: length 7.6
  BOTTOM w0.203: v2(132.38,156.01) 132.25,155.88 PU1204.19 ; PU1204.24 134.93,153.76 135.4,154.23 v3(135.4,154.36)
  BOTTOM w0.356: PC1225.2 137.71,152.28 v2(137.92,152.48) PC1272.2 ; v2(132.38,156.01) 132.58,156.21 PC1280.2 ; v2(137.87,154.84) 137.94,154.77 137.94,154.13 PR1232.1 ; PC1222.1 134.54,158.02 v3(134.13,158.42) 133.65,157.94 PR1224.2
  vias: v1(135.38,156.04)
VCCIO_GSNS: length 3.5
  BOTTOM w0.203: PR1229.2 PR1202.2 135.4,154.99 135.15,155.25 134.03,155.25 133.85,155.07 PU1204.23
VCCIO_LP_: length 2.1
  TOP w0.254: PR1220.2 133.98,150.6 v2(133.52,150.14)
  BOTTOM w0.203: v2(133.52,150.14) 133.45,150.21 PU1204.2
VCCIO_PWRGD: length 452.1
  TOP w0.097: PR1221.2 135.71,150.85 v2(135.12,151.44)
  IN05 w0.091: v2(49.5,39.2) 49.5,38.49 49.99,38 49.99,35.53 56.22,29.29 56.72,29.29 57.72,28.29 62.94,28.29 64.74,26.5 71.6,26.5 74.52,29.42 80.36,29.42 80.66,29.12 93.67,29.12 94.66,30.11 97.56,30.11 99.46,32 110.68,32 111.52,32.85 v2(114.01,32.85)
  IN08 w0.091: v2(173.83,195.41) 177.26,195.41 178.28,194.39 184.88,194.39 185.13,194.64 185.13,195.28 185.9,196.04 192.12,196.04 192.37,195.79 195.04,195.79 196.69,194.14 196.69,193.39 199.95,190.13 199.95,183.93 198.73,182.71 198.73,176.73 200.37,175.09 200.37,167.21 201.53,166.06 201.53,158.95 204.89,155.58 204.89,151.41 198.85,145.37 198.85,130.51 192.88,124.54 192.88,117.05 201.01,108.92 201.01,85.17 201.64,84.53 201.64,59.85 199.03,57.23 199.03,46.33 197.37,44.68 195.33,44.68 194.91,45.1 194.91,45.67 193.01,47.58 189.2,47.58 188.46,46.84 171.48,46.84 168.98,49.35 119.36,49.35 113.13,43.11 113.13,33.73 v2(114.01,32.85)
  IN10 w0.091: v2(173.83,195.41) 173.32,194.9 171.29,194.9 169.89,196.29 165.83,196.29 165.32,195.79 164.43,195.79 163.54,194.9 158.08,194.9 156.31,193.12 154.15,193.12 152.62,191.6 152.62,181.05 150.46,178.9 150.46,174.58 147.67,171.78 135.73,171.78 134.84,170.89 134.84,151.72 v2(135.12,151.44)
  BOTTOM w0.097: R521.1 47.47,40.97 47.72,41.23 48.1,41.23 48.3,41.02 48.3,40.37 48.47,40.21 49.02,40.21 49.28,39.95 49.28,39.4 49.48,39.2 v2(49.5,39.2) 49.61,39.2 50.42,40.01 R837.2 ; v2(135.12,151.44) 135,151.31 135,150.47 134.89,150.37 134.18,150.37 133.85,150.7 PU1204.1
VCCIO_SLEW: length 3.1
  BOTTOM w0.203: PU1204.21 133.05,155.49 133.65,156.09 133.88,156.09
  BOTTOM w0.356: PC1222.2 134.54,156.29 134.33,156.09 133.88,156.09
VCCIO_SW: length 3.9
  BOTTOM w0.508: PL1201.1 131.96,148.35 133.78,146.54 PC1271.2
  vias: v1(128.21,147.02)
VCCIO_TRIP: length 5.1
  BOTTOM w0.203: v1(132.58,158.58) PR1226.2 132.86,157.66 133.08,157.44 133.08,156.98 133.24,156.82 PR1224.1 133.65,156.59 132.65,155.6 PU1204.20
VCCIO_VIN:
  vias: v1(128.62,156.8) v2(129.64,156.54) v2(129.64,155.65) v2(129.64,154.89)
VCCIO_VREF: length 2.6
  BOTTOM w0.203: PU1204.26 135.45,152.96 135.52,153.03
  BOTTOM w0.356: 135.52,153.03 135.63,153.14 PR1231.1 136.11,153.22 PC1272.1
VCCIO_VREFIN: length 2.8
  BOTTOM w0.203: PU1204.25 135.17,153.36 135.34,153.53
  BOTTOM w0.356: 135.34,153.53 135.86,154.05 PR1231.2 136.09,154.11 PR1232.2
VCCIO_VSNS: length 4.4
  BOTTOM w0.203: PU1204.22 133.45,155.28 133.8,155.63 134.89,155.63 135.43,156.16 PR1201.1 PR1227.2
VCCIOP:
  vias: v1(138.14,142.95)
VCCSENSE_NVVDDS: length 104.6
  IN08 w0.254: v2(207.11,101.43) 207.23,101.55 207.23,106.41 207.71,106.89 208.38,106.89 209.14,107.65 209.14,112.96 208.5,113.59 204.67,113.59 204.18,113.11 200.25,113.11 194.79,118.57 194.79,122.51 200.88,128.6 200.88,144 206.98,150.1 206.98,151.08 207.36,151.46 208.12,151.46 v2(208.25,151.59)
  BOTTOM w0.2: v2(208.25,151.59) 208.38,151.46 209.39,151.46 209.77,151.08 217.14,151.08 219.04,152.99 223.34,152.99 223.87,152.45 225.2,152.45 233.81,143.84 235.76,143.84 G2.BM45
  BOTTOM w0.254: v2(207.11,101.43) 207.23,101.3 207.99,101.3 208.88,102.19 209.47,102.19 PR3437.2
VCCSENSE_VGA: length 132.8
  TOP w0.254: PR1473.2 298.7,181.44 299.05,181.44 299.43,181.05 v1(299.69,181.05) 300.07,181.05 300.45,180.67 300.45,178.64 300.2,178.39 299.18,178.39 296.89,176.1 288.77,176.1 v2(288.64,176.23)
  IN10 w0.254: v2(288.64,176.23) 288.51,176.1 288,176.1 286.15,177.96 286.15,180.5 284.91,181.74 282.98,181.74 282.67,181.44 282.04,181.44 281.45,182.02 278.66,182.02 v2(278.48,182.2) 278.3,182.02 274.59,182.02 273.22,180.65 269.87,180.65 269.26,180.04 266.19,180.04 263.4,182.83 261.56,182.83 259.65,180.93 259.14,180.93 258.51,180.29 256.73,180.29 256.35,180.67 251.46,180.67 250.57,181.56 247.84,181.56 247.08,180.8 239.46,180.8 237.3,178.64 235.2,178.64 234.57,179.28 228.92,179.28 226.79,177.15 226.79,155.69 224.85,153.75 224.5,153.75 v2(224.16,154.09)
  BOTTOM w0.15: 236.78,144.32 236.44,144.32 236.09,144.67
  BOTTOM w0.2: 236.78,144.32 237.14,143.97 G2.BK45 ; 236.09,144.67 234.2,144.67 225.04,153.83 224.42,153.83 v2(224.16,154.09)
  BOTTOM w0.254: v2(278.48,182.2) 278.3,182.38 PR3530.2
VCCSFR_OC_EN: length 2.1
  TOP w0.097: PC1226.1 PR1258.1 190.47,129.04 PU1254.2
VCCST_SFR_ENABLE_EN: length 2.7
  TOP w0.097: PR1317.2 PC1316.1 202.79,152.61 202.23,153.17 PU1308.2
VCCSTG_EN: length 4
  TOP w0.097: PR1253.1 206.52,153.47 PC1227.1 207.79,153.9 v1(207.79,154.38) 207.79,155.22 207.31,155.71 PU1252.2
VDD18_GPU: length 2.9
  TOP w0.254: C2218.1 247.69,117.1 v3(248.23,117.1)
  TOP w0.356: v3(248.23,117.66) 248.08,117.81 C2214.1
  BOTTOM w0.356: C2217.1 v2(234.52,112.75) ; C2220.1 v2(232.89,113.36)
  vias: v1(219.93,119.21) v2(221.33,120.35) v2(222.09,120.35) v2(222.85,120.98) v2(222.85,120.35) v3(244.64,120.52) v3(244.64,119.83) v3(245.93,120.52) v3(245.99,119.77) v3(246.83,120.52) v3(246.78,119.77) v3(248.04,120.52) v3(248.09,119.77) v3(248.93,120.52) v3(248.88,119.77) v3(250.13,120.52) v3(250.18,119.77)
VDDQ_FB_R: length 4.4
  TOP w0.254: PC413.1 PR408.1 105.33,91.72 105.28,91.77 PR441.1
  TOP w0.381: PR408.1 105.76,92.54 105.96,92.74 PR440.1 106.72,93.17 v1(106.88,93.32)
VDDQ_PWRGD: length 121.1
  TOP w0.097: PR411.1 107.66,88.52 108.08,88.52 108.58,88.01 v2(108.97,88.01) 109.35,88.39 109.35,88.52 109.18,88.69 PU401.10
  IN05 w0.091: v2(97.12,46.31) 97,46.18 90.27,46.18 89.49,46.96 73.11,46.96 72.75,47.31 61.71,47.31 55.72,53.29 55.47,53.29 53.31,55.45 53.31,57.99 52.28,59.02 46.34,59.02 45.22,57.9 43.02,57.9 39.76,61.17 37.18,61.17 v2(36.29,60.28)
  IN08 w0.091: v2(97.12,46.31) 97.12,51.9 98.01,52.78 98.01,61.42 99.66,63.07 100.43,63.07 102.71,65.36 102.71,65.87 108.47,71.63 108.47,87.52 v2(108.97,88.01)
  BOTTOM w0.097: R257.2 v2(36.29,60.28)
VDDQ_VTT_EN: length 139.4
  TOP w0.097: PU401.7 108.15,89.89 v2(107.92,90.12) 107.66,89.87 PC439.2 ; v2(108.55,95.71) 108.21,95.37 U56.4 107.64,95.01 107.37,94.75 R49.1
  IN05 w0.091: v2(96.87,30.94) 93.82,30.94 93.44,30.56 85.06,30.56 84.39,29.89 81.05,29.89 80.87,30.07 74.16,30.07 71.34,27.26 65.12,27.26 63.34,29.03 58.14,29.03 57.15,30.02 56.65,30.02 51.31,35.36 51.31,39.62 50.21,40.72 v2(48.74,40.72)
  IN08 w0.091: v2(96.87,30.94) 96.34,30.94 95.98,31.3 95.98,32.08 93.52,34.54 93.52,39.47 94.94,40.89 95.65,40.89 96.68,41.93 96.68,45.86 96.61,45.93 96.61,51.89 97.63,52.91 97.63,61.42 98.01,61.8 98.01,63.71 103.85,69.55 103.85,87.07 104.62,87.84 104.62,90.01 105.37,90.76 107.28,90.76 v2(107.92,90.12) 107.92,91.27 107.79,91.39 107.79,92.15 108.17,92.54 108.17,93.17 108.55,93.55 v2(108.55,95.71)
  BOTTOM w0.097: R839.2 48.74,41.56 v2(48.74,40.72)
VSSSENSE_NVVDDS: length 104.7
  IN08 w0.254: v2(207.11,100.79) 207.23,100.92 207.36,100.92 207.61,101.17 207.61,106.25 207.87,106.51 208.53,106.51 209.52,107.49 209.52,113.14 208.68,113.97 204.41,113.97 203.93,113.49 200.5,113.49 195.17,118.82 195.17,122.25 201.26,128.35 201.26,143.76 207.36,149.86 207.36,150.83 207.61,151.08 208.12,151.08 v2(208.25,150.96)
  BOTTOM w0.2: G2.BM44 235.88,143.27 235.63,143.52 233.65,143.52 225.07,152.1 223.62,152.1 223.11,152.61 219.17,152.61 217.27,150.7 209.65,150.7 209.26,151.08 208.38,151.08 v2(208.25,150.96)
  BOTTOM w0.254: v2(207.11,100.79) 207.23,100.92 208.15,100.92 209.04,101.81 209.59,101.81 PR3436.2
VSSSENSE_VGA: length 133.2
  TOP w0.254: v2(288.64,175.47) 288.89,175.72 297.05,175.72 299.34,178.01 300.35,178.01 300.96,178.61 v1(300.96,179.15) 300.96,180.8 300.2,181.56 299.56,181.56 299.31,181.82 298.52,181.82 PR1472.2
  IN10 w0.254: v2(288.64,175.47) 288.39,175.72 287.83,175.72 285.77,177.78 285.77,180.34 284.75,181.36 283.13,181.36 282.83,181.05 281.78,181.05 281.27,181.56 278.61,181.56 v2(278.48,181.44) 278.35,181.56 274.67,181.56 273.32,180.22 270.02,180.22 269.46,179.66 266.03,179.66 263.24,182.45 261.72,182.45 259.81,180.55 259.3,180.55 258.67,179.91 256.57,179.91 256.19,180.29 251.3,180.29 250.41,181.18 248,181.18 247.24,180.42 239.62,180.42 237.46,178.26 235.05,178.26 234.41,178.9 229.08,178.9 227.17,176.99 227.17,155.53 225.01,153.37 224.33,153.37 v2(224.16,153.2)
  BOTTOM w0.15: 236.01,144.34 236.39,143.97 G2.BL45
  BOTTOM w0.2: v2(224.16,153.2) 224.42,153.45 224.95,153.45 234.06,144.34 236.01,144.34
  BOTTOM w0.254: v2(278.48,181.44) 278.4,181.51 PR3529.2
1.05G_FB: length 3.6
  BOTTOM w0.254: PU702.4 218.02,167.14 PR721.1 PC721.2 218.28,165.99 PR719.1
1.05G_LX: length 1.5
  TOP w0.508: PC712.2 214.48,163.97 v3(214.03,164.43)
203_RAMP: length 3.8
  TOP w0.203: 122.17,190.7 122.27,190.8 PU1101.9
  TOP w0.381: PC1152.2 120.64,190.02 PR1196.2 121.52,190.05 v1(121.77,190.29) 122.17,190.7
203_VCC: length 2
  TOP w0.203: PU1101.7 122.52,191.6 122.27,191.85
  TOP w0.381: 122.27,191.85 v2(122.02,191.85) v2(121.38,191.85)
  vias: v1(121.61,190.66)
81203_RDY: length 7.1
  TOP w0.097: PR1241.2 121.33,192.61 v2(121.61,192.61) 122.03,192.61 122.65,192 PU1101.6
  BOTTOM w0.097: PR1240.2 118.59,192.23 118.69,192.13 119.73,192.13 120.21,192.61 v2(121.61,192.61)
+CORE_PLLVDD: length 3
  TOP w0.381: R35.1 233.27,128.98 232.89,128.6 232.89,127.21
  vias: v1(234.66,122)
+CORE_PLLVDD_GPU: length 61.1
  TOP w0.254: v3(260.63,141.52) 260.85,141.3 C698.1
  TOP w0.356: C2415.1 254.2,120.65 v3(254.34,120.52) ; C2416.1 242.39,129.47 242.67,129.75 v3(243.3,129.75) 243.79,129.26 C697.1
  TOP w0.406: R35.2 235.92,129.16 238.55,129.16 238.86,128.86 v1(239.36,128.86) 240.76,128.86 241.14,129.24 C2416.1
  IN03 w0.356: v3(245.3,122.61) 245.27,122.61 244.44,123.44 244.44,128.98 243.68,129.75 v3(243.3,129.75)
  IN05 w0.381: v3(245.3,122.61) 245.3,122.03 246.09,121.24 253.61,121.24 v3(254.34,120.52) 255.44,121.62 262.86,121.62 263.49,122.25 263.49,123.27 263.41,123.36 263.41,139.36 262.22,140.54 261.61,140.54 v3(260.63,141.52)
  BOTTOM w0.254: G2.BB24 243.3,129.68 v3(243.3,129.75) ; v3(254.34,120.52) 254.09,120.27 G2.AF11 ; v3(260.63,141.52) 260.63,141.62 G2.U42
+FB_PLL_AVDD: length 48.1
  TOP w0.356: C691.1 263.89,123.92 v3(264.18,124.21) ; v3(264.23,138.82) 263.83,139.22 C692.1 ; v3(259.44,120.52) 259.81,120.89 C690.1 ; v3(248.94,141.52) 248.87,141.45 C686.1
  IN03 w0.406: v2(228.82,127.84) 232.25,127.84 236.44,123.65 236.44,123.14 236.95,122.63 243.38,122.63 244.19,121.82 244.19,121.36 244.44,121.11 262.35,121.11 263.75,122.51 263.75,123.78 v3(264.18,124.21)
  BOTTOM w0.254: G2.L38 264.34,138.82 v3(264.23,138.82) ; G2.V11 259.44,120.42 v3(259.44,120.52) ; v2(228.82,127.84) 228.7,127.84 227.93,127.08 227.43,127.08 v1(227.04,126.7) ; v3(264.18,124.21) 264.34,124.37 G2.L17
  BOTTOM w0.3: v3(248.94,141.52) 249.19,141.77 G2.AN42
+FB_PLLVDD: length 1.6
  TOP w0.097: v1(223.36,128.35) 223.36,127.4 C687.1
+GVDD_AMP: length 3.2
  TOP w0.254: U8.8 266.81,33.95
  TOP w0.305: C340.1 265.96,33.61 266.01,33.56 R325.1 266.81,33.95
+IFP_IOVDD: length 9.9
  TOP w0.356: C1396.1 v2(218.41,127.71)
  BOTTOM w0.203: G2.BC23 v3(242.48,128.27)
  BOTTOM w0.25: v3(243.23,126.22) 243.13,126.22 G2.BB20
  BOTTOM w0.254: G2.BB21 243.31,127.17 v3(243.33,127.18) ; v3(242.48,125.37) 242.19,125.07 G2.BC18 ; G2.BC15 242.19,122.97 v3(242.48,123.27) ; v3(243.23,128.32) 243.13,128.32 G2.BB23 ; v3(242.48,127.47) 242.19,127.17 G2.BC21 ; G2.BB18 243.06,125.24 v3(243.34,125.24) ; G2.BB17 243.13,124.12 v3(243.23,124.12) ; G2.BC20 v3(242.48,126.17) ; G2.BB15 243.14,123.22 v3(243.34,123.22) ; G2.BC17 242.48,124.07 v3(242.48,124.07)
  BOTTOM w0.356: C1394.1 229.69,124.14 v2(229.46,123.9) 229.22,124.14 C2443.1 ; C2444.1 v2(224.12,127.84) ; C1407.1 v2(226.3,124.67) ; C1395.1 v2(225.01,127.84)
  vias: v2(217.14,127.71) v2(217.77,127.71) v2(219.04,127.71) v2(219.68,127.71) v2(220.31,127.71)
+IFPAB_PLLVDD: length 8
  TOP w0.356: v3(241.79,127.47) 241.88,127.37 C1343.1 241.52,126.83 241.4,126.95 238.86,126.95 v1(238.47,127.33) 238.3,127.16 235.54,127.16 R41.2
  BOTTOM w0.254: G2.BD21 v3(241.79,127.47)
+IFPCD_PLLVDD: length 8
  TOP w0.356: R36.2 236.58,124.84 v1(240.38,124.84) 241.4,124.84 241.47,124.77 C701.1 241.76,125.34 v3(241.79,125.37)
  BOTTOM w0.254: v3(241.79,125.37) 241.49,125.07 G2.BD18
+IFPEF_PLLVDD: length 5.1
  TOP w0.356: R37.2 v1(238.98,122.63) 240,122.63 240.11,122.74 C702.1 241.38,122.74 241.79,123.15 v3(241.79,123.27)
  BOTTOM w0.254: G2.BD15 v3(241.79,123.27)
+NVVDDS: length 25.9
  TOP w0.229: v3(245.99,129.62) 246.69,130.32 C595.1
  TOP w0.356: v3(245.99,132.42) 245.99,132.18 245.59,131.78 PC1811.1 245.59,131.65 245.99,131.25 v3(245.99,131.02) ; v3(253.79,122.62) v3(253.79,123.32)
  TOP w0.381: v3(261.53,129.62) 261.53,129.76 C592.1 261.53,130.88 v3(261.53,131.02) ; v3(253.69,132.42) 253.69,132.19 C594.1 ; v3(255.89,131.02) 255.75,131.16 C593.1 255.75,132.28 v3(255.89,132.42)
  IN05 w0.381: v2(220.47,107.01) 219.42,107.01 216.45,104.04 215.67,104.04 214.9,104.8 213.96,104.8 213.63,104.47 v2(208.63,104.47)
  BOTTOM w0.25: G2.AG27 G2.AG28 253.69,132.37 v3(253.69,132.42) 253.69,132.47 G2.AG29
  BOTTOM w0.254: G2.AF26 G2.AF25 254.09,129.92 v3(253.79,129.62) 254.09,129.32 G2.AF24
  BOTTOM w0.381: v2(208.63,104.47) 208.71,104.4 PR3435.2
  vias: v1(224.89,106.38) v2(216,154.38) v2(216,153.75) v2(216.63,154.38) v2(216.63,153.75) v2(217.27,154.38) v2(217.27,153.75) v2(217.9,154.38) v2(217.9,153.75) v2(220.47,105.74) v2(221.33,107.01) v2(221.33,105.74) v2(222.22,107.01) v2(222.22,105.74) v2(222.98,107.01) v2(222.98,105.74) v2(223.74,107.01) v2(223.74,105.74) v2(224.5,107.01) v2(224.5,105.74) v2(225.17,107.01) v2(225.17,105.74) v2(225.8,107.01) v2(225.93,105.74) v2(226.64,107.01) v2(226.66,105.74) v2(226.79,103.46) v2(226.79,102.7) v2(227.43,107.01) v2(227.43,105.74) v2(228.19,107.01) v2(228.19,105.74) v2(228.95,107.01) v2(228.98,105.74) v2(229.81,107.01) v2(229.84,105.74) v2(230.63,107.01) v2(230.63,105.74) v2(231.62,103.46) v2(231.62,102.57) v2(231.9,107.01) v2(231.9,105.74) v2(232.38,103.46) v2(232.38,102.57) v2(233.14,106.51) v2(233.14,105.82) v2(234.41,106.51) v2(234.41,105.82) v2(235.71,107.01) v2(235.68,105.82) v2(236.62,107.01) v2(236.62,105.74) v2(236.95,104.98) v2(236.95,104.22) v2(236.95,103.46) v2(236.95,102.7) v2(237.36,107.01) v2(237.36,105.74) v2(238.37,107.01) v2(238.37,105.74) v3(245.36,140.12) v3(245.99,138.72) v3(245.96,124.72) v3(245.96,123.32) v3(246.01,122.62) v3(248.79,139.42) v3(248.79,138.72) v3(248.79,137.32) v3(248.79,132.42) v3(248.79,131.02) v3(248.79,129.62) v3(248.79,124.72) v3(248.76,123.32) v3(248.79,122.62) v3(251.53,123.32) v3(251.58,139.42) v3(251.58,138.72) v3(251.58,137.32) v3(251.58,133.07) v3(251.58,132.42) v3(251.58,131.02) v3(251.58,129.62) v3(251.58,128.97) v3(251.58,124.72) v3(251.58,122.58) v3(253.64,138.73) v3(253.66,139.43) v3(253.69,137.32) v3(253.79,124.72) v3(255.89,139.42) v3(255.89,138.72) v3(255.89,137.32) v3(255.89,129.62) v3(255.89,124.72) v3(255.89,123.32) v3(255.89,122.62) v3(258.69,139.42) v3(258.72,138.72) v3(258.69,137.32) v3(258.69,132.42) v3(258.69,131.02) v3(258.69,129.62) v3(258.69,124.72) v3(258.69,123.32) v3(258.66,122.63) v3(261.48,139.42) v3(261.52,138.72) v3(261.52,137.32) v3(261.48,132.42) v3(261.48,124.72) v3(261.48,123.32) v3(261.48,122.62)
+PEX_VDD: length 9.4
  TOP w0.356: v2(213.84,153.75) 212.19,153.75 211.68,154.26 211.68,156.61 R1008.2
  BOTTOM w0.254: G2.BD36 v3(241.79,137.97) ; G2.BC36 242.19,137.67 v3(242.48,137.97) ; v3(243.23,136.72) 243.13,136.72 G2.BB35 ; G2.BD33 v3(241.79,135.87) ; v3(243.23,137.92) 243.14,137.92 G2.BB36 ; v3(242.48,135.87) 242.19,135.57 G2.BC33 ; v3(243.23,135.82) 243.14,135.82 G2.BB33 ; G2.BC35 v3(242.48,136.67)
  vias: v1(215.23,151.97) v2(213.84,153.11) v2(213.84,152.48) v2(213.84,151.84) v2(214.47,153.75) v2(214.47,153.11) v2(214.47,152.48) v2(214.47,151.84) v2(217.14,129.75) v2(217.77,129.75) v2(218.41,129.75) v2(219.04,129.75) v2(219.68,129.75) v2(220.31,129.75) v2(222.35,151.21) v2(222.98,151.21)
+RTC_VCC: length 2.4
  TOP w0.508: v2(82.22,20.74) 82.09,20.6 R570.2
  BOTTOM w0.508: JRTC1.1 v2(82.22,20.74)
+V_BL_LED:
  vias: v1(191.1,194.9)
+V_CPU_VREF_CA: length 57.2
  IN08 w0.508: v2(162.72,94.57) 162.72,109.08 147.16,124.64 147.16,127.08 150.41,130.33 150.41,134.27 149.57,135.11 149.57,138.89 149.83,139.14 150.72,139.14 151.41,138.45 v2(151.59,138.45)
  BOTTOM w0.254: v2(151.59,138.45) 151.27,138.77 U1.BN13
  BOTTOM w0.457: R90.1 v2(162.72,94.57) C172.2
+V_CPU_VREF_DQ_CHA: length 1.2
  TOP w0.102: v2(150.29,138.45) 150.36,138.51 TP124.1
  BOTTOM w0.254: v2(150.29,138.45) 150.62,138.77 U1.BP13
+V_CPU_VREF_DQ_CHB: length 97
  IN08 w0.508: v2(148.11,138.31) 147.91,138.51 147.16,138.51 146.53,137.87 146.53,135.33 147.42,134.45 148.77,134.45 149.32,133.89 149.32,131.07 146.12,127.87 146.12,124.03 161.39,108.77 161.39,73.74 162.02,73.1 162.02,67.9 163.8,66.12 163.8,64.39 164.69,63.5 164.69,60.4 165.96,59.13 v2(166.47,59.13)
  BOTTOM w0.254: v2(148.11,138.31) 148.18,138.31 148.51,138.64 148.95,138.64 149.1,138.49 149.61,138.49 U1.BR13
  BOTTOM w0.457: C175.2 166.34,59.01 v2(166.47,59.13) 166.72,58.88 R94.1
+V_DIM_VREF_CA_CHA: length 34
  TOP w0.254: v2(174.4,89.61) 173.96,89.61 173.65,89.31 JDIMM2.164
  IN08 w0.508: v2(172.5,94.64) 173.32,93.82 173.32,90.38 174.09,89.61 v2(174.4,89.61) 174.85,89.61 175.48,88.98 175.48,77.42 176.12,76.79 v2(176.44,76.79)
  BOTTOM w0.254: v2(176.44,76.79) 175.93,76.79 175.32,77.4 JDIMM1.164
  BOTTOM w0.457: R90.2 164.69,94.52 R89.1 C38.2 R91.2 C70.1 C37.1 C173.2 C54.2 172.37,94.52 v2(172.5,94.64)
+V_DIM_VREF_CA_CHB: length 32.4
  TOP w0.254: JDIMM4.164 173.85,75.75 173.7,75.9 173.7,76.53 173.45,76.79 v2(172.5,76.79)
  IN08 w0.508: v2(172.5,76.79) 174.34,74.95 174.34,67.64 175.48,66.5 v2(175.48,64.34) 175.48,59.9 176.12,59.26 v2(176.12,59.13)
  BOTTOM w0.254: v2(175.48,64.34) 175.55,64.41 JDIMM3.164
  BOTTOM w0.457: R94.2 168.52,58.8 R93.1 R95.2 C103.2 C176.2 C104.1 C120.2 C136.1 175.79,58.8 v2(176.12,59.13)
+VGA_CORE: length 316.7
  TOP w0.254: PR914.2 283.86,178.44 v2(283.18,177.75) ; v2(280.13,184.99) 280.13,185.25 280.95,186.06 283.66,186.06 PR1013.2 ; v2(278.99,185.88) 279.11,186.01 279.11,187.91 279.88,188.67 283.48,188.67 PR1006.2 ; PR907.2 283.61,181.05 283.05,180.5 v2(283.05,180.22) ; PR3532.2 v2(283.86,182.88)
  TOP w0.356: v3(262.88,127.52) 262.97,127.61 C2336.1
  TOP w0.381: C2385.1 263.51,134.73 263.3,134.52 ; R1012.2 291.5,172.23 v2(291.31,172.42) ; C2392.1 263.51,134.3 263.3,134.52 ; v3(262.85,134.52) 263.3,134.52
  IN05 w0.381: v2(291.31,172.42) 283.43,172.42 283.08,172.77 283.08,175.24 281.68,176.64 281.68,181.26 279.52,183.42 272.82,183.42
  IN08 w0.254: v2(283.05,180.22) 282.92,180.34 282.92,183.72 283.69,184.48 283.69,188.04 281.53,190.2 273.91,190.2 273.65,190.45 271.37,190.45 270.1,189.18 260.57,189.18 v2(260.45,189.06) ; v2(272.64,189.06) 272.79,189.21 280.11,189.21 281.78,187.53 281.78,184.99 280.26,183.47 280.26,179.78 281.65,178.39 283.21,178.39 283.43,178.16 283.43,178.01 v2(283.18,177.75) ; v2(248.38,189.69) 248.51,189.82 249.65,189.82 250.29,190.45 268.7,190.45 269.84,191.6 274.29,191.6 274.67,191.21 281.78,191.21 285.59,187.4 285.59,183.72 285.46,183.59 284.32,183.59 283.86,183.14 v2(283.86,182.88) ; v2(280.13,184.99) 280.38,185.25 280.38,186.77 279.5,187.66 259.81,187.66 258.16,189.31 250.92,189.31 250.16,188.55 246.98,188.55 246.35,189.18 236.19,189.18 v2(236.06,189.06) ; v2(223.87,189.06) 224,189.18 230.09,189.18 231.36,187.91 245.59,187.91 246.09,187.4 250.67,187.4 251.43,188.17 257.65,188.17 259.18,186.64 278.61,186.64 278.99,186.26 v2(278.99,185.88)
  BOTTOM w0.25: G2.W30 v3(258.69,133.17) ; G2.AC33 256.19,135.62 v3(255.89,135.92) 256.19,136.21 G2.AC34 ; G2.R30 v3(261.48,133.17) ; G2.AC32 256.19,134.81 v3(255.89,134.52) 256.19,134.22 G2.AC31 ; G2.R32 261.79,134.81 v3(261.49,134.52) 261.79,134.22 G2.R31 ; G2.AC30 v3(255.89,133.17)
  BOTTOM w0.254: v2(260.45,189.06) 260.32,189.18 254.86,189.18 254.39,188.72 PL901.2 ; v2(272.64,189.06) 272.51,189.18 267.05,189.18 266.58,188.72 PL902.2 ; PL1001.2 217.82,188.84 218.03,189.06 v2(223.87,189.06) ; v2(248.38,189.69) 247.87,189.69 247.49,189.31 242.67,189.31 242.2,188.84 PL1810.2 ; v2(236.06,189.06) 235.93,189.18 230.35,189.18 230.01,188.84 PL1811.2
  BOTTOM w0.356: PR3530.1 277.29,183.72 273.53,183.72 273.02,183.21
  vias: v1(223.74,168.48) v2(214.47,184.86) v2(214.47,184.1) v2(214.47,183.34) v2(214.47,182.58) v2(215.23,184.86) v2(215.23,184.1) v2(215.23,183.34) v2(215.23,182.58) v2(215.36,181.94) v2(215.74,181.44) v2(216.38,181.44) v2(216.38,172.16) v2(216.76,180.8) v2(217.14,181.44) v2(217.52,180.8) v2(217.52,179.53) v2(217.52,178.77) v2(217.52,178.01) v2(217.52,177.24) v2(217.52,176.61) v2(217.9,181.44) v2(218.28,180.8) v2(218.28,179.53) v2(218.28,178.77) v2(218.28,178.01) v2(218.28,177.24) v2(218.28,176.61) v2(218.66,181.44) v2(218.92,180.8) v2(219.3,181.44) v2(220.06,181.44) v2(220.44,184.86) v2(220.44,184.1) v2(220.44,183.34) v2(220.44,182.58) v2(221.2,184.86) v2(221.2,184.1) v2(221.2,183.34) v2(221.2,182.58) v2(221.96,184.86) v2(221.96,184.1) v2(221.96,183.34) v2(221.96,182.58) v2(222.6,185.63) v2(222.6,184.86) v2(222.6,184.1) v2(222.6,183.34) v2(223.23,185.63) v2(223.23,184.86) v2(223.23,184.1) v2(223.87,185.63) v2(223.87,184.86) v2(223.87,184.1) v2(224.25,160.23) v2(224.25,159.46) v2(224.25,158.7) v2(224.5,185.63) v2(224.5,184.86) v2(224.5,184.1) v2(225.01,160.23) v2(225.01,159.46) v2(225.01,158.7) v2(225.14,184.1) v2(225.65,185.63) v2(225.9,184.74) v2(225.9,183.98) v2(225.9,183.21) v2(226.66,184.74) v2(226.66,183.98) v2(226.66,183.21) v2(226.66,182.45) v2(227.43,184.74) v2(227.43,183.98) v2(227.43,183.21) v2(227.43,182.45) v2(227.81,181.31) v2(228.31,162.51) v2(228.31,161.75) v2(228.31,160.99) v2(228.44,181.31) v2(229.08,181.31) v2(229.08,162.51) v2(229.08,161.75) v2(229.08,160.99) v2(229.48,178.26) v2(229.48,177.63) v2(229.48,176.99) v2(229.48,176.36) v2(229.84,181.31) v2(230.6,181.31) v2(231.36,181.31) v2(231.36,155.02) v2(232,181.31) v2(232.63,184.74) v2(232.63,183.98) v2(232.63,183.21) v2(232.63,182.45) v2(233.39,184.74) v2(233.39,183.98) v2(233.39,183.21) v2(233.39,182.45) v2(234.16,184.74) v2(234.16,183.98) v2(234.16,183.21) v2(234.16,182.45) v2(234.92,184.74) v2(234.92,183.98) v2(234.92,183.34) v2(235.68,184.74) v2(235.68,183.98) v2(235.68,183.34) v2(236.44,184.74) v2(236.44,183.98) v2(236.44,183.34) v2(237.33,184.74) v2(238.09,184.74) v2(238.09,183.98) v2(238.09,183.21) v2(238.86,184.74) v2(238.86,183.98) v2(238.86,183.21) v2(238.86,182.45) v2(239.62,184.74) v2(239.62,183.98) v2(239.62,183.21) v2(239.62,182.45) v2(239.87,181.31) v2(240.51,181.31) v2(241.14,181.31) v2(241.78,181.31) v2(242.41,181.31) v2(243.05,181.31) v2(243.81,181.31) v2(244.82,184.74) v2(244.82,183.98) v2(244.82,183.21) v2(244.82,182.45) v2(245.59,184.74) v2(245.59,183.98) v2(245.59,183.21) v2(245.59,182.45) v2(246.35,184.74) v2(246.35,183.98) v2(246.35,183.21) v2(246.35,182.45) v2(247.24,185.5) v2(247.24,184.74) v2(247.24,183.98) v2(248,185.5) v2(248,184.74) v2(248,183.98) v2(248.76,185.5) v2(248.76,184.74) v2(248.76,183.98) v2(249.52,185.5) v2(249.52,184.74) v2(249.52,183.98) v2(250.29,184.74) v2(250.29,183.98) v2(250.29,183.21) v2(251.05,184.74) v2(251.05,183.98) v2(251.05,183.21) v2(251.81,184.74) v2(251.81,183.98) v2(251.81,183.21) v2(251.81,182.45) v2(252.44,181.31) v2(253.08,181.31) v2(253.71,181.31) v2(254.48,181.31) v2(255.24,181.31) v2(256,181.31) v2(256.64,181.31) v2(257.02,184.74) v2(257.02,183.98) v2(257.02,183.21) v2(257.02,182.45) v2(257.14,181.82) v2(257.4,181.05) v2(257.78,184.74) v2(257.78,183.98) v2(257.78,183.21) v2(257.78,182.45) v2(258.16,181.82) v2(258.16,181.05) v2(258.54,184.74) v2(258.54,183.98) v2(258.54,183.21) v2(258.54,182.45) v2(259.18,184.74) v2(259.18,183.98) v2(259.18,183.21) v2(259.18,182.45) v2(259.94,185.5) v2(259.94,184.74) v2(259.94,183.98) v2(259.94,183.21) v2(260.7,185.5) v2(260.7,184.74) v2(260.7,183.98) v2(260.7,183.21) v2(261.46,185.5) v2(261.46,184.74) v2(261.46,183.98) v2(262.48,184.86) v2(262.48,184.1) v2(262.48,183.34) v2(263.24,184.86) v2(263.24,184.1) v2(263.24,183.34) v2(264,184.86) v2(264,184.1) v2(264,183.34) v2(266.29,181.44) v2(266.29,180.67) v2(267.05,181.44) v2(267.05,180.67) v2(267.81,181.44) v2(267.81,180.67) v2(268.57,180.67) v2(269.08,184.86) v2(269.08,184.1) v2(269.08,183.34) v2(269.08,182.58) v2(269.08,181.82) v2(269.72,181.82) v2(269.84,184.86) v2(269.84,184.1) v2(269.84,183.34) v2(269.84,182.58) v2(270.61,184.86) v2(270.61,184.1) v2(270.61,183.34) v2(270.61,182.58) v2(270.61,181.82) v2(271.37,184.86) v2(271.37,184.1) v2(271.37,183.34) v2(271.37,182.58) v2(272,184.1) v2(272,183.34) v2(272,182.58) v2(272.76,182.58) v3(234.66,149.56) v3(235.3,148.8) v3(235.48,146.42) v3(235.68,150.07) v3(235.68,149.3) v3(236.19,148.54) v3(236.32,150.07) v3(236.32,149.3) v3(236.88,146.42) v3(236.95,149.3) v3(236.95,148.54) v3(237.58,147.12) v3(238.29,146.42) v3(238.99,144.32) v3(239.69,145.02) v3(240.39,144.32) v3(241.09,145.02) v3(241.09,142.22) v3(241.09,140.87) v3(241.78,144.32) v3(241.78,142.92) v3(241.78,142.19) v3(241.88,146.47) v3(243.18,142.92) v3(243.17,142.19) v3(243.23,138.82) v3(243.88,145.07) v3(243.88,140.82) v3(244.58,142.92) v3(244.69,143.67) v3(245.33,142.93) v3(245.29,140.82) v3(245.99,135.92) v3(245.99,134.52) v3(245.99,133.17) v3(245.99,128.87) v3(245.98,127.52) v3(245.98,126.12) v3(246.69,140.82) v3(246.83,135.22) v3(247.39,139.42) v3(247.39,138.72) v3(247.39,137.32) v3(247.39,135.92) v3(247.39,134.52) v3(247.39,133.12) v3(247.39,132.42) v3(247.39,131.02) v3(247.39,129.62) v3(247.39,128.92) v3(247.38,127.52) v3(247.38,126.12) v3(247.38,124.72) v3(247.38,123.32) v3(247.39,122.62) v3(248.79,135.92) v3(248.79,134.52) v3(248.79,133.17) v3(248.79,128.87) v3(248.78,127.52) v3(248.78,126.12) v3(250.18,139.42) v3(250.18,138.72) v3(250.18,137.32) v3(250.18,135.92) v3(250.18,135.22) v3(250.18,134.52) v3(250.18,133.12) v3(250.18,132.42) v3(250.18,131.02) v3(250.18,129.62) v3(250.18,128.92) v3(250.18,127.52) v3(250.18,126.12) v3(250.18,124.72) v3(250.18,123.32) v3(250.18,122.62) v3(251.53,135.92) v3(251.54,135.22) v3(251.53,134.52) v3(251.58,127.52) v3(251.58,126.12) v3(252.42,123.32) v3(252.44,122.62) v3(252.99,139.42) v3(252.99,138.72) v3(252.99,137.32) v3(252.99,133.12) v3(252.99,132.42) v3(252.99,131.02) v3(252.99,129.62) v3(252.99,128.92) v3(254.52,139.42) v3(254.52,138.72) v3(254.48,133.12) v3(254.53,132.42) v3(254.53,131.02) v3(254.53,129.62) v3(254.48,128.92) v3(254.48,124.72) v3(254.48,123.32) v3(254.48,122.62) v3(255.89,128.87) v3(255.94,127.52) v3(255.93,126.82) v3(255.94,126.12) v3(257.28,139.42) v3(257.28,138.72) v3(257.28,137.32) v3(257.29,135.92) v3(257.29,134.52) v3(257.28,133.12) v3(257.34,132.42) v3(257.34,131.02) v3(257.28,129.62) v3(257.34,128.92) v3(257.28,127.52) v3(257.28,126.82) v3(257.28,126.12) v3(257.28,124.72) v3(257.28,123.32) v3(257.28,122.62) v3(258.69,135.92) v3(258.69,134.52) v3(258.69,128.87) v3(258.69,127.52) v3(258.69,126.12) v3(260.09,139.42) v3(260.09,138.72) v3(260.09,137.32) v3(260.09,135.92) v3(260.09,134.52) v3(260.09,133.12) v3(260.09,132.42) v3(260.09,131.02) v3(260.09,129.62) v3(260.09,128.92) v3(260.09,127.52) v3(260.09,126.12) v3(260.09,124.72) v3(260.09,123.32) v3(260.09,122.62) v3(260.63,126.82) v3(261.49,135.92) v3(261.48,128.87)
+VID_PLLVDD_GPU_1: length 17.8
  TOP w0.356: v3(241.79,121.17) 241.22,120.6 C696.1
  TOP w0.508: R33.2 226.59,121.69 v2(226.66,121.62)
  IN08 w0.381: v2(226.66,121.62) 227.04,121.24 236.32,121.24 236.95,120.6 241.27,120.6 241.79,121.12 v3(241.79,121.17)
  BOTTOM w0.254: G2.BD12 v3(241.79,121.17)
+VID_PLLVDD_GPU_2: length 23.1
  TOP w0.356: v3(242.92,120.87) 242.92,120.83 242.7,120.6 C695.1
  TOP w0.508: R34.2 225.14,122.19 v2(225.14,121.36)
  IN08 w0.381: v2(225.14,121.36) 225.77,121.36 228.82,118.32 241.27,118.32 242.18,119.23 242.18,120.13 v3(242.92,120.87)
  BOTTOM w0.254: G2.BC12 242.19,120.87 v3(242.92,120.87)
+VSTBY0_EC: length 5.2
  BOTTOM w0.356: 31.97,47.4 v1(31.97,47.76) 31.97,49.22 32.27,49.52 U5.A1
  BOTTOM w0.457: R232.2 C238.1 C239.2 31.41,46.84 31.97,47.4
+VTT_REFP: length 2.8
  TOP w0.254: v1(108.81,92.03) 109.24,92.46 PC410.1 110.06,92.22 PU401.4
AC_CHARGED_LED_W: length 144.4
  TOP w0.097: R184.1 v2(4.44,167.77)
  IN08 w0.089: 33.24,58.63 33.88,57.99 35.15,57.99 v1(35.68,57.46)
  IN08 w0.091: 33.24,58.63 33.12,58.75 33.12,62.06 32.1,63.07 26.26,63.07 24.35,64.98 24.35,66.63 23.08,67.9 23.08,69.8 19.53,73.36 19.53,77.3 33.24,91.01 33.24,107.01 21.94,118.32 19.27,118.32 14.51,123.08 14.51,124.95 13.68,125.77 13.68,133.05 14.57,133.94 14.57,140.03 8.73,145.88 8.73,164.16 5.12,167.77 v2(4.44,167.77)
  BOTTOM w0.076: 35.53,56.21 35.53,55.67 35.27,55.42 U5.M7
  BOTTOM w0.097: v1(35.68,57.46) 35.53,57.31 35.53,56.21
AC_CHARGING_LED_A: length 144.5
  TOP w0.097: R191.1 v2(6.27,168.43)
  IN08 w0.089: 33.75,58.63 34.13,58.25 35.78,58.25 36.04,57.99 36.04,55.71 v1(35.27,54.94)
  IN08 w0.091: v2(6.27,168.43) 9.11,165.59 9.11,145.9 14.95,140.06 14.95,125.94 34.77,106.12 34.77,102.8 33.62,101.65 33.62,90.76 19.78,76.91 19.78,73.74 23.4,70.12 23.4,67.96 24.61,66.75 24.61,65.05 26.33,63.33 32.35,63.33 33.37,62.31 33.37,59.01 33.75,58.63
  BOTTOM w0.089: U5.K7 v1(35.27,54.94)
AC_PRESENT: length 234.1
  TOP w0.097: R142.1 239.24,48.59 239.62,48.97 v3(240.13,48.97)
  IN05 w0.091: v2(43.4,46.82) 46.58,46.82 47.02,46.37 47.96,46.37 53.28,41.05 53.28,37.08 58.15,32.21 66.01,32.21 68.68,29.54 70.45,29.54 73.25,32.34 76.04,32.34 76.55,32.85 77.93,32.85 78.73,32.04 79.52,32.04 80.07,32.59 86.18,32.59 86.96,33.37 111.12,33.37 111.46,33.71 115.1,33.71 115.54,33.27 118.25,33.27 v2(118.71,33.73)
  IN08 w0.091: v2(149.57,39.96) 146.07,39.96 142.35,43.68 122.65,43.68 119.38,40.41 119.38,38.09 117.77,36.48 117.77,34.93 118.71,33.99 v2(118.71,33.73)
  IN10 w0.091: v2(149.57,39.96) 149.9,40.28 149.9,41.43 153.26,44.78 202.03,44.78 205.58,48.34 208.25,48.34 209.47,49.56 213.89,49.56 214.85,48.59 214.85,47.58 216.88,45.55 225.14,45.55 225.65,45.04 234.41,45.04 237.71,48.34 238.86,48.34 239.49,48.97 v3(240.13,48.97)
  BOTTOM w0.097: U2.BB15 241.24,52.63 241.01,52.4 241.01,49.86 v3(240.13,48.97) ; D5.2 v2(43.4,46.82)
AC_PRESENT_R: length 6.6
  BOTTOM w0.076: 38.42,50.66 38.04,50.66 37.78,50.91 U5.C12
  BOTTOM w0.089: 41.5,47.23 41.27,47.45 v1(40.84,47.45)
  BOTTOM w0.097: v1(40.84,47.45) 40.23,47.45 39.47,48.21 39.47,49.61 38.42,50.66 ; 41.5,47.23 D5.1
ACDET: length 6.5
  TOP w0.097: PU201.1 82.52,11 v1(82.32,11.2) 81.63,11.89 PC223.1 80.94,11.64 80.74,11.44 78.58,11.44 PR206.1 PR203.2
ACOK: length 84.2
  TOP w0.097: v3(82.01,10.72) 82.13,10.6 PU201.2
  IN05 w0.091: v2(29.69,43.26) 30.96,43.26 34.74,39.48 38.48,39.48 39.08,40.08 39.34,40.08 40.23,40.97 46.65,40.97 49.76,37.87 49.76,35.38 56.06,29.08 56.63,29.08 57.66,28.04 62.82,28.04 64.61,26.24 71.72,26.24 74.39,28.91 v2(79.6,28.91)
  IN08 w0.091: v3(82.01,10.72) 81.12,11.61 81.12,16.21 78.92,18.41 78.92,28.29 79.54,28.91 v2(79.6,28.91)
  BOTTOM w0.097: R245.2 R248.1 v2(29.69,43.26) v1(29.1,43.26)
ACOK_R: length 7.6
  BOTTOM w0.097: U5.A4 33.77,49 33.62,48.85 33.62,48.16 33.12,47.65 33.12,45.93 v1(32.36,45.17) 31.41,44.22 C71.1 R248.2
ADAPTER_ID: length 168
  TOP w0.089: v3(30.45,56.47) 30.52,56.39 PC108.1
  TOP w0.097: PQ101.1 80.88,94.07 81.17,94.36 PR107.1 80.54,95.84 78.58,95.84 78.33,95.58 v2(78.33,94.95)
  IN05 w0.091: v1(35.3,52.91) 34.92,52.53 34.64,52.53 33.88,53.29 33.88,55.32 34.39,55.83 37.92,55.83 39.69,54.05 40.86,54.05 41.11,53.81 45.56,53.81 49.64,49.74 52.42,49.74 55.34,46.82 55.34,45.42 57.25,43.51 57.25,41.23 57.88,40.59 58.39,40.59 60.29,42.5 68.17,42.5 69.95,40.72 75.53,40.72 v2(77.06,42.24)
  IN08 w0.089: v3(30.45,56.47) 33.24,56.47 33.62,56.09 33.62,53.41 34.5,52.53 34.92,52.53 v1(35.3,52.91)
  IN08 w0.091: v2(77.06,42.24) 77.06,50.37 77.44,50.75 77.44,65.36 74.61,68.19 74.61,78.22 75.12,78.73 76.26,78.73 76.71,79.18 76.71,81.89 77.18,82.36 77.18,89.21 76.04,90.35 76.04,91.14 76.42,91.52 76.42,93.3 78.07,94.95 v2(78.33,94.95)
  IN10 w0.089: v3(30.45,56.47) 30.19,56.21 30.19,48.23 30.1,48.13 30.1,46.69
  IN10 w0.091: 30.1,46.69 30.1,46.48 29.05,45.44 29.05,40.08 31.08,38.05 31.08,26.75 v2(31.97,25.86)
  BOTTOM w0.089: v1(35.3,52.91) 35.68,52.53 36.16,52.53 U5.F9
  BOTTOM w0.097: v2(31.97,25.86) 31.97,24.84 31.55,24.42 PD101.1 31.08,24.08 30.52,24.65 JDCIN1.5
ADIN_1: length 217.5
  TOP w0.203: v2(79.09,95.33) PR106.1
  TOP w0.381: v2(77.44,13.29) 77.57,13.16 PR203.1
  TOP w0.508: v2(94.58,3.64) 95.09,3.64 95.42,3.96 PD201.2
  IN05 w0.356: v2(79.47,3.25) 79.47,2.87 79.65,2.7 80.94,2.7 81.63,3.38 81.63,7.19 80.74,8.08 80.74,12.91 80.23,13.41 77.57,13.41 v2(77.44,13.29)
  IN08 w0.203: v2(79.09,95.33) 78.84,95.58 73.88,95.58 71.6,93.3 71.6,81.87 70.96,81.23 70.96,78.44 71.85,77.55 71.85,68.15 72.87,67.14 72.87,61.93 74.39,60.4 74.39,59.13 73.88,58.63 71.22,58.63 70.33,57.74 70.33,51.97 71.25,51.05 71.25,44.58 70.99,44.32 70.99,38.86 72.74,37.11 72.74,25.1 74.92,22.91 74.92,19.66 76.4,18.19 76.4,14.97 76.68,14.69 76.68,14.05 v2(77.44,13.29)
  IN10 w0.508: v2(26,29.04) 25.75,28.78 25.75,23.19 22.19,19.64 22.19,8.03 27.22,3 47.86,3 50.9,6.05 59.79,6.05 62.07,3.76 68.92,3.76 69.94,4.78 71.34,4.78 73.12,3 79.22,3 v2(79.47,3.25) 80.11,3.89 81.76,3.89 82.9,5.03 93.19,5.03 v2(94.58,3.64)
  vias: v1(27.15,32.46)
ALL_SYS_PWRGD: length 6.6
  BOTTOM w0.076: U5.B9 36.52,50.16 36.52,47.6 36.53,47.59
  BOTTOM w0.097: 36.53,47.59 36.53,47.34 v1(36.93,46.93) 37.28,46.59 37.28,45.22 C246.2 R260.1
ALL_SYS_PWRGD_PMIC: length 282
  TOP w0.097: v2(56.48,37.8) v1(53.56,37.8) 53.49,37.87 44.35,37.87 43.15,39.07 42.01,39.07 41.62,38.69 v2(41.28,38.69)
  IN03 w0.091: v2(58.13,44.15) 58.9,44.15 61.4,41.64 68.13,41.64 71.72,38.05 78.96,38.05 83.03,33.99 86.71,33.99 87.34,34.62 87.73,34.62 91.41,38.31 v2(92.68,38.31) ; v2(119.48,176.23) 119.48,180.42 117.57,182.32 117.57,186.77 116.94,187.4 116.94,191.43 117.24,191.73 117.24,193.55 118.33,194.64 118.33,195.28 v2(118.84,195.79)
  IN08 w0.091: v2(92.68,38.31) 92.68,43.71 92.13,44.26 92.13,59.72 94.46,62.06 96.87,62.06 97.5,62.69 97.5,63.58 103.35,69.42 103.35,89.49 106.78,92.92 106.78,94.44 107.41,95.08 107.41,95.84 121.63,110.06 138.91,110.06 142.97,114.13 142.97,132.29 140.11,135.14 140.11,138.83 138.14,140.8 138.14,147.78 137.13,148.8 137.13,150.07 v2(137.89,150.83)
  IN10 w0.091: v2(119.48,176.23) 127.1,168.61 127.1,158.58 128.49,157.18 133.32,157.18 133.95,156.54 133.95,151.08 134.59,150.45 136.62,150.45 137,150.83 v2(137.89,150.83) ; v2(56.48,37.8) 55.47,38.81 55.47,41.74 57.88,44.15 v2(58.13,44.15)
  BOTTOM w0.097: PR1242.2 119.22,195.41 v2(118.84,195.79) ; v2(58.13,44.15) 58.13,46.18 56.79,47.53 R843.1 ; R538.2 R56.1 41.8,38.99 41.5,38.69 v2(41.28,38.69)
ALL_SYS_PWRGD_PMIC_R: length 2.7
  BOTTOM w0.097: U61.4 42.83,40.45 R538.1 42.72,40.26 43.66,39.32 R300.2
ALW_B+:
  vias: v1(39.47,24.21) v2(45.05,26.24) v2(45.05,25.61) v2(45.69,26.24) v2(45.69,25.61) v2(46.32,26.24) v2(46.32,25.61) v2(47.85,27.89) v2(47.85,27.13) v2(48.61,27.89) v2(48.61,27.26) v2(49.37,27.89) v2(49.37,27.26)
AMON: length 80.4
  TOP w0.097: v3(77.95,9.39) 78.11,9.22 79.04,9.22 PC218.2 PR213.1
  IN05 w0.089: v1(40.99,51.51) 41.5,51.51
  IN05 w0.091: 41.5,51.51 42.12,51.51 42.93,52.32 43.56,52.32 43.81,52.07 43.81,51.69 44.5,51 44.93,51 47.12,48.81 47.87,48.81 48.72,47.96 51.66,47.96 53.18,46.44 53.18,44.78 55.17,42.8 55.17,38.03 57.94,35.26 76.3,35.26 v2(77.06,34.5)
  IN08 w0.091: v3(77.95,9.39) 77.85,9.49 77.85,12.48 78.16,12.79 78.16,15.09 77.95,15.29 77.55,15.29 76.8,16.03 76.8,18.95 76.04,19.71 76.04,31.96 77.06,32.97 v2(77.06,34.5)
  BOTTOM w0.097: v1(40.99,51.51) 40.27,51.51 39.93,51.86 39.51,51.86 38.95,52.41 U5.F13
AMP_GAIN/FSW: length 3.5
  TOP w0.097: R328.1 266.36,32.59 R325.2 266.45,32.67 266.95,32.67 267.51,33.23 267.51,33.35 267.61,33.45 U8.9
AMP_MONO: length 2.8
  TOP w0.254: U9.14 280.8,45.77 281.02,45.55 v2(281.02,44.91)
  BOTTOM w0.254: v2(281.02,44.91) 281.32,45.22 R335.2
AMP_PD_N_R: length 44.3
  TOP w0.097: R338.1 280.56,26.29 v2(280.26,25.99) 280,25.99 279.72,26.27 D19.2 278.86,26.27 278.75,26.17 R323.1 277.92,26.17 277.13,26.95 U8.27 ; v2(272.38,52.7) 273.38,53.7 276.35,53.7 277.08,54.44 R330.2
  IN10 w0.091: v2(280.26,25.99) 279.62,26.62 279.62,28.27 280.51,29.16 280.51,31.58 279.62,32.46 279.62,36.4 277.98,38.05 275.99,38.05 275.1,38.94 274.17,38.94 273.38,39.73 273.38,42.22 274.54,43.39 274.54,49.36 272.38,51.52 v2(272.38,52.7)
AMP_SPK_L+: length 6.3
  TOP w0.254: 277.34,35.95 U8.45
  TOP w0.508: 277.34,35.95 277.61,35.95 277.97,35.59 C354.1 278.99,35.59 279.62,36.22 v1(279.62,37.62) R68.2
AMP_SPK_L-: length 5.2
  TOP w0.254: 277.54,36.83 277.42,36.95 U8.47
  TOP w0.508: R69.2 278.35,38.43 278.89,37.9 278.89,36.71 278.63,36.45 C353.1 278.02,36.45 277.64,36.83 277.54,36.83
AMP_SPK_R+: length 2.5
  TOP w0.254: U8.4 267.14,35.95 267.13,35.97
  TOP w0.508: 267.13,35.97 266.62,36.48 C351.1
  vias: v1(265.12,37.52)
AMP_SPK_R-: length 1.2
  TOP w0.254: 267.31,36.95 U8.2
  TOP w0.508: 267.3,36.96 267.31,36.95
  vias: v1(266.8,37.52)
APDIN:
  vias: v1(25.88,16.97) v1(28.92,16.46) v1(30.19,19.51) v2(24.81,19.13) v2(24.86,17.86) v2(24.86,16.59) v2(24.86,15.32) v2(24.86,14.43) v2(25.7,19.13) v2(26.13,15.32) v2(26.13,14.43) v2(27.4,15.32) v2(27.4,14.43) v2(28.67,17.86) v2(28.67,15.32) v2(29.94,17.86) v2(29.94,15.32) v2(31.21,19.13) v2(31.21,18.11) v2(31.21,17.22) v2(31.21,16.34) v2(31.21,15.45) v2(32.1,19.13) v2(32.1,18.11) v2(32.1,17.22) v2(32.1,16.34) v2(32.1,15.45)
AR_HOLD_RST_N: length 49.2
  IN10 w0.089: 37.31,68.91 37.31,72.6 36.67,73.23 36.67,79.86 35.81,80.72 ; 37.43,58.63 37.43,56.85 36.67,56.09 33.88,56.09 31.97,54.18 31.97,50.63 33.12,49.48 38.32,49.48 38.71,49.1 38.71,48.85 v1(38.2,48.34)
  IN10 w0.091: 37.43,58.63 37.43,63.71 37.69,63.96 37.69,65.87 37.31,66.25 37.31,68.91 ; v2(34.39,82.15) 35.81,80.72
  BOTTOM w0.076: 38.02,49.8 38.02,50.16 U5.B12
  BOTTOM w0.097: 38.02,49.8 38.58,49.25 38.58,48.72 v1(38.2,48.34) ; v2(34.39,82.15) 35.35,81.18 R2103.1
ASGATE: length 2.5
  TOP w0.254: 83.79,12.78 84.04,12.78 84.59,12.24 PU201.30
  TOP w0.356: 83.79,12.78 83.28,13.29 PR202.2
AUD_AZACPU_SCLK: length 6.8
  TOP w0.097: R2291.1 190.8,150.37 v2(190.72,150.45) 190.6,150.57 v1(190.09,150.57)
  IN08 w0.091: v2(186.37,149.7) 186.99,150.32 190.34,150.32 190.47,150.45 v2(190.72,150.45)
  BOTTOM w0.097: v2(186.37,149.7) 186.37,149.77 U1.G27
AUD_AZACPU_SDO: length 1.4
  TOP w0.097: R2292.1 185.86,149.05 v2(185.72,148.91)
  BOTTOM w0.102: v2(185.72,148.91) 186.05,148.59 U1.G25
B+: length 41.6
  TOP w0.203: v2(80.61,18.49) 80.44,18.32 80.44,17.92 PR232.2
  TOP w0.254: PR201.2 49.39,30.69 48.86,30.17 v2(48.86,29.67)
  IN03 w0.254: v2(48.86,29.67) 48.74,29.54 48.74,29.16 48.86,29.04 49.88,29.04 50.39,29.54 56.1,29.54 57.88,27.77 69.21,27.77 75.69,21.29 78.45,21.29 80.49,19.26 80.49,18.62 v2(80.61,18.49)
  vias: v1(106.9,121.75) v1(111.86,110.57) v2(85.44,69.29) v2(85.57,69.93) v2(85.69,70.56) v2(85.82,71.2) v2(86.07,69.29) v2(86.2,69.93) v2(86.33,70.56) v2(86.46,71.2) v2(86.71,71.83) v2(89.38,32.46) v2(89.38,31.32) v2(90.01,32.46) v2(90.01,31.32) v2(91.79,32.46) v2(91.79,31.32) v2(92.42,32.46) v2(92.42,31.32) v2(93.95,35.64) v2(93.95,34.75) v2(94.58,32.46) v2(94.71,35.64) v2(94.71,34.75) v2(95.22,35.26) v2(138.02,188.04) v2(139.03,188.04) v2(139.41,186.77) v2(140.3,188.04) v2(140.68,186.77) v2(140.68,185.5) v2(141.57,188.04) v2(141.95,186.77) v2(141.95,185.5) v2(142.84,188.04) v2(143.22,186.77) v2(143.22,185.5) v2(143.99,188.04) v2(144.49,186.77) v2(144.49,185.5) v2(145,188.04) v2(145.51,186.77) v2(145.51,185.5) v2(145.51,42.88) v2(145.51,42.24) v2(146.15,42.88) v2(146.15,42.24) v2(146.91,42.88) v2(146.91,42.24) v2(147.54,42.88) v2(147.54,42.24) v2(150.59,205.18) v2(150.59,204.17) v2(150.59,203.15) v2(151.86,205.18) v2(151.86,204.17) v2(151.86,203.15) v2(153.13,205.18) v2(153.13,204.17) v2(153.13,203.15) v2(154.4,205.18) v2(154.4,204.17) v2(154.4,203.15) v2(155.67,205.18) v2(155.67,204.17) v2(155.67,203.15) v2(156.94,205.18) v2(156.94,204.17) v2(156.94,203.15) v2(158.21,205.18) v2(158.21,204.17) v2(158.21,203.15) v2(165.32,205.06) v2(165.96,205.06) v2(165.96,204.3) v2(165.96,203.53) v2(166.59,205.06) v2(166.59,204.3) v2(166.59,203.53) v2(167.23,205.06) v2(167.23,204.3) v2(167.23,203.53) v2(167.86,205.06) v2(167.86,204.3) v2(167.86,203.53) v2(168.5,205.06) v2(168.5,204.3) v2(168.5,203.53) v2(178.15,195.15) v2(178.78,195.15) v2(179.7,194.95) v2(217.65,84.79) v2(218.28,84.79) v2(218.92,84.79) v2(219.55,84.79) v2(255.37,44.91) v2(255.37,44.28) v2(256.13,44.91) v2(256.13,44.28) v2(256.89,44.91) v2(256.89,44.28)
