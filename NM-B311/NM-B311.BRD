# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N410243850: length 0.9
  BOTTOM w0.254: Q95.5 277.88,193.29 PR3556.1
N410259530: length 1.1
  BOTTOM w0.254: PU1606.28 243.92,201.74 PT1004.1
N410261670: length 1.1
  BOTTOM w0.254: PU1002.28 231.73,201.74 PT1003.1
N410319630: length 1.1
  BOTTOM w0.097: PU1602.28 184.81,190.06 PT1603.1
N410323190: length 1.1
  BOTTOM w0.097: PT1605.1 206.53,190.06 PU1603.28
N410350240: length 5.4
  BOTTOM w0.254: PR3579.1 211.6,105.31 210.66,106.25 v1(210.66,106.38) 210.66,108.54 211.26,109.13 PU1609.8

## Copper pours and planes (outline as drawn)
1.0VG_BS on BOTTOM (solid shape): 217.46,169.05 217.46,168.29 217.08,167.91 216.31,167.91 216.19,168.04 216.19,168.16 216.69,168.67 216.69,169.05 216.82,169.18 217.33,169.18
1.2V_B+ on TOP: 108,84.53 109.44,84.53 109.7,84.28 109.7,83.14 109.57,83.01 109.57,82.25 109.29,81.97 109.29,79.12 109.28,79.11 109.28,78.27 109.13,78.12 108.13,78.12 107.69,77.68 107.03,77.68 106.09,78.62 106.09,83.23 106.55,83.69 106.55,85.6 106.68,85.72 107.7,85.72 107.82,85.6 107.82,84.71
1.2V_B+ on BOTTOM: 107.06,85.72 110.24,85.72 110.36,85.6 110.36,81.28 109.09,80.01 109.09,79.5 108.97,79.38 107.7,79.38 106.93,80.14 106.93,80.52 107.06,80.64 108.71,80.64 109.35,81.28 109.35,83.44 109.22,83.57 108.33,83.57 108.08,83.31 107.06,83.31 106.93,83.44 106.93,85.6
1.05VP_LX on TOP: 260.95,48.85 261.08,48.72 262.22,48.72 262.22,49.74 262.6,50.12 262.63,50.12 263.14,50.63 265.27,50.63 265.27,51.64 265.4,51.77 266.16,51.77 266.41,52.02 266.41,52.78 266.29,52.91 265.27,52.91 264,54.18 260.19,54.18 260.06,54.05 260.06,52.38 259.23,51.54 259.23,51.31 259.33,51.21 259.99,51.21 260.95,50.24
1.8VP_LX on BOTTOM (solid shape): 122.21,133.04 122.21,132.03 122.47,131.77 122.47,131.26 122.34,131.14 121.96,131.14 121.83,131.01 121.83,130.38 122.72,129.49 125.25,129.49 125.53,129.21 125.53,127.13 125.2,126.8 120.65,126.8 120.31,127.14 120.31,128.09 119.93,128.47 118.53,128.47 118.4,128.6 118.4,129.49 118.66,129.74 120.05,129.74 120.31,129.99 120.31,131.65 120.43,131.77 120.94,131.77 121.2,132.03 121.2,133.04 121.32,133.17 122.09,133.17
2.5VP_BS on TOP (solid shape): 211.17,117.68 211.17,116.89 211.58,116.49 211.58,116.36 211.45,116.23 210.84,116.23 210.41,116.67 210.41,117.81 210.53,117.94 210.92,117.94
2.5VP_LX on TOP (solid shape): 213.48,114.58 213.48,113.49 214.22,112.75 214.22,110.44 214.04,110.26 210.97,110.26 210.53,110.7 210.53,112.98 210.74,113.19 212.08,113.19 212.21,113.31 212.21,114.58 212.34,114.71 213.35,114.71
+0.6V_VTT on TOP: 120.24,73.36 120.36,73.49 120.36,84.79 119.98,85.17 119.35,85.17 119.22,85.04 119.22,84.79 119.09,84.66 118.84,84.66 118.71,84.79 118.71,85.17 118.46,85.17 118.46,84.66 118.33,84.53 117.95,84.53 117.95,85.04 117.82,85.17 117.32,85.17 116.94,84.79 116.94,70.31 117.19,70.06 118.21,70.06 118.46,70.31 118.46,70.69 118.71,70.95 119.22,70.95 120.24,71.96
+0.6V_VTT on BOTTOM: 197.96,76.03 203.68,76.03 204.31,75.39 204.31,68.66 204.95,68.02 206.47,68.02 206.85,68.41 206.85,84.53 206.09,85.3 204.44,85.3 204.44,78.82 203.93,78.31 199.23,78.31 198.98,78.57 198.98,80.22 198.85,80.34 198.6,80.34 198.6,77.3 197.83,76.53 197.83,76.15
+0.6V_VTT on IN03: 203.61,68.47 205.65,68.47 206.6,69.42 206.6,72.22 204.06,74.76 126.46,74.76 126.33,74.63 116.81,74.63 116.05,73.87 116.05,71.07 116.81,70.31 118.97,70.31 119.73,71.07 124.68,71.07 126.59,72.98 199.1,72.98
+0.6VSP on TOP: 110.71,91.77 111.6,91.77 111.82,91.56 111.82,90.72 111.53,90.43 111.53,90.12 112.47,90.12 112.62,90.28 112.62,90.88 112.87,91.14 114.4,91.14 117.19,88.34 117.19,85.68 117.57,85.3 120.24,85.3 120.49,85.55 120.49,90.5 119.73,91.27 117.44,91.27 117.19,91.52 117.19,93.55 116.55,94.19 111.4,94.19 110.76,93.55 110.76,93.48 110.71,93.42
+1.0V_VCCST on BOTTOM: 196.56,160.35 196.06,160.86 193.9,160.86 192.63,162.13 188.31,162.13 185.77,164.67 182.59,164.67 182.47,164.54 182.47,163.78 182.59,163.66 185.39,163.66 187.8,161.24 191.61,161.24 193.77,159.08 196.44,159.08 196.56,159.21
+1.0V_VCCST on IN03: 188.94,158.19 190.6,159.85 196.44,159.85 196.56,159.72 196.56,159.21 195.93,158.58 190.6,158.58 189.2,157.18 187.88,157.18 187.37,156.67 187.37,156.09 187.32,156.04 187.32,153.58 186.6,152.85 185.4,152.85 185.39,152.86 185.13,152.86 184.75,153.24 184.75,155.91 187.04,158.19
+1.0V_VCCST_VCCSFR on TOP: 197.71,157.94 197.71,155.4 198.09,155.02 199.31,155.02 199.64,155.35 199.64,157.64 199.49,157.79 198.62,157.79 198.34,158.07 197.83,158.07
+1.0V_VCCST_VCCSFR on BOTTOM: 197.33,156.92 196.82,157.43 196.82,161.12 196.31,161.62 193.64,161.62 192.75,162.51 188.69,162.51 186.28,164.93 184.75,164.93 184.5,165.18 184.5,166.07 184.63,166.2 186.66,166.2 189.33,163.53 197.33,163.53 198.72,162.13 198.72,157.31 198.34,156.92
+1.0V_VCCSTG on TOP: 201.52,157.69 202.41,157.69 202.42,157.7 203.05,157.7 203.17,157.81 203.17,160.35 203.04,160.48 197.58,160.48 197.23,160.13 197.23,158.37 197.4,158.19 201.01,158.19
+1.0V_VCCSTG on IN05: 194.79,160.35 197.58,160.35 198.09,159.85 198.09,155.78 192.63,150.32 187.42,150.32 185.39,152.35 185.39,153.11 187.17,154.89 189.33,154.89
+1.0VALW on TOP: 206.47,157.69 206.47,156.16 206.6,156.04 207.36,156.04 207.74,155.65 208.12,155.65 208.25,155.78 208.25,157.56 208.12,157.69 207.61,157.69 207.49,157.81 206.6,157.81
+1.0VALW on TOP: 264.26,82.88 264.89,82.25 264.89,73.36 265.53,72.72 265.53,67.77 266.16,67.14 266.16,65.56 265.53,64.93 265.53,63.96 265.45,63.88 264.61,63.88 264.36,64.14 260.37,64.14 259.68,64.82 259.68,67.39 259.05,68.02 257.65,68.02 257.21,68.47 257.21,74.69 255.75,76.15 255.75,76.66 255.24,77.17 251.05,77.17 250.54,77.68 250.54,79.45 250.16,79.84 233.14,79.84 232.89,79.58 222.6,79.58 222.35,79.84 222.35,82.76 222.73,83.14 240.13,83.14 240.38,82.88 ; 2 cut-outs
+1.0VALW on TOP: 201.01,153.5 201.14,153.37 202.28,153.37 202.79,152.86 203.42,152.86 203.55,152.99 203.55,154.26 203.3,154.51 201.26,154.51 201.01,154.26
+1.0VALW on IN10: 202.66,153.37 203.23,152.8 203.23,142.76 210.41,135.59 210.41,132.16 213.2,129.37 213.2,116.79 212.69,116.28 212.69,109.17 212.82,109.05 212.82,97.62 216.5,93.93 216.5,86.57 217.01,86.06 219.55,86.06 220.44,85.17 220.44,81.49 222.35,79.58 224.63,79.58 225.01,79.96 225.01,81.74 223.93,82.82 223.93,86.76 222.73,87.96 220.63,87.96 220,88.6 219.27,88.6 219.07,88.8 219.07,89.45 219.62,90 219.62,96.79 219.17,97.23 219.17,104.73 219.68,105.24 219.68,111.59 218.28,112.98 218.28,117.17 219.68,118.57 219.68,121.75 217.01,124.41 217.01,127.33 216.88,127.46 216.88,129.75 218.03,130.89 218.03,140.54 212.19,146.38 212.19,156.92 211.42,157.69 203.55,157.69 202.66,156.8
+1.0VALW_PCH on TOP: 255.37,76.28 255.37,75.52 256.51,74.37 256.51,61.55 256.38,61.42 255.62,61.42 255.37,61.17 255.37,60.28 255.11,60.02 252.06,60.02 251.94,60.15 251.94,61.17 252.7,61.93 252.7,64.72 252.44,64.98 252.44,67.64 252.19,67.9 250.92,67.9 250.92,69.42 251.3,69.8 251.3,70.44 252.06,71.2 252.06,74.53 251.84,74.76 251.4,74.76 251.2,74.55 251.2,74.12 251.07,73.99 250.54,73.99 250.41,74.12 250.41,76.66 250.67,76.91 254.73,76.91
+1.0VALW_PCH on BOTTOM: 253.13,65.69 255.01,65.69 255.11,65.79 255.11,66.75 254.86,67.01 253.51,67.01 253.03,66.53 253.03,65.79
+1.0VG on BOTTOM (solid shape): 218.54,158.83 218.54,155.15 218.28,154.89 217.52,154.89 217.32,155.09 217.3,155.07 213.38,155.07 212.69,154.38 211.8,154.38 211.55,154.64 211.55,157.94 211.8,158.19 212.82,158.19 213.58,158.96 216.38,158.96 216.63,159.21 218.15,159.21
+1.0VP on TOP: 260.7,59.03 260.7,63.76 260.9,63.96 264.13,63.96 264.64,63.45 264.97,63.45 265.35,63.07 265.35,57.81 264.51,56.98 264.51,56.59 264.13,56.21 260.47,56.21 259.2,57.48 259.2,58.14 259.39,58.33 260,58.33
+1.2V_CPU_VDDQ on TOP: outline of 93 points within 156,118.38 187.8,139.14 ; 3 cut-outs
+1.2V_UG on TOP: 112.69,88.65 112.69,88.37 112.86,88.21 113.77,88.21 113.81,88.24 113.81,88.7 113.66,88.85 113.13,88.85 112.87,89.11 112.74,89.11 112.62,88.98 112.62,88.73
+1.2V_VDDQ on TOP: outline of 96 points within 119.34,53.67 195.62,131.98 ; 2 cut-outs
+1.2V_VDDQ on TOP: 158.26,78.11 173.55,78.11 173.6,78.06 173.6,76.41 172.82,75.62 170.63,75.62 170.3,75.95 159.2,75.95 158.95,76.2 158.95,76.71 158.24,77.42 158.24,78.08
+1.2V_VDDQ on BOTTOM: 159.99,78.18 174.52,78.18 174.97,77.73 174.97,75.77 174.82,75.62 160.06,75.62 159.73,75.95 159.73,77.93
+1.2V_VDDQ on BOTTOM: 133.95,62.44 133.93,62.46 121.99,62.46 119.98,64.47 118.66,64.47 116.55,66.58 116.55,70.95 116.81,71.2 124.43,71.2 125.19,71.96 125.19,77.93 124.43,78.69 124.43,87.61 127.6,90.78 131.97,90.78 132,90.76 135.1,90.76 135.22,90.63 172.31,90.63 173.2,91.52 174.59,91.52 175.61,90.5 194.41,90.5 194.53,90.38 194.53,89.87 193.9,89.23 173.45,89.23 172.94,88.73 159.73,88.73 159.23,89.23 145,89.23 144.37,88.6 143.99,88.6 143.86,88.73 143.86,89.11 143.99,89.23 131.79,89.23 127.88,85.32 127.88,82.38 130.91,79.35 130.91,73.99 128.09,71.17 128.09,67.16 130.58,64.67 133.9,64.67 134.21,64.98 194.66,64.98 195.68,63.96 195.68,62.56 195.55,62.44
+1.2V_VDDQ on VCC07: 119.07,63.07 118.08,64.07 118.08,105.77 118.69,106.38 118.82,106.38 119.2,106.76 192.14,106.76 195.8,103.1 195.8,63.18 195.7,63.07
+1.2V_VDDQ on IN08: 116.05,95.71 116.05,89.49 114.97,88.41 114.97,76.47 113.76,75.26 113.76,66.88 120.36,60.28 157.96,60.28 158.72,61.04 158.72,67.77 158.97,68.02 158.97,71.58 158.59,71.96 158.59,75.39 156.69,77.3 156.69,94.19 153.26,97.62 117.95,97.62
+1.2V_VDDQ on IN08: 179.29,93.68 179.29,60.79 180.05,60.02 188.18,60.02 188.69,60.53 188.69,93.68 188.31,94.06 179.67,94.06
+1.2VDDQ on TOP (solid shape): 114.03,90.8 114.03,90.75 114.04,90.73 114.04,90.38 113.41,89.74 112.67,89.74 112.59,89.82 112.59,90.1 112.77,90.28 112.77,90.96 112.82,91.01 113.81,91.01
+1.2VDDQ on BOTTOM (solid shape): 122.02,91.77 122.02,87.2 122.4,86.82 123.79,86.82 124.09,86.53 124.09,78.57 124.43,78.23 124.43,72.6 123.79,71.96 116.68,71.96 116.43,72.22 116.43,79.96 116.81,80.34 119.09,80.34 119.79,81.04 119.79,86.63 120.36,87.2 120.36,90.5 119.86,91.01 114.78,91.01 114.65,90.88 114.65,90.12 114.52,90 112.74,90 112.62,90.12 112.62,92.03 113,92.41 121.38,92.41
+1.8V on TOP: 87.85,48.72 87.73,48.85 84.68,48.85 84.42,48.59 84.42,45.16 84.68,44.91 87.6,44.91 87.85,45.16
+1.8V on TOP: 86.07,56.98 86.46,56.98 86.46,56.47 87.6,56.47 87.85,56.72 87.85,58.63 87.6,58.88 85.19,58.88 85.06,58.75 85.06,56.59 85.31,56.34 85.82,56.34 85.95,56.47 85.95,56.85
+1.8V on IN08: 83.03,58.88 83.41,59.26 89,59.26 89.38,58.88 89.38,48.34 88.23,47.2 83.53,47.2 83.03,47.7
+1.8V_AON on TOP: 219.3,123.02 221.84,123.02 222.09,122.76 222.09,122.13 221.2,121.24 219.3,121.24 219.17,121.36 219.17,122.89
+1.8V_AON on TOP: 242.28,122.25 244.06,122.25 244.06,120.73 243.55,120.22 243.55,119.08 243.81,118.82 243.81,118.44 243.68,118.32 243.17,118.32 242.79,118.7 242.79,120.22 243.17,120.6 243.17,121.49 242.92,121.75 242.28,121.75 242.16,121.87 242.16,122.13
+1.8V_AON on BOTTOM: 220.44,122.89 223.23,122.89 223.36,122.76 223.36,121.87 222.98,121.49 220.44,121.49 220.19,121.75 220.19,122.63
+1.8V_AON on IN03: 231.68,120.41 231.74,120.35 236.7,120.35 237.46,119.59 241.01,119.59 241.4,119.97 241.4,120.6 241.32,120.68 241.32,121.77 241.7,122.15 243.02,122.15 244.06,121.11 244.06,119.08 241.52,116.54 240.25,116.54 240.13,116.41 236.06,116.41 234.41,118.06 230.54,118.06 229.33,119.27 227.36,119.27 225.14,121.49 221.84,121.49 221.58,121.24 220.06,121.24 219.93,121.36 219.93,122.51 220.82,123.4 229.2,123.4 231.68,120.92
+1.8V_MAIN on TOP: 220.69,123.27 220.44,123.52 220.44,124.16 220.95,124.67 220.95,126.19 221.08,126.32 223.11,126.32 223.23,126.19 223.23,124.54 223.11,124.41 223.11,123.78 222.6,123.27
+1.8V_MAIN on TOP: 242.92,135.46 243.5,135.46 243.68,135.64 243.94,135.64 244.09,135.49 244.09,135 244.29,134.8 244.29,134.34 244.16,134.22 243.71,134.22 243.43,133.94 243.43,132.82 243.61,132.64 243.61,131.73 243.94,131.4 243.94,130.64 243.43,130.13 242.41,130.13 242.16,130.38 242.16,130.51 241.78,130.89 241.78,131.27 241.52,131.52 241.52,132.41 241.9,132.79 241.9,133.43 241.65,133.68 241.65,134.19 242.28,134.83 242.54,134.83 242.79,135.08 242.79,135.33
+1.8V_MAIN on BOTTOM: 241.9,134.95 243.3,134.95 243.43,134.83 243.43,130.25 243.3,130.13 242.41,130.13 242.16,130.38 242.16,130.51 241.78,130.89 241.52,130.89 241.27,131.14 241.27,134.32
+1.8V_MAIN on BOTTOM: 219.68,122.51 216.88,122.51 216.5,122.13 213.2,122.13 213.07,122 211.93,122 211.68,122.25 211.68,124.79 211.93,125.05 212.06,125.05 212.44,125.43 212.44,127.59 211.8,128.22 211.8,132.79 211.93,132.92 216.88,132.92 217.01,132.79 217.01,131.27 216.63,130.89 216.63,124.67 216.88,124.41 222.6,124.41 222.73,124.29 222.73,123.4 222.47,123.14 220.31,123.14
+1.8V_MAIN on IN03: 243.05,130.13 242.92,130 242.92,129.62 243.17,129.37 243.68,129.37 244.19,128.86 244.19,126.7 243.68,126.19 236.7,126.19 234.92,127.97 234.92,128.6 234.03,129.49 228.57,129.49 227.81,128.73 223.62,128.73 222.47,129.87 216,129.87 214.85,131.02 212.69,131.02 212.44,131.27 212.44,136.6 213.46,137.62 243.55,137.62 244.06,137.11 244.06,130.25 243.94,130.13 ; 1 cut-out
+1.8V_SW on TOP: 206.09,124.03 210.66,124.03 210.79,123.9 210.79,122 210.53,121.75 206.09,121.75 205.84,122 205.84,123.78
+1.8V_SW on TOP: 129.76,124.41 129.64,124.54 129.64,127.97 130.02,128.35 134.08,128.35 134.33,128.1 134.33,124.67 134.08,124.41
+1.8V_SW on BOTTOM: 137.26,115.52 131.92,120.86 131.92,126.83 132.68,127.59 138.27,127.59 144.49,121.36 187.29,121.36 195.68,129.75 202.91,129.75 203.55,129.11 205.2,129.11 205.71,128.6 207.49,128.6 208.38,127.71 208.38,123.14 208.12,122.89 207.23,122.89 206.98,122.63 202.41,122.63 200.88,124.16 197.45,124.16 195.42,122.13 195.42,119.97 190.98,115.52
+1.8VP on TOP (solid shape): 129.25,128.1 129.25,124.67 129,124.41 123.29,124.41 123.16,124.29 123.16,121.36 123.03,121.24 119.86,121.24 119.6,121.49 119.6,127.71 120.36,128.48 128.87,128.48
+1.8VP on BOTTOM (solid shape): 128.24,124.16 128.24,120.22 128.14,120.12 124.53,120.12 124.5,120.09 118.09,120.09 117.7,120.48 117.7,123.39 119.09,124.79 127.61,124.79
+1.8VP on TOP: 84.8,44.15 87.6,44.15 87.85,43.89 87.85,41.86 87.73,41.74 84.68,41.74 84.55,41.86 84.55,43.89
+1.8VP on IN10: 90.33,62.44 90.33,65.55 93.19,68.41 93.19,72.72 94.01,73.55 94.01,78.76 98.46,83.2 98.46,92.47 99.16,93.17 99.16,97.49 100.81,99.14 110.97,99.14 119.98,108.16 119.98,118.57 121.25,119.84 121.25,124.16 120.87,124.54 117.06,124.54 114.78,122.25 114.78,109.3 109.95,104.47 99.16,104.47 95.22,100.54 95.22,94.57 93.44,92.79 93.44,85.3 90.39,82.25 90.39,73.68 89.44,72.72 89.44,69.49 86.58,66.63 86.58,59.39 85.95,58.75 85.95,44.78 85.31,44.15 85.31,43.13 85.5,42.94 90.46,42.94 91.28,43.77 91.28,61.48
+1.55VG on TOP (solid shape): 286.35,103.2 287.4,103.2 287.66,102.94 287.66,100.03 287.65,99.95 287.66,99.87 287.66,99.14 287.65,99.06 287.66,98.98 287.66,98.42 287.13,97.88 287.13,91.53 286.99,91.39 279.88,91.39 279.75,91.52 279.75,99.01 280.64,99.9 280.64,101.68 280.89,101.93 282.1,101.93 282.1,101.86 282.8,101.86 282.8,101.93 283.3,101.93 283.3,101.86 284,101.86 284,101.93 284.32,101.93 285.72,103.33 286.23,103.33
+1.55VG on BOTTOM: 278.73,106.38 278.73,92.41 279.24,91.9 284.7,91.9 284.96,92.15 284.96,96.6 285.46,97.11 285.46,106.25 285.21,106.51 278.86,106.51
+1.55VSG on TOP: outline of 243 points within 229.71,82.12 305.15,181.56 ; 4 cut-outs
+1.55VSG on BOTTOM: 301.85,150.7 303.88,150.7 304.01,150.57 304.01,149.56 303.88,149.43 301.85,149.43 301.72,149.56 301.72,150.57
+1.55VSG on BOTTOM: 262.73,175.09 262.6,175.21 262.6,176.61 262.73,176.74 265.02,176.74 265.91,175.85 266.54,175.85 266.67,175.72 267.3,175.72 267.43,175.59 267.43,175.21 267.3,175.09
+1.55VSG on BOTTOM: 301.72,115.78 303.63,115.78 303.75,115.65 303.75,112.73 303.37,112.35 301.85,112.35 301.47,112.73 301.47,115.52
+1.55VSG on BOTTOM: 250.81,119.67 250.81,120.67 250.91,120.77 262.83,120.77 262.96,120.64 262.96,119.54 262.76,119.34 261.58,119.34 261.16,119.77 260.96,119.77 260.53,119.34 259.53,119.34 259.09,119.79 258.88,119.79 258.41,119.32 257.41,119.32 256.99,119.74 256.76,119.74 256.28,119.27 255.36,119.27 254.91,119.72 254.63,119.72 254.16,119.24 253.34,119.24 252.83,119.74 252.56,119.74 252.09,119.27 251.21,119.27
+1.55VSG on BOTTOM: 239.24,178.39 239.36,178.26 240.13,178.26 240.25,178.13 240.25,177.63 240.13,177.5 238.47,177.5 238.22,177.75 238.22,180.04 238.35,180.17 239.11,180.17 239.24,180.04
+1.55VSG on BOTTOM: 301.72,157.43 303.37,157.43 303.5,157.31 303.5,156.16 303.37,156.04 301.85,156.04 301.59,156.29 301.59,157.31
+1.55VSG on BOTTOM: 301.47,119.08 303.24,119.08 303.37,118.95 303.37,118.44 302.48,117.55 300.96,117.55 300.83,117.68 300.83,117.94 301.34,118.44 301.34,118.95
+1.55VSG on BOTTOM: 279.37,181.31 281.4,181.31 281.53,181.18 281.53,178.77 281.4,178.64 280.26,178.64 280.13,178.51 279.5,178.51 279.5,179.28 279.24,179.53 279.24,181.18
+1.55VSG on BOTTOM: 246.93,142.49 246.93,142.64 247.01,142.72 247.96,142.72 248.31,142.37 248.31,141.52 248.18,141.39 248.04,141.39
+1.55VSG on BOTTOM: 249.14,176.86 251.43,176.86 251.56,176.74 251.56,176.48 250.92,175.85 250.03,175.85 249.52,175.34 248.76,175.34 248.63,175.47 248.63,176.36
+1.55VSG on BOTTOM: 273.53,104.98 273.27,104.73 271.62,104.73 271.49,104.85 271.49,110.82 271.75,111.08 273.15,111.08 273.53,110.7
+1.55VSG on BOTTOM: 301.85,140.16 303.37,140.16 303.5,140.03 303.5,138.89 303.24,138.64 301.72,138.64 301.59,138.76 301.59,139.91
+1.55VSG on BOTTOM: 267.56,177.63 267.56,176.99 267.43,176.86 265.4,176.86 265.27,176.99 265.27,178.01 265.4,178.13 267.05,178.13
+1.55VSG on BOTTOM: 262.79,141.34 249.93,141.34 249.28,141.99 248.93,141.99 248.74,142.19 248.74,142.42 249.16,142.84 249.93,142.84 250.44,142.34 250.71,142.34 251.13,142.77 252.13,142.77 252.58,142.32 252.79,142.32 253.21,142.74 254.23,142.74 254.63,142.34 254.93,142.34 255.39,142.79 256.31,142.79 256.74,142.37 257.04,142.37 257.48,142.82 258.36,142.82 258.86,142.32 259.06,142.32 259.53,142.79 260.48,142.79 260.93,142.34 261.23,142.34 261.69,142.79 262.63,142.79 262.9,142.53 262.88,142.52 262.88,141.44
+1.55VSG on BOTTOM: 273.4,89.36 276.57,89.36 277.21,88.73 277.21,84.92 276.83,84.53 275.69,84.53 275.3,84.92 275.3,85.42 274.92,85.8 274.03,85.8 273.78,86.06 273.78,86.31 273.91,86.44 275.3,86.44 275.43,86.57 275.43,87.71 275.3,87.84 273.65,87.84 272.51,88.98 272.51,89.36 272.89,89.74 273.02,89.74
+1.55VSG on BOTTOM: 264.89,84.79 266.03,84.79 266.16,84.66 266.16,83.14 265.53,82.5 264.64,82.5 264.26,82.88 264.26,84.15
+1.55VSG on BOTTOM: 257.78,176.86 257.52,176.61 255.49,176.61 255.24,176.86 255.24,178.13 255.87,178.77 255.87,180.17 256,180.29 257.52,180.29 257.78,180.04
+1.55VSG on BOTTOM: 264.04,125.32 264.04,140.12 264.14,140.22 265.23,140.22 265.49,139.97 265.49,138.97 265.04,138.52 265.04,138.24 265.46,137.82 265.46,136.84 265.04,136.42 265.04,136.09 265.46,135.67 265.46,134.74 265.01,134.29 265.01,134.02 265.49,133.54 265.49,132.67 265.01,132.19 265.01,131.94 265.49,131.47 265.49,130.57 265.06,130.14 265.06,129.77 265.49,129.34 265.49,128.47 265.04,128.02 265.04,127.72 265.49,127.27 265.49,126.37 265.01,125.89 265.01,125.62 265.46,125.17 265.46,124.27 265.01,123.82 265.01,123.52 265.49,123.04 265.49,122.17 265.11,121.79 264.09,121.79 263.98,121.89 263.98,125.27
+1.55VSG on BOTTOM: 301.72,145.49 301.47,145.75 301.47,146.76 301.59,146.89 303.24,146.89 303.37,146.76 303.37,145.75 303.12,145.49
+1.55VSG on BOTTOM: 301.85,134.45 303.24,134.45 303.37,134.32 303.37,131.02 303.24,130.89 301.72,130.89 301.59,131.02 301.59,134.19
+1.55VSG on BOTTOM: 272.76,178.26 272.64,178.13 270.22,178.13 269.72,178.64 269.72,179.78 269.97,180.04 272.51,180.04 272.76,179.78
+1.55VSG on IN03: 255.49,178.39 267.43,178.39 268.19,177.63 268.19,171.02 267.68,170.51 266.67,170.51 265.53,169.37 265.53,168.86 264.89,168.23 264.89,165.05 264.26,164.42 259.56,164.42 254.86,169.12 253.59,169.12 253.46,168.99 251.68,168.99 251.56,169.12 251.56,170.77 253.97,173.18 253.97,173.43 254.22,173.69 254.22,174.45 253.46,175.21 251.81,175.21 251.68,175.34 251.68,176.23 252.06,176.61 254.73,176.61 254.98,176.86 254.98,177.88
+1.55VSG on IN03: 274.67,182.71 281.02,182.71 281.65,182.07 281.65,172.8 281.02,172.16 277.97,172.16 277.21,171.4 276.7,171.4 275.05,173.05 275.05,176.99 274.54,177.5 274.54,182.58
+1.55VSG on IN03: 248,142.7 264.89,142.7 265.65,141.94 265.65,120.35 264.51,119.21 250.92,119.21 250.79,119.33 250.79,120.6 250.92,120.73 262.48,120.73 264,122.25 264,123.6 264.46,124.06 264.46,124.31 264,124.77 264,140.03 262.86,141.18 248,141.18 247.75,141.43 247.75,142.45
+1.55VSG on IN03: 233.27,178.9 244.7,178.9 245.08,178.51 245.08,172.55 244.57,172.04 242.54,172.04 241.78,171.28 241.52,171.28 241.4,171.4 241.4,171.91 240,173.31 240,176.36 237.97,178.39 234.16,178.39 233.27,177.5 233.27,175.85 233.01,175.59 233.01,173.05 232.76,172.8 231.62,172.8 231.49,172.93 231.49,177.12
+1.55VSG on IN05: 274.8,171.66 277.72,171.66 279.5,169.88 279.5,167.21 279.11,166.83 278.99,166.83 278.48,167.34 278.35,167.34 277.59,166.58 276.57,166.58 276.19,166.96 274.92,166.96 274.54,167.34 274.54,171.4
+1.55VSG on IN05: 253.33,177.88 272.13,177.88 275.94,181.69 279.88,181.69 280.13,181.44 280.13,177.63 279.62,177.12 277.34,177.12 276.96,176.74 276.96,175.21 277.59,174.58 279.37,174.58 279.62,174.32 279.62,173.18 279.37,172.93 275.43,172.93 274.8,173.56 274.8,174.07 272.64,176.23 271.24,176.23 270.48,175.47 270.22,175.47 269.72,175.97 268.95,175.97 268.32,175.34 268.32,173.82 268.83,173.31 268.83,172.67 268.95,172.55 270.48,172.55 271.62,171.4 271.62,168.48 271.37,168.23 270.35,168.23 268.7,166.58 266.54,166.58 264.76,164.8 262.1,164.8 261.97,164.93 261.97,166.32 261.08,167.21 258.54,167.21 258.29,167.47 258.29,171.28 259.56,172.55 260.45,172.55 261.84,173.94 261.84,174.96 261.46,175.34 261.21,175.34 261.08,175.47 261.08,176.1 260.95,176.23 259.05,176.23 258.03,175.21 257.14,175.21 254.86,172.93 250.67,172.93 250.54,173.05 250.54,174.83 250.79,175.09 252.7,175.09 253.08,175.47 253.08,175.59 252.44,176.23 252.44,176.99
+1.55VSG on IN05: 232.76,177.37 241.78,177.37 242.03,177.12 242.03,175.09 242.41,174.7 244.57,174.7 244.7,174.58 244.7,173.18 244.44,172.93 240.51,172.93 239.87,173.56 239.87,174.7 238.35,176.23 235.93,176.23 235.55,175.85 235.55,175.47 235.43,175.34 235.17,175.34 235.05,175.47 235.05,175.72 234.54,176.23 234.03,176.23 233.14,175.34 233.14,172.55 234.03,171.66 235.43,171.66 235.55,171.53 235.55,168.99 234.92,168.35 234.92,167.21 235.43,166.7 236.32,166.7 236.44,166.58 236.44,165.56 236.19,165.31 235.17,165.31 234.92,165.56 234.92,166.2 233.9,167.21 233.39,167.21 233.14,166.96 233.14,166.58 232.89,166.32 232.89,165.43 233.01,165.31 233.01,165.05 232.76,164.8 232.12,164.8 232,164.93 232,176.61
+1.55VSG on IN05: 248,142.7 264.89,142.7 265.65,141.94 265.65,120.35 264.51,119.21 250.92,119.21 250.79,119.33 250.79,120.6 250.92,120.73 255.11,120.73 255.68,121.3 263.05,121.3 263.75,122 263.75,139.53 262.1,141.18 248,141.18 247.75,141.43 247.75,142.45
+1.55VSG on IN05: 241.14,170.39 243.05,170.39 243.43,170.01 243.43,168.48 243.17,168.23 241.01,168.23 240.76,168.48 240.76,170.01
+1.55VSG on VCC07: 258.16,80.34 258.16,82.35 257.5,83.01 243.28,83.01 242.28,84 242.28,107.52 268.42,107.52 271.47,110.57 274.01,110.57 277.97,114.53 277.97,145.64 284.83,152.5 284.83,160.1 306.06,160.1 306.29,159.87 306.29,108.54 290.06,108.54 286.99,105.47 286.99,80.34
+1.55VSG on IN08: 262.48,81.99 260.7,83.77 243.55,83.77 242.54,84.79 242.54,98.63 243.17,99.27 274.67,99.27 276.32,100.92 276.32,131.02 276.7,131.4 282.92,131.4 284.7,133.18 284.7,158.45 286.1,159.85 302.61,159.85 303.5,158.96 303.5,110.7 301.21,108.41 299.94,108.41 299.56,108.79 297.53,108.79 297.28,108.54 294.86,108.54 294.48,108.92 286.73,108.92 285.85,108.03 285.85,105.28 285.57,104.47 285.85,103.67 285.85,85.68 282.16,81.99
+1.55VSG on IN10: 269.97,177.88 270.73,178.64 274.54,178.64 276.45,176.74 277.08,176.74 277.46,176.36 278.99,176.36 279.24,176.1 279.24,175.21 279.11,175.09 276.45,175.09 276.32,174.96 276.32,172.93 277.84,171.4 277.84,169.88 277.72,169.75 277.46,169.75 277.34,169.88 273.27,169.88 271.88,168.48 271.88,164.42 271.24,163.78 264.64,163.78 264.38,164.04 264.38,169.5 263.75,170.13 262.1,170.13 260.95,171.28 260.95,177.37 261.46,177.88
+1.55VSG on IN10: 231.36,177.88 233.78,177.88 233.9,177.75 238.09,177.75 238.6,178.26 240.89,178.26 241.14,178.01 241.14,176.86 241.4,176.61 241.9,176.61 242.03,176.48 242.03,175.72 241.52,175.21 241.14,175.21 241.01,175.09 241.01,173.18 241.65,172.55 242.16,172.55 242.67,172.04 242.67,169.88 242.54,169.75 242.16,169.75 241.9,170.01 239.24,170.01 238.22,168.99 238.22,163.78 237.33,162.89 231.49,162.89 230.73,163.66 230.73,177.24
+1.55VSG on IN10: 248,142.7 264.89,142.7 265.65,141.94 265.65,120.35 264.51,119.21 251.17,119.21 250.79,119.59 250.79,120.98 251.05,121.24 258.54,121.24 258.6,121.3 263.05,121.3 263.75,122 263.75,139.53 262.1,141.18 248,141.18 247.75,141.43 247.75,142.45
+1.55VSG on IN10: 250.92,178.01 254.86,178.01 255.24,177.63 255.24,176.48 254.86,176.1 254.22,176.1 253.84,175.72 253.84,173.82 254.35,173.31 254.35,173.18 253.97,172.8 253.84,172.8 253.33,172.29 253.33,171.53 253.21,171.4 252.95,171.4 252.57,171.78 250.29,171.78 250.03,172.04 250.03,177.12
+2.5V_MEM on TOP: 197.07,65.1 196.95,65.23 196.95,67.26 197.71,68.02 200.76,68.02 201.52,68.79 201.52,76.28 200.12,77.68 197.58,77.68 196.82,78.44 196.82,80.22 196.95,80.34 201.77,80.34 203.04,81.61 203.04,84.66 201.52,86.19 201.52,89.55 201.55,89.58 201.55,91.93 204.18,94.57 204.18,96.22 204.44,96.47 205.33,96.47 205.45,96.6 205.45,101.93 205.84,102.31 206.47,102.31 206.85,102.7 206.85,105.87 206.72,106 206.34,106 206.22,106.12 206.22,107.01 206.47,107.27 214.22,107.27 214.6,106.89 214.6,103.08 214.47,102.95 211.55,102.95 211.3,102.7 211.3,94.06 211.17,93.93 210.15,93.93 205.84,89.61 205.84,84.66 206.85,83.65 206.85,68.23 207.08,68 207.08,64.32 206.85,64.09 201.26,64.09 200.25,65.1
+2.5V_MEM on BOTTOM: 198.47,88.98 198.85,89.36 203.17,89.36 203.63,88.9 203.63,86.13 203.17,85.68 199.1,85.68 198.47,86.31
+2.5V_MEM on BOTTOM: 198.72,73.36 198.72,75.64 198.85,75.77 203.3,75.77 203.93,75.14 203.93,73.36 203.68,73.1 198.98,73.1
+3V on TOP: 197.45,64.98 196.31,64.98 195.93,64.6 195.93,63.83 196.31,63.45 199.61,63.45 199.87,63.71 199.87,64.7 199.69,64.88 198.85,64.88 198.32,64.34 198.09,64.34
+3V on TOP: 72.74,84.79 72.74,83.9 72.61,83.77 72.61,83.39 72.87,83.14 74.01,83.14 74.14,83.26 74.14,83.77 73.88,84.03 73.88,84.66 73.76,84.79
+3V on TOP: 63.09,9.22 63.85,9.22 63.98,9.35 63.98,11.13 63.72,11.38 63.21,11.38 62.96,11.13 62.96,9.35
+3V on TOP: 86.96,82.38 86.96,80.85 87.22,80.6 87.22,76.66 86.96,76.41 86.96,76.03 87.09,75.9 87.73,75.9 87.98,76.15 87.98,82.25 87.73,82.5 87.09,82.5
+3V on TOP: 277.08,76.28 277.08,77.68 277.21,77.8 278.73,77.8 278.86,77.68 278.86,76.28 278.73,76.15 277.21,76.15
+3V on TOP: 16.1,148.42 16.1,149.43 16.22,149.56 17.24,149.56 17.49,149.3 17.49,147.53 17.24,147.27 16.22,147.27 15.97,147.53 15.97,148.29
+3V on TOP: 58.01,72.6 60.55,72.6 60.8,72.34 60.8,70.06 60.67,69.93 58.01,69.93 57.63,70.31 57.63,72.22
+3V on TOP: 196.18,90.61 196.18,92.41 196.69,92.92 199.79,92.92 200.3,93.42 200.3,96.96 200.88,97.54 200.88,104.73 201.96,105.81 206.47,105.81 206.6,105.68 206.6,102.82 206.34,102.57 203.93,102.57 203.68,102.31 203.68,94.77 201.07,92.17 201.07,86.05 202.71,84.41 202.71,82.17 201.52,80.98 198.47,80.98 197.96,81.49 197.96,83.9 198.6,84.53 198.6,89.23 197.56,90.28 196.51,90.28
+3V on BOTTOM: 63.47,42.62 64.23,42.62 64.48,42.37 67.91,42.37 68.17,42.12 68.17,36.4 67.66,35.89 64.99,35.89 64.87,36.02 64.87,36.78 65.5,37.42 65.5,39.07 65.25,39.32 64.23,39.32 64.1,39.45 64.1,40.21 63.85,40.47 63.47,40.47 63.34,40.59 63.34,42.5
+3V on BOTTOM: 68.55,79.45 68.42,79.58 68.42,80.85 68.55,80.98 70.2,80.98 70.33,80.85 70.33,79.84 69.95,79.45
+3V on BOTTOM: 286.99,77.17 286.99,78.69 286.86,78.82 285.59,78.82 284.45,79.96 282.92,79.96 282.67,79.71 282.67,76.91 282.8,76.79 284.32,76.79 284.7,77.17
+3V on BOTTOM: 36.16,89.87 38.45,89.87 38.58,89.74 38.58,86.82 37.94,86.19 35.91,86.19 35.53,86.57 35.53,89.23
+3V on BOTTOM: 233.42,46.69 233.83,47.1 235.73,47.1 236.24,47.6 237.69,47.6 237.76,47.53 237.76,46.89 236.75,45.88 236.75,45.09 236.57,44.91 233.75,44.91 233.14,45.52 231.79,45.52 231.46,45.85 231.46,46.59 231.57,46.69
+3V on BOTTOM: 300.96,37.87 300.61,37.87 300.23,38.25 300.23,39.78 300.48,40.03 301.21,40.03 301.97,40.79 305.53,40.79 305.91,40.41 305.91,37.24 305.53,36.86 301.97,36.86
+3V on BOTTOM: 195.93,195.79 195.93,194.77 195.8,194.64 192.25,194.64 192.12,194.77 192.12,195.53 192.37,195.79
+3V on BOTTOM: 196.06,90.12 196.06,93.32 193.44,95.94 193.44,104.7 200.45,111.71 203.04,111.71 203.17,111.59 203.17,110.82 202.8,110.46 202.8,108.4 203.93,107.27 206.34,107.27 206.6,107.01 206.6,102.95 206.34,102.7 198.98,102.7 197.2,100.92 197.2,95.2 197.58,94.82 197.58,90.38 197.07,89.87 196.31,89.87
+3V on BOTTOM: 221.48,65.51 221.48,64.37 221.63,64.21 222.19,64.21 222.32,64.09 222.32,63.63 222.19,63.5 220.52,63.5 220.36,63.35 220.36,62.97 221.05,62.28 221.05,61.52 220.9,61.37 220.57,61.37 219.58,62.36 219.58,63.94 219.83,64.19 220.77,64.19 221.04,64.46 221.04,65.95 221.46,66.37 222.4,66.37 222.4,65.92 222.35,65.87 221.84,65.87
+3V on BOTTOM: 92.93,65.1 93.19,64.85 93.19,62.06 92.93,61.8 90.01,61.8 89.63,62.18 89.63,64.98 89.76,65.1
+3V on BOTTOM: 199.49,64.85 196.18,64.85 195.93,64.6 195.93,64.21 196.06,64.09 196.69,64.09 196.82,63.96 196.95,63.96 197.07,63.83 197.07,60.79 197.2,60.66 197.96,60.66 198.34,61.04 199.64,61.04 199.82,61.22 199.82,64.52
+3V on IN03: 16.61,149.84 17.39,149.84 17.55,149.69 17.55,147.88 17.29,147.63 14.6,147.63 14.45,147.78 14.45,148.54 14.57,148.67 16.2,148.67 16.4,148.87 16.4,149.63
+3V on IN03: 185.58,197.12 184.5,196.04 171.55,196.04 171.42,195.91 171.42,194.52 183.08,194.52 183.09,194.53 185.4,194.53 186.42,195.55 190.09,195.55 191,194.64 193.14,194.64 193.39,194.9 193.39,196.8 192.37,197.82 186.34,197.82 185.64,197.12
+3V on IN03: 34.77,88.98 37.69,88.98 38.2,88.47 38.2,86.57 37.81,86.19 34.89,86.19 34.26,86.82 34.26,88.47
+3V on IN05: 290.93,69.55 290.93,61.29 298.7,53.52 298.7,39.62 300.74,37.59 308.99,37.59 309.37,37.97 309.37,46.86 309.12,47.12 305.94,47.12 305.4,47.66 305.4,53.93 298.04,61.29 298.04,69.04 296.26,70.82 292.2,70.82
+3V on VCC07: outline of 99 points within 13.81,17.12 298.93,198.83
+3V on IN08: 62.71,9.99 62.83,9.86 63.98,9.86 64.1,9.99 64.1,13.67 66.01,15.57 66.01,20.4 68.55,22.94 68.55,36.66 68.29,36.91 64.23,36.91 64.1,36.78 64.1,24.59 62.71,23.19
+3V on IN08: 200.88,60.46 198.77,58.35 198.77,52.45 198.53,52.21 195.47,52.21 194.86,52.83 194.86,57.32 194.58,57.61 192.91,57.61 192.07,56.76 189.54,56.76 188.94,57.36 188.94,90.63 191.74,93.42 195.55,93.42 195.56,93.41 199.93,93.41 200.88,92.46 ; 6 cut-outs
+3V_CAMERA on BOTTOM: 154.27,200.23 154.27,199.22 155.04,198.45 155.04,196.55 155.4,196.19 159.45,196.19 160.37,197.1 160.37,197.69 159.99,198.07 158.72,198.07 158.33,198.46 156.42,198.46 155.8,199.09 155.8,200.23 155.67,200.36 154.4,200.36
+3V_DP_CON on TOP: 12.92,147.27 12.41,147.78 12.41,150.7 12.16,150.96 7.72,150.96 6.83,151.84 6.83,162.64 9.87,165.69 14.19,165.69 14.45,165.94 15.08,165.94 15.21,165.81 15.21,164.82 15.77,164.27 15.77,163.2 15.72,163.15 15.72,162.64 15.08,162.64 14.57,162.13 12.16,162.13 12.05,162.25 12.05,163.03 12.03,163.05 12.03,163.4 12.21,163.58 14.17,163.58 14.29,163.71 14.29,164.57 14.19,164.67 10.38,164.67 8.73,163.02 8.73,153.11 9.62,152.23 14.7,152.23 15.21,151.72 15.21,150.57 14.32,149.69 14.32,147.4 14.19,147.27
+3V_DPA_REP on TOP: 69.95,88.34 69.95,86.82 69.69,86.57 66.9,86.57 66.39,87.07 66.39,93.3 66.14,93.55 65.37,93.55 65.12,93.3 65.12,86.06 66.01,85.17 70.83,85.17 70.96,85.04 70.96,84.15 71.22,83.9 72.23,83.9 72.36,84.03 72.36,86.57 71.34,87.58 71.34,93.42 71.22,93.55 69.95,93.55 69.82,93.42 69.82,88.47
+3V_DPE_REP on TOP: 71.98,76.28 76.42,76.28 76.55,76.15 76.55,75.77 76.8,75.52 78.07,75.52 78.2,75.39 78.2,74.37 78.07,74.25 77.82,74.25 77.31,74.76 75.91,74.76 75.41,74.25 74.77,74.25 74.26,74.76 73.25,74.76 73.12,74.63 73.12,74.37 72.99,74.25 71.98,74.25 71.6,73.87 71.6,70.06 71.85,69.8 72.99,69.8 73.5,69.29 74.77,69.29 75.28,69.8 75.66,69.8 76.17,69.29 76.93,69.29 77.44,69.8 77.95,69.8 78.07,69.68 78.07,68.15 77.31,67.39 71.85,67.39 69.69,69.55 69.69,75.64 68.93,76.41 68.93,79.07 69.31,79.45 70.45,79.45 70.58,79.33 70.58,77.68
+3V_DPE_REP on BOTTOM: 68.8,78.57 69.56,78.57 69.82,78.82 69.82,79.07 70.2,79.45 70.83,79.45 71.09,79.2 71.09,77.04 70.83,76.79 69.06,76.79 68.8,77.04
+3V_DPF_REP on TOP: 59.66,69.17 59.66,67.64 59.91,67.39 61.06,67.39 61.31,67.14 61.31,55.58 61.94,54.94 64.99,54.94 65.37,54.56 66.52,54.56 67.02,55.07 67.53,55.07 68.04,54.56 68.8,54.56 68.93,54.69 68.93,60.53 68.8,60.66 67.79,60.66 67.66,60.53 67.66,60.28 67.41,60.02 65.88,60.02 65.37,59.52 64.36,59.52 63.47,60.4 62.45,60.4 62.2,60.66 62.2,63.83 62.45,64.09 63.34,64.09 63.6,64.34 63.6,64.72 63.72,64.85 66.01,64.85 66.14,64.72 66.14,64.21 66.26,64.09 66.52,64.09 66.64,64.21 66.64,64.72 66.77,64.85 67.66,64.85 67.79,64.72 67.79,64.21 67.91,64.09 69.44,64.09 69.56,63.96 69.56,63.33 69.69,63.2 70.83,63.2 70.96,63.33 70.96,68.02 70.2,68.79 68.42,68.79 68.17,68.53 62.58,68.53 62.07,69.04 62.07,69.29 61.82,69.55 61.31,69.55 60.93,69.17
+3V_EDP on BOTTOM: 196.18,194.72 197,194.72 197.71,194.01 198.6,194.01 198.72,194.14 198.72,194.64 198.57,194.8 198.57,195.76 198.39,195.94 196.26,195.94 196.16,195.84 196.16,194.75
+3V_EDP_CONN on BOTTOM: 196.92,199.98 196.92,197.97 196.77,197.82 196.77,196.35 196.87,196.24 198.5,196.24 198.93,196.68 199.36,196.68 199.36,196.9 198.77,197.49 198.77,199.93 198.7,200 196.95,200
+3V_GPU on TOP: 274.92,73.1 273.65,73.1 273.4,73.36 273.4,75.26 273.53,75.39 274.92,75.39 275.05,75.26 275.05,73.23
+3V_HDMI_REP on TOP: 83.53,82.63 83.53,88.22 84.04,88.73 86.46,88.73 86.71,88.47 86.71,81.36 86.33,80.98 84.17,80.98 84.04,80.85 79.22,80.85 78.58,81.49 78.58,88.6 79.09,89.11 80.23,89.11 80.23,82.38 80.36,82.25 83.15,82.25
+3V_REP on TOP: 84.17,80.72 85.19,80.72 85.31,80.6 85.31,79.96 85.06,79.71 85.06,77.42 85.31,77.17 85.31,75.9 84.17,75.9 84.04,76.03 84.04,76.66 83.92,76.79 83.15,76.79 82.77,77.17 82.77,79.33
+3V_SATA on IN08: 280.26,64.72 280.26,59.39 280.89,58.75 285.85,58.75 286.1,59.01 286.1,59.77 284.83,61.04 284.83,68.79 285.46,69.42 285.46,70.31 284.96,70.82 280.51,70.82 280.13,70.44 280.13,64.85
+3V_SSD1 on BOTTOM: 93.31,40.72 93.19,40.85 88.87,40.85 87.34,42.37 87.34,55.07 89.76,57.48 89.76,61.17 90.14,61.55 93.06,61.55 93.69,60.91 97.88,60.91 99.2,59.59 99.2,59.26 97.65,59.26 97.65,59.07 99.2,59.07 99.2,58.34 99.12,58.26 96.88,58.26 96.23,57.61 94.46,57.61 94.2,57.36 94.2,56.85 90.8,53.45 90.8,47.76 92.75,45.8 94.63,45.8 94.81,45.98 95.7,45.98 96.01,45.67 99.28,45.67 99.41,45.55 99.41,40.85 99.28,40.72
+3V_SSD2 on BOTTOM: 94.58,83.39 95.98,83.39 96.23,83.65 97.25,83.65 97.63,84.03 99.41,84.03 99.54,83.9 99.54,80.6 99.28,80.34 96.62,80.34 96.49,80.47 94.71,80.47 94.46,80.72 94.46,83.26
+3V_SSD2 on BOTTOM: 99.16,70.06 99.16,65.23 93.19,65.23 93.06,65.36 90.39,65.36 90.06,65.69 90.06,66.5 93.62,70.06
+3V_SSD2 on IN08: 94.96,75.64 94.96,71.07 92.3,68.41 92.3,66.12 92.93,65.48 96.87,65.48 100.81,69.42 100.81,82.44 99.98,83.26 95.85,83.26 95.47,82.88 95.47,76.15
+3V_THERM on BOTTOM: 203.68,111.33 203.68,113.74 203.8,113.87 204.44,113.87 204.57,113.74 204.57,111.2 204.44,111.08 203.93,111.08
+3V_TP on BOTTOM: 278.73,23.45 278.48,23.19 276.57,23.19 276.45,23.32 276.45,28.02 276.7,28.27 278.48,28.27 278.73,28.02
+3V_WLAN on BOTTOM: 263.11,69.8 262.6,69.29 258.92,69.29 258.29,69.93 258.29,76.28 258.54,76.53 260.32,76.53 260.57,76.28 262.22,76.28 264,74.5 264,72.98 263.11,72.09
+3V_WLAN on BOTTOM: 278.86,70.26 279.75,70.26 279.88,70.39 279.88,71.91 279.9,71.94 279.9,74.76 281.17,76.03 284.07,76.03 284.96,76.91 286.99,76.91 286.99,72.85 285.66,71.52 283.88,71.52 283.05,70.69 283.05,70.33 283.05,70.29 283.05,70.01 283.03,70.01 283.03,69.4 282.67,69.04 282.42,69.04 282.37,68.99 278.78,68.99 278.73,69.04 278.73,70.14
+3V_WLAN on IN03: 263.62,72.09 259.43,72.09 259.05,72.47 259.05,77.17 260.57,78.69 282.04,78.69 284.32,76.41 284.32,72.72 284.07,72.47 279.75,72.47 278.1,74.12 265.65,74.12
+3VALW on TOP: 61.82,26.62 57.37,26.62 57.12,26.37 57.12,25.61 56.61,25.1 56.61,23.57 56.71,23.47 61.69,23.47 62.07,23.85 62.07,26.37
+3VALW on TOP: 201.14,152.86 201.14,152.48 200.88,152.23 200.88,150.7 201.01,150.57 202.03,150.57 202.28,150.83 202.28,152.61 202.03,152.86
+3VALW on TOP: 220.89,48.15 220.57,48.47 220.11,48.47 220.09,48.49 213.81,48.49 212.57,49.74 210.03,49.74 209.39,50.37 209.39,53.17 207.92,54.64 191.41,54.64 189.55,56.49 189.55,60.68 187.93,62.31 159.73,62.31 150.06,52.63 119.04,52.63 118,53.67 112.39,53.67 111.35,52.63 108.66,52.63 107.79,51.77 107.79,46.43 108.05,46.18 109.95,46.18 112.24,48.47 112.26,48.47 112.77,48.97 151.68,48.97 160.12,57.41 180.44,57.41 187.85,49.99 203.55,49.99 204.18,49.36 204.18,46.69 204.95,45.93 211.42,45.93 211.93,45.42 211.93,42.62 213.33,41.23 213.33,39.4 214.57,38.15 256.46,38.15 256.89,38.59 256.89,39.81 256.56,40.14 221.51,40.14 220.06,41.58 220.06,44.33 220.89,45.15
+3VALW on TOP: 30.22,49.89 30.22,47.93 30.47,47.68 31.09,47.68 31.34,47.42 31.93,47.42 32.09,47.57 32.09,48.45 31.9,48.64 31.03,48.64 30.88,48.8 30.88,49.94 30.86,49.97 30.3,49.97
+3VALW on TOP: 62.45,41.1 62.45,38.81 61.69,38.05 50.9,38.05 50.39,38.56 44.55,38.56 42.31,40.8 42.31,42.32 50.87,50.88 67.91,50.88 68.42,50.37 68.42,48.97 68.68,48.72 69.31,48.72 69.44,48.59 69.44,46.05 67.91,46.05 67.28,45.42 63.85,45.42 62.83,44.4 62.83,43.64 63.09,43.39 68.93,43.39 70.64,41.68 77.51,41.68 77.82,41.99 77.82,44.53 79.22,44.53 80.61,45.93 80.61,46.31 80.49,46.43 80.49,46.82 80.61,46.94 82.52,46.94 82.77,46.69 82.77,41.74 80.23,39.2 69.95,39.2 67.79,41.35 62.71,41.35
+3VALW on TOP: 62.83,9.1 61.31,9.1 60.93,9.48 60.93,9.86 61.56,10.49 62.33,10.49 62.83,9.99
+3VALW on BOTTOM: 61.44,43.39 62.83,43.39 62.96,43.26 62.96,24.46 62.45,23.96 57.12,23.96 56.74,24.34 56.74,36.78 59.53,39.58 59.53,41.86 59.79,42.12 61.31,42.12 61.44,42.24
+3VALW on BOTTOM: 219.35,48.11 219.25,48.01 219.25,45.49 219.35,45.39 220.01,45.39 220.72,44.68 221.89,44.68 221.95,44.75 221.95,46.71 221.93,46.74 221.38,46.74 220.92,47.2 220.92,48.01 220.82,48.11
+3VALW on BOTTOM: 281.65,29.42 281.53,29.54 281.53,30.43 282.92,30.43 283.05,30.31 283.05,29.54 282.92,29.42
+3VALW on BOTTOM: 45.82,72.47 50.13,72.47 50.26,72.34 50.26,71.07 50.01,70.82 48.36,70.82 47.85,70.31 47.85,69.68 47.72,69.55 44.42,69.55 44.04,69.17 44.04,68.66 41.37,68.66 41.37,70.44 42.89,71.96 42.89,72.47 43.02,72.6 45.69,72.6
+3VALW on IN03: 80.74,51.01 91.03,51.01 92.04,52.02 100.55,52.02 102.2,53.67 105.76,53.67 107.28,55.2 111.86,55.2 112.36,54.69 112.36,49.74 111.86,49.23 109.57,49.23 107.54,47.2 106.14,47.2 103.22,44.28 92.55,44.28 92.04,44.78 83.41,44.78 82.9,44.28 80.61,44.28 79.85,45.04 79.85,50.12
+3VALW on IN03: 202.48,76.33 201.43,75.27 126.45,75.27 126.13,75.59 126.13,77.6 128.39,79.86 177.12,79.86 177.75,80.48 200.64,80.48 200.69,80.53 209.65,80.53 210.85,79.33 218.03,79.33 218.15,79.2 218.15,76.53 217.95,76.33
+3VALW on IN03: 96.62,25.1 97.25,24.46 97.25,19.22 94.31,16.28 92.18,16.28 90.52,14.62 87.79,14.62 86.2,13.03 63.09,13.03 61.69,14.43 61.69,18.37 58.64,21.42 58.13,21.42 56.99,22.56 56.99,26.37 57.12,26.5 69.06,26.5 77.82,17.73 82.93,17.73 90.3,25.1
+3VALW on IN10: 261.79,49.74 264.54,49.74 265.09,49.18 265.09,44.2 264.33,43.44 260.75,43.44 256.25,38.94 252.01,38.94 251.56,39.4 251.56,40.26 251.89,40.59 254.48,40.59 254.71,40.82 254.71,41.38 255.01,41.68 256.84,41.68 258.29,43.13 258.29,46.23
+3VALW on IN10: 47.72,72.6 50.77,72.6 51.02,72.34 51.02,70.95 50.9,70.82 50.9,67.52 50.26,66.88 50.26,55.32 50.13,55.2 50.13,51.01 52.55,48.59 52.55,38.31 62.71,28.15 62.71,24.34 61.56,23.19 57.88,23.19 55.98,25.1 47.34,25.1 38.2,34.24 38.2,38.18 36.54,39.83 36.54,42.37 34.26,44.66 32.86,44.66 31.21,46.31 31.21,48.34 31.34,48.47 36.54,48.47 37.5,47.51 43.59,47.51 45.94,49.86 45.94,69.55 47.47,71.07 47.47,72.34
+3VALW on IN10: 95.22,23.57 91.66,23.57 90.65,24.59 90.65,28.88 93.52,31.75 98.32,31.75 99.03,32.46 99.03,35 106.01,41.99 106.01,60.66 104.31,62.36 104.31,73.82 109.19,78.69 128.87,78.69 129.38,78.18 129.38,73.1 128.11,71.83 126.59,71.83 124.56,69.8 118.21,69.8 117.7,69.29 117.7,64.21 117.44,63.96 116.55,63.96 114.4,66.12 108.43,66.12 107.79,65.48 107.79,64.7 111.37,61.12 111.37,55.17 113.63,52.91 113.63,43.01 106.01,35.39 106.01,30.43 105.25,29.67 105.25,27.51 104.74,27 98.65,27
+3VALW on IN10: 210.15,118.32 210.41,118.06 210.41,107.9 211.04,107.27 211.04,95.84 212.69,94.19 212.69,93.17 214.6,91.27 214.6,89.61 215.11,89.11 215.11,85.42 215.49,85.04 215.49,79.2 216,78.69 217.77,78.69 218.03,78.95 218.03,83.52 216.63,84.92 216.63,85.8 216.25,86.19 216.25,93.55 212.44,97.36 212.44,108.92 212.31,109.05 212.31,116.41 212.82,116.92 212.82,129.24 209.58,132.48 209.58,134.89 202.79,141.68 202.79,152.99 202.41,153.37 202.41,157.31 203.17,158.07 220.06,158.07 221.33,159.34 221.33,169.12 220.82,169.62 215.74,169.62 215.23,169.12 215.23,168.35 215.61,167.97 218.15,167.97 219.17,166.96 219.17,160.99 218.66,160.48 211.17,160.48 210.41,161.24 206.09,161.24 205.58,160.73 204.06,160.73 200.88,157.56 200.88,139.78 206.6,134.06 206.6,131.14 210.15,127.59
+3VALW_AUD on BOTTOM: 283.18,31.45 284.19,31.45 284.32,31.58 284.32,32.85 284.19,32.97 281.78,32.97 281.4,32.59 281.4,31.07 281.53,30.94 282.67,30.94
+3VALW_LC on TOP: 67.79,5.16 68.04,5.41 68.04,6.05 67.91,6.18 67.66,6.18 67.41,6.43 67.41,7.45 67.28,7.57 66.26,7.57 66.14,7.45 66.14,7.06 65.75,6.68 64.99,6.68 64.36,7.32 64.36,8.21 63.72,8.84 62.07,8.84 61.94,8.72 60.55,8.72 59.28,7.45 52.04,7.45 51.91,7.32 51.91,6.81 52.04,6.68 60.04,6.68 60.93,7.57 62.45,7.57 63.47,6.56 63.47,6.05 63.6,5.92 64.23,5.92 64.48,5.67 64.48,4.52 64.74,4.27 67.79,4.27
+3VALW_LC on IN08: 77.31,9.99 77.31,4.02 76.42,3.13 67.15,3.13 64.99,5.29 64.99,9.35 65.63,9.99 68.42,9.99 68.8,10.37 68.8,12.14 68.93,12.27 69.95,12.27 70.07,12.14 70.07,9.73 70.58,9.22 72.49,9.22 73.24,9.98 73.24,14.06 73.49,14.31 75.1,14.31 75.36,14.05 75.36,11.05 75.53,10.87 75.53,10.62 75.91,10.24 77.06,10.24 ; 1 cut-out
+3VALW_PCH on TOP: 254.07,58.12 253.71,57.76 253.71,57.48 254.48,56.72 254.48,50.75 253.08,49.36 253.08,48.47 253.23,48.31 254.71,48.31 255.59,49.2 255.59,57.76 255.24,58.12
+3VALW_PCH on TOP: 221.46,54.44 222.5,54.44 222.6,54.33 222.6,51.11 222.5,51.01 222.14,51.01 222.12,51.03 221.43,51.03 221.33,51.13 221.33,51.64 222.09,52.4 222.09,53.62 221.96,53.75 221.41,53.75 221.33,53.83 221.33,54.31
+3VALW_PCH on TOP: 222.47,58.37 221.71,59.13 221.46,59.13 221.33,59.01 221.33,58.5 221.61,58.22 221.79,58.22 222.02,57.99 222.02,56.54 222.14,56.42 222.52,56.42 222.6,56.49 222.6,57.1 223.23,57.74 225.93,57.74 226,57.66 226.61,57.66 226.94,57.33 226.94,56.57 227.04,56.47 227.55,56.47 227.68,56.59 227.68,58.25 227.55,58.37
+3VALW_PCH on BOTTOM: 222.09,44.53 222.09,46.74 222.05,46.78 221.65,46.78 221.33,47.1 221.33,54.31 221.46,54.44 222.35,54.44 222.47,54.31 222.47,53.65 222.82,53.31 222.82,48 223.11,47.7 225.39,47.7 226.05,47.04 226.99,47.04 227.15,46.89 227.68,46.89 227.81,46.76 227.81,46.18 228.06,45.93 228.44,45.93 228.7,45.67 229.58,45.67 230.85,44.4 237.46,44.4 237.84,44.02 239.85,44.02 240.1,44.28 240.1,45.39 240.24,45.53 240.24,46.14 240.35,46.26 240.58,46.26 240.89,46.56 240.89,47.02 240.68,47.22 240.68,47.43 240.76,47.5 242.11,47.5 242.21,47.4 242.21,43.64 242.46,43.39 250.77,43.39 252.09,44.71 252.09,48.37 252.11,48.39 252.11,48.97 252.06,48.97 252.06,49.86 252.19,49.99 254.73,49.99 254.86,49.86 254.86,48.54 254.83,48.52 254.86,48.52 254.86,45.57 251.56,42.27 228.67,42.27 228.57,42.37 228.31,42.37 227.3,43.39 223.23,43.39
+3VALW_PCH on BOTTOM: 253.08,59.9 253.08,57.64 253.69,57.03 256.05,57.03 256.13,57.1 256.13,60.32 255.87,60.57 253.5,60.57 253.19,60.87 253.19,62.55 253.05,62.69 253.05,63.73 252.98,63.81 252.39,63.81 252.37,63.78 252.37,62.56 252.57,62.36 252.57,60.4
+3VALWP on TOP (solid shape): 63.72,22.3 63.72,11.89 63.47,11.64 61.72,11.64 60.94,12.42 60.94,13.61 60.45,14.1 57.12,14.1 56.74,14.48 56.74,22.56 56.86,22.69 63.34,22.69
+3VD_AMP on TOP: 278.02,28.53 280.54,28.53 280.66,28.4 280.66,28.12 280.56,28.02 280,28.02 279.88,27.89 279.88,27.51 279.75,27.38 278.86,27.38 278.61,27.13 278.61,26.88 277.84,26.88 277.34,27.38 277.34,28.02 277.06,28.3 275.53,28.3 275.51,28.32 275.51,29.06 275.53,29.09 277.46,29.09
+3VD_AUD on BOTTOM: 283.05,34.62 283.43,34.24 284.19,34.24 284.32,34.12 284.32,33.23 284.19,33.1 280.77,33.1 280.26,33.61 280.26,33.99 280.51,34.24 282.16,34.24 282.29,34.37 282.29,35.26 282.42,35.39 282.92,35.39 283.05,35.26
+3VLP on TOP: 78.07,22.43 78.07,21.42 77.95,21.29 76.68,21.29 76.55,21.42 76.55,23.11 76.89,23.44 77.93,23.44 78.07,23.31 78.07,22.44
+3VLP_EC on TOP: 34.13,51.64 34,51.64 33.75,51.9 32.99,51.9 32.73,51.64 31.08,51.64 30.96,51.77 30.32,51.77 30.26,51.71 28.54,51.71 28.51,51.74 27.93,51.74 27.92,51.73 27.13,51.73 26.51,51.11 26.51,50.32 25.75,49.56 25.75,49.13 24.47,47.84 24.47,44.91 25.11,44.26 25.11,42.24 25.88,41.48 29.43,41.48 29.81,41.1 29.81,40.08 30.32,39.58 39.97,39.58 40.23,39.83 40.23,44.28 45.43,49.48 45.43,50.37 45.31,50.5 45.27,50.5 45.03,50.74 42.97,50.74 42.48,50.25 42.48,48.56 38.32,44.4 38.32,41.99 37.81,41.48 36.8,41.48 36.29,41.99 36.29,44.4 35.53,45.16 30.32,45.16 29.94,45.55 25.93,45.55 25.83,45.65 25.83,45.98 25.93,46.08 26.51,46.08 27.02,46.59 27.2,46.59 27.6,46.99 27.6,49.36 27.78,49.53 28.24,49.53 28.34,49.64 28.34,50.5 28.47,50.63 30.07,50.63 30.19,50.5 30.19,50.24 32.73,50.24 33.62,51.13 34.13,51.13
+3VLP_EC on IN05: 33.43,55.39 32.42,55.39 32.29,55.26 32.29,50.94 32.54,50.69 33.94,50.69 34.32,51.07 36.48,51.07 36.86,50.69 37.5,50.69 37.62,50.82 37.62,51.32 37.37,51.58 37.37,52.72 37.75,53.1 37.75,55.01 37.5,55.26 36.61,55.26 36.48,55.13 36.48,52.47 35.91,51.9 33.24,51.9 32.86,52.28 32.86,54.31 33.18,54.63 33.43,54.63 33.56,54.75 33.56,55.26
+5V on TOP: 17.11,17.61 18.26,17.61 18.38,17.48 18.38,15.45 18,15.07 12.67,15.07 12.41,15.32 12.41,17.86 12.67,18.11 16.61,18.11
+5V on TOP: 294.25,39.7 294,39.96 294,40.11 293.24,40.87 289.94,40.87 289.91,40.85 289.02,40.85 288.89,40.97 288.89,41.68 289.07,41.86 296.89,41.86 297.15,41.61 297.15,39.96 296.89,39.7
+5V on BOTTOM: 206.98,122.13 208.12,122.13 208.25,122 208.25,121.11 207.99,120.86 206.98,120.86 206.72,121.11 206.72,121.87
+5V on BOTTOM: 98.52,92.15 99.73,92.15 99.82,92.25 100.97,92.25 101.19,92.03 101.19,91.33 100.81,90.95 98.45,90.95 98.39,91.01 98.39,92.03
+5V on BOTTOM: 290.85,41.86 290.65,41.66 290.65,40.82 290.98,40.48 291.37,40.48 291.74,40.85 293.29,40.85 293.8,40.34 293.8,40.31 294,40.1 294,39.42 294.11,39.32 296.54,39.32 296.8,39.58 296.8,41.48 296.42,41.86
+5V on BOTTOM: 71.22,97.23 71.22,98 71.34,98.12 72.61,98.12 72.74,98 72.74,97.23 72.61,97.11 71.34,97.11
+5V on BOTTOM: 290.42,78.82 290.42,77.8 290.29,77.68 289.27,77.68 289.15,77.8 288.26,77.8 286.99,79.07 286.35,79.07 285.97,79.45 285.97,80.6 286.29,80.92 288.32,80.92
+5V on BOTTOM: 195.8,194.01 195.8,193.37 196.06,193.12 196.06,192.61 195.93,192.48 195.42,192.48 194.79,193.12 194.79,193.88 194.91,194.01
+5V on IN03: 97,71.71 81.38,71.71 80.74,72.34 73.37,72.34 72.99,72.72 67.41,72.72 67.15,72.98 67.15,74.12 67.53,74.5 69.69,74.5 74.14,78.95 92.81,78.95 94.58,77.17 94.58,75.77 94.96,75.39 97,75.39 97.38,75.01 97.38,72.09
+5V on IN05: 305.78,54.82 305.78,47.78 306.07,47.5 309.09,47.5 309.34,47.75 309.34,59.13 306.93,61.55 306.93,71.58 301.59,76.91 294.99,76.91 291.56,80.34 286.1,80.34 285.21,79.45 285.21,75.77 289.4,71.58 297.15,71.58 301.59,67.14 301.59,59.01
+5V on VCC07: 18.02,1.02 18.02,13.71 18,13.72 17.43,14.93 16.22,15.5 16.21,15.52 10.38,15.52 10.38,19.41 13.81,22.83 13.81,25.61 29.84,25.61 38.78,16.64 68.81,16.62 97.86,45.67 221.18,45.67 222.43,46.92 224.3,46.92 226.18,45.04 234.39,45.04 235.02,45.67 250.39,45.67 253.18,48.47 268.93,48.47 270.48,50.01 270.48,55.98 271.49,57 271.49,70.56 288.79,70.56 292.85,66.5 305.86,66.5 306.04,66.32 306.04,60.68 309.09,57.63 309.09,51.92 309.47,51.54 309.47,47.3 309.09,46.92 309.09,37.78 306.06,34.75 299.24,34.75 299.19,34.8 299.14,34.8 298.07,35.87 298.07,36.55 297.33,37.29 294.46,37.29 294,37.75 294,40.11 293.27,40.85 291.13,40.85 289.91,39.63 289.91,37.08 263.2,37.08 262.56,37.71 261.72,38 261.71,38.02 124.09,38.02 124.08,38 122.87,37.43 122.3,36.22 122.28,36.21 122.28,28.08 115.66,28.08 115.65,28.06 114.44,27.49 113.86,26.28 113.85,26.27 113.85,1.02 97.52,1.02 97,2.35 95.72,3 95.71,3.01 62.99,3.01 62.98,3 61.7,2.35 61.18,1.02
+5V on IN08: 70.83,97.87 72.87,97.87 73.12,97.62 73.12,95.71 72.87,95.46 70.71,95.46 70.45,95.71 70.45,97.49
+5V on IN10: 94.33,72.04 94.33,66.22 97.48,63.07 97.48,61.47 96.44,60.43 96.44,54.56 97,54 97,43.96 97.63,43.32 104.55,43.32 104.87,43.64 104.87,59.26 103.35,60.79 103.35,80.09 103.98,80.72 103.98,83.14 104.74,83.9 104.74,91.14 104.24,91.65 103.09,91.65 102.2,92.54 99.28,92.54 98.77,92.03 98.77,82.88 96.11,80.22 96.11,73.82
+5V_FAN1 on BOTTOM: 294.42,76.96 294.29,76.83 292.61,76.83 291.97,76.2 291.08,76.2 290.96,76.33 290.96,79.38 291.08,79.5 292.61,79.5 294.42,77.69
+5V_FAN2 on BOTTOM: 94.96,94.82 97.5,94.82 97.76,94.57 97.76,91.39 97.63,91.27 96.23,91.27 94.9,92.6 94.9,94 94.84,94.06 94.84,94.69
+5V_HDD on BOTTOM: 294.35,81.23 286.23,81.23 286.1,81.36 286.1,83.14 286.35,83.39 289.56,83.39 289.94,83.77 289.94,84.58 290.07,84.71 290.58,84.71 291.34,85.47 292.73,85.47 293.62,86.36 295.02,86.36 295.15,86.23 295.15,82.03
+5V_HDMI_CON on BOTTOM: 5.68,138.51 4.54,138.51 4.29,138.26 4.29,136.48 7.08,136.48 7.33,136.22 7.33,135.84 7.46,135.72 8.1,135.72 8.22,135.84 8.22,136.35 7.33,137.24 5.05,137.24 4.92,137.37 4.92,137.49 5.05,137.62 5.56,137.62 5.68,137.75
+5V_USB1 on TOP: 17.88,67.14 17.88,68.41 16.48,68.41 15.59,67.52 14.7,67.52 14.57,67.39 14.57,66.63 14.37,66.42 13.56,66.42 13.43,66.3 13.43,64.09 13.68,63.83 16.48,63.83 17.49,62.82 18.51,62.82 18.64,62.94 18.64,63.45 18.51,63.58 18.51,66.5
