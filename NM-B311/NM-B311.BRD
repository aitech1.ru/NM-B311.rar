# Allegro board NM-B311.BRD (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP: 300.96,98.63 302.48,98.63 302.61,98.76 302.61,100.79 302.86,101.04 303.5,101.04 303.75,100.79 303.75,98.25 302.99,97.49 302.99,96.47 302.86,96.35 300.83,96.35 300.58,96.6 300.58,98.25
GND on TOP: 208.63,170.41 208.63,175.21 209.65,175.21 210.03,174.83 210.03,168.74 209.9,168.61 208.88,168.61 208.87,168.62 208.67,168.62 208.45,168.84 208.45,170.23
GND on TOP: 128.04,56.65 128.04,60.18 128.72,60.86 132.23,60.86 132.48,60.61 132.48,56.09 128.62,56.09 128.61,56.07
GND on TOP: 249.78,84.79 250.92,84.79 251.17,84.53 251.17,83.14 251.05,83.01 249.65,83.01 249.52,83.14 249.52,84.53
GND on TOP: 223.62,47.96 223.62,49.46 223.9,49.74 224.5,49.74 225.39,50.63 225.39,50.88 225.65,51.13 226.79,51.13 226.92,51.01 226.92,49.99 224.89,47.96
GND on TOP: outline of 126 points within 150.59,167.31 209.01,190
GND on TOP: 65.88,10.87 65.88,10.24 65.63,9.99 64.36,9.99 64.23,10.11 64.23,20.78 66.14,20.78 66.26,20.65 66.26,19.76 66.77,19.26 68.42,19.26 68.57,19.1 68.57,16.52 69.34,15.75 69.34,14.35 68.71,13.72 66.9,13.72 66.52,13.34 66.52,11.51
GND on TOP: 219.42,108.66 225.52,108.66 226.66,107.52 229.84,107.52 231.11,108.79 238.09,108.79 238.22,108.92 238.22,110.73 238.09,110.86 233.74,110.86 230.09,114.51 225.9,114.51 223.62,112.22 219.81,112.22 219.42,111.84
GND on TOP: 244.82,69.04 244.19,69.68 244.19,76.41 245.08,77.3 245.08,78.06 244.57,78.57 244.57,79.2 244.7,79.33 249.9,79.33 250.03,79.2 250.03,75.77 249.52,75.26 249.52,73.99 249.27,73.74 249.27,72.65 248.48,71.86 248.48,70.41 248.38,70.31 248.38,70.18 248.25,70.06 248.25,69.17 248.13,69.04
GND on TOP: 261.97,174.96 262.35,174.96 262.6,174.7 264.26,174.7 264.38,174.58 264.38,174.32 264.26,174.2 262.1,174.2 261.84,174.45 261.84,174.83
GND on TOP: 259.23,131.25 259.56,131.25 259.73,131.07 259.73,130.84 259.94,130.64 259.94,130 259.76,129.82 259.76,129.49 259.63,129.37 259.25,129.37 259.1,129.52 259.1,131.12
GND on TOP: 107.54,52.91 106.78,53.67 106.78,64.72 106.9,64.85 107.79,64.85 108.05,64.6 108.05,62.31 108.43,61.93 111.35,61.93 111.86,61.42 111.86,60.02 112.74,59.13 114.78,59.13 115.28,59.64 115.28,63.96 114.78,64.47 114.78,70.44 113.89,71.33 108.93,71.33 108.17,70.56 108.17,67.9 107.92,67.64 107.28,67.64 107.03,67.9 107.03,77.17 107.41,77.55 107.92,77.55 108.25,77.88 109.65,77.88 109.9,78.13 109.9,85.12 110.2,85.42 110.84,85.42 110.97,85.55 112.24,85.55 112.36,85.68 115.28,85.68 115.54,85.93 115.54,88.09 116.55,88.09 116.55,69.68 117.7,68.53 117.7,68.28 117.57,68.15 116.55,68.15 116.55,63.83 117.19,63.2 119.48,63.2 119.6,63.07 119.6,55.83 119.48,55.71 117.44,55.71 117.19,55.45 117.19,54.31 116.81,53.93 111.98,53.93 110.97,52.91
GND on TOP: 236.57,128.73 236.95,128.73 237.2,128.48 237.2,128.1 237.33,127.97 237.71,127.97 237.84,127.84 237.84,127.59 237.71,127.46 236.32,127.46 235.81,127.97 233.39,127.97 233.27,128.1 233.27,128.35 233.39,128.48 233.78,128.48 233.9,128.35 236.19,128.35
GND on TOP: 300.96,148.54 303.12,148.54 303.24,148.42 303.24,147.4 303.12,147.27 302.74,147.27 302.36,147.65 300.96,147.65 300.7,147.91 300.7,148.29
GND on TOP: 131.91,138.9 131.91,137.15 131.93,137.13 131.93,136.85 132.18,136.6 135.35,136.6 135.73,136.99 135.73,142.45 132.43,145.75 127.1,145.75 123.16,141.81 123.16,139.91 123.29,139.78 127.1,139.78 127.6,139.27 131.54,139.27
GND on TOP: 288.61,58.37 288.87,58.63 290.67,58.63 290.93,58.37 290.93,54.69 290.57,54.33 288.59,54.33 288.41,54.51 288.41,55.07 288.61,55.27
GND on TOP: 226.31,85.47 224.28,85.47 224.03,85.22 224.03,84.2 224.28,83.95 226.69,83.95 226.82,84.07 226.82,84.96
GND on TOP: 246.86,120.86 246.73,120.98 246.73,121.49 246.6,121.62 245.08,121.62 244.95,121.49 244.95,120.98 244.57,120.98 244.44,121.11 244.44,129.75 244.19,130 244.19,131.47 243.81,131.85 243.81,132.29 243.94,132.41 244.19,132.41 244.39,132.62 244.39,135.89 244.34,135.94 244.34,136.45 244.55,136.66 245.23,136.66 245.51,136.38 245.51,132.34 245.33,132.16 245.08,132.16 245,132.08 245,131.4 245.15,131.25 245.51,131.25 245.59,131.17 245.59,126.42 245.54,126.37 245.54,125.84 245.64,125.73 245.64,125.1 245.46,124.92 245.46,122.25 245.59,122.13 246.35,122.13 246.48,122.25 246.48,123.4 246.6,123.52 246.73,123.52 246.86,123.4 246.86,122.51 247.24,122.13 247.24,120.98 247.11,120.86
GND on TOP: 281.4,81.87 278.73,81.87 278.23,82.38 278.23,89.11 278.73,89.61 281.4,89.61 281.78,89.23 281.78,82.25
GND on TOP: 199.71,152.86 200.91,152.86 200.96,152.81 200.96,152.53 200.63,152.2 200.63,150.7 200.25,150.32 198.47,150.32 198.2,150.59 198.2,151.45 198.19,151.46 198.19,152.81 198.34,152.96 199.61,152.96
GND on TOP: 85.57,74.76 85.69,74.63 86.46,74.63 86.58,74.76 86.58,76.41 86.71,76.53 86.71,79.33 86.46,79.58 85.44,79.58 85.31,79.45 85.31,77.42 85.57,77.17
GND on TOP: 242.03,84.53 242.92,84.53 243.43,85.04 243.81,85.04 244.19,85.42 244.19,85.68 244.32,85.8 244.82,85.8 244.95,85.68 244.95,83.26 244.82,83.14 241.9,83.14 241.78,83.26 241.78,84.28
GND on TOP: 295.85,65.85 295.85,60.64 295.97,60.52 296.99,60.52 297.24,60.77 297.24,65.85 297.12,65.98 295.97,65.98
GND on TOP: 289.15,112.47 290.8,112.47 291.05,112.22 291.05,110.44 290.8,110.19 290.8,109.3 290.67,109.17 288.89,109.17 288.77,109.3 288.77,112.09
GND on TOP: 301.09,117.43 301.59,117.43 301.72,117.3 302.23,117.3 302.99,118.06 303.37,118.06 303.63,117.81 303.63,116.54 303.5,116.41 301.34,116.41 300.83,116.92 300.83,117.17
GND on TOP: 196.31,93.17 196.18,93.3 196.18,98.25 196.31,98.38 196.31,113.74 194.28,115.78 188.06,115.78 188.06,119.08 191.87,122.89 194.79,122.89 196.31,124.41 201.14,124.41 203.42,122.13 203.42,119.33 203.49,119.27 203.49,118.38 204.13,117.73 204.77,117.73 205.58,116.92 205.58,106.12 205.45,106 201.52,106 200.5,104.98 200.5,98.63 200.65,98.48 200.65,97.72 199.82,96.88 199.82,93.4 199.59,93.17
GND on TOP: 253.7,124.4 253.74,124.36 253.74,123.85 253.51,123.63 253.51,122.3 253.59,122.23 253.59,121.8 253.49,121.69 253.05,121.69 252.85,121.49 252.85,120.93 252.77,120.86 252.5,120.86 252.39,120.96 252.39,122.18 252.6,122.38 252.6,123.47 252.55,123.52 252.55,124.08 252.06,124.57 252.06,124.92 252.22,125.07 252.22,125.84 252.09,125.96 252.09,126.37 252.24,126.52 252.24,127.18 252.09,127.33 252.09,127.69 252.24,127.84 252.24,128.48 251.96,128.76 251.96,129.7 252.08,129.81 252.23,129.81 252.24,129.82 252.42,129.82 252.55,129.7 252.55,128.73 253.08,128.2 255.14,128.2 255.39,127.94 255.39,124.92 255.52,124.79 255.52,122.43 255.7,122.25 256.2,122.25 256.36,122.41 256.36,123.35 256.51,123.5 256.66,123.5 256.84,123.32 256.84,121.85 256.81,121.82 255.54,121.82 255.31,121.59 255.31,120.93 255.21,120.83 254.88,120.83 254.81,120.91 254.81,122.46 254.93,122.58 254.93,124.84 254.76,125.02 253.79,125.02 253.7,124.93
GND on TOP: 42.89,75.64 42.77,75.77 42.77,78.31 43.28,78.82 43.28,79.96 43.91,80.6 48.61,80.6 48.99,80.22 48.99,79.76 49.14,79.61 50.26,79.61 50.51,79.86 50.51,81.49 50.64,81.61 51.02,81.61 51.02,82.12 51.28,82.38 51.53,82.38 51.91,82.76 55.21,82.76 55.47,82.5 55.47,81.49 55.4,81.42 55.4,79.65 54.96,79.2 53.82,79.2 50.77,76.15 44.8,76.15 44.29,75.64
GND on TOP: 210.15,50.24 209.9,50.5 209.9,53.93 208.38,55.45 191.1,55.45 189.83,56.72 189.83,60.79 190.68,61.64 205.8,61.64 207.61,63.45 207.61,83.52 206.09,85.04 206.09,89.23 209.14,92.28 210.92,92.28 211.68,93.04 211.68,96.85 212.06,97.23 214.22,97.23 214.47,96.98 214.47,95.89 217.21,93.15 217.21,83.95 220.25,80.92 220.25,68.98 220.44,68.79 220.44,63.83 218.92,62.31 218.92,58.63 214.6,54.31 212.44,54.31 211.8,53.67 211.8,50.37 211.68,50.24
GND on TOP: 299.31,111.84 302.48,111.84 302.61,111.71 302.61,110.82 302.1,110.32 302.1,109.17 301.97,109.05 301.47,109.05 301.21,109.3 301.21,110.06 300.32,110.95 299.94,110.95 299.69,110.7 299.69,108.64 299.71,108.61 299.71,107.95 299.59,107.83 298.93,107.83 298.8,107.95 298.8,110.32 298.93,110.44 298.93,111.46
GND on TOP: 31.06,53.32 31.34,53.32 31.46,53.19 31.46,53.04 31.52,52.99 32.68,52.99 33.19,53.5 34.26,53.5 34.51,53.24 34.51,52.73 34.65,52.59 34.7,52.59 35.63,51.67 35.63,51.31 35.48,51.16 34.49,51.16 34.31,51.34 34.31,51.95 34.16,52.1 31.29,52.1 31.16,52.23 31.16,52.68 30.96,52.89 30.96,53.22
GND on TOP, IN03, IN05, IN08: 109.95,205.95 132.56,205.95 133.95,204.55 133.95,202.64 133.57,202.26 130.91,202.26 130.78,202.39 120.49,202.39 116.81,198.71 114.14,198.71 113.38,197.95 113.38,183.09 115.03,181.44 115.03,171.4 114.4,170.77 109.82,170.77 109.57,171.02 109.57,205.57
GND on BOTTOM: 247.36,51.77 247.36,52.91 247.87,53.42 248.89,53.42 249.02,53.29 249.02,52.15 248.51,51.64 247.49,51.64
GND on BOTTOM: 227.3,85.34 227.3,84.04 227.08,83.82 223.65,83.82 223.36,84.1 223.36,85.31 223.52,85.47 227.17,85.47
GND on BOTTOM: 249.04,122.09 249.04,139.87 249.13,139.97 249.31,139.97 249.71,139.57 249.71,139.32 249.61,139.22 249.61,138.97 249.74,138.84 249.74,138.59 249.51,138.37 249.51,137.59 249.64,137.47 249.64,137.12 249.46,136.94 249.46,136.29 249.69,136.07 249.69,135.74 249.41,135.47 249.41,134.97 249.71,134.67 249.71,134.37 249.44,134.09 249.44,133.57 249.69,133.32 249.69,132.24 249.53,132.09 249.53,131.32 249.74,131.12 249.74,130.92 249.51,130.69 249.51,129.94 249.71,129.74 249.71,128.82 249.53,128.64 249.53,127.79 249.71,127.62 249.71,127.37 249.58,127.24 249.58,126.39 249.71,126.27 249.71,125.99 249.56,125.84 249.56,125.02 249.71,124.87 249.71,124.59 249.39,124.27 249.39,123.87 249.53,123.72 249.53,123.62 249.69,123.47 249.69,123.14 249.56,123.02 249.56,122.87 249.69,122.74 249.69,122.49 249.51,122.32 249.51,122.17 249.39,122.04 249.09,122.04
GND on BOTTOM: 79.12,19.18 74.68,19.18 74.42,18.92 74.42,16.64 74.68,16.38 78.99,16.38 79.5,16.89 79.5,18.8
GND on BOTTOM: 66.39,42.75 64.74,42.75 64.48,43.01 63.47,43.01 63.34,43.13 63.34,44.53 63.72,44.91 66.26,44.91 66.52,44.66 66.52,42.88
GND on BOTTOM: 224.12,109.3 224.25,109.17 224.25,108.92 225.01,108.16 231.11,108.16 231.87,108.92 232.63,108.92 232.89,109.17 239.74,109.17 239.87,109.3 239.87,109.88 239.85,109.91 239.85,110.6 239.62,110.82 232.89,110.82 229.84,113.87 226.41,113.87 224.25,111.71 218.79,111.71 217.52,110.44 217.01,110.44 216.76,110.19 216.76,108.92 216.88,108.79 218.28,108.79 218.79,109.3
GND on BOTTOM: 132.1,139.88 131.95,139.73 131.95,136.96 132.2,136.71 138.5,136.71 139.16,137.37 139.16,139.65 138.93,139.88
GND on BOTTOM: 243.81,86.06 244.82,87.07 244.82,88.22 244.44,88.6 243.94,88.6 243.68,88.34 242.54,88.34 242.28,88.09 241.65,88.09 241.4,87.84 241.4,86.31 241.65,86.06
GND on BOTTOM: 113.89,93.04 113.38,93.55 113.38,100.66 114.52,101.81 124.3,101.81 124.94,101.17 124.94,93.17 124.81,93.04
GND on BOTTOM: 218.28,133.3 220.31,133.3 220.57,133.05 220.57,131.78 220.44,131.65 218.41,131.65 218.15,131.91 218.15,133.18
GND on BOTTOM: 27.93,68.58 28.14,68.79 28.59,68.79 28.7,68.69 28.7,68.25 28.39,67.95 28.39,67.59 28.06,67.26 25.75,67.26 25.48,67.53 25.47,67.52 25.06,67.52 24.86,67.72 24.86,68.43 25.01,68.58
GND on BOTTOM: 244.83,123.9 244.83,139.87 244.93,139.97 245.11,139.97 245.51,139.57 245.51,139.32 245.41,139.22 245.41,138.97 245.53,138.84 245.53,138.59 245.31,138.37 245.31,137.59 245.44,137.47 245.44,137.12 245.26,136.94 245.26,136.29 245.48,136.07 245.48,135.74 245.21,135.47 245.21,134.97 245.51,134.67 245.51,134.37 245.23,134.09 245.23,133.57 245.48,133.32 245.48,132.24 245.34,132.09 245.34,131.32 245.53,131.12 245.53,130.92 245.31,130.69 245.31,129.94 245.51,129.74 245.51,128.82 245.34,128.64 245.34,127.79 245.51,127.62 245.51,127.37 245.39,127.24 245.39,126.39 245.51,126.27 245.51,125.99 245.36,125.84 245.36,125.02 245.51,124.87 245.51,124.59 245.33,124.41 245.33,123.72 245.34,123.72 245.34,123.62 245.48,123.47 245.48,123.14 245.36,123.02 245.36,122.87 245.21,122.71 245.21,122.13 245.12,122.04 244.78,122.04 244.7,122.13 244.7,123.77
GND on BOTTOM: 281.02,68.53 281.15,68.41 281.15,66.88 280.89,66.63 276.57,66.63 276.32,66.88 276.32,68.41 276.45,68.53
GND on BOTTOM: 230.35,70.97 231.77,70.97 231.97,70.77 236.44,70.77 236.85,71.17 236.85,71.66 236.33,72.18 235.74,72.18 235.58,72.01 230.8,72.01 230.7,72.11 230.12,72.11 230.07,72.06 230.07,71.68 230.3,71.45 230.3,71.02
GND on BOTTOM: 103.73,63.83 103.98,63.58 106.78,63.58 107.28,64.09 107.28,65.61 106.65,66.25 105.25,66.25 105.12,66.37 105.12,66.63 104.87,66.88 103.98,66.88 103.73,66.63
GND on BOTTOM: 262.69,122.14 262.69,122.42 262.58,122.52 262.58,122.79 262.71,122.92 262.71,123.79 262.61,123.89 262.61,124.22 262.71,124.32 262.71,125.14 262.53,125.32 262.53,125.52 262.69,125.67 262.69,126.59 262.56,126.72 262.56,126.92 262.71,127.07 262.71,127.24 262.56,127.39 262.56,127.64 262.69,127.77 262.69,139.87 262.56,139.99 262.44,139.99 262.01,139.57 262.01,138.57 262.18,138.39 262.18,137.67 261.98,137.47 261.98,137.12 262.16,136.94 262.16,136.24 262.01,136.09 262.01,135.72 262.14,135.59 262.14,134.87 261.93,134.67 261.93,134.42 262.16,134.19 262.16,133.42 261.93,133.19 261.93,133.04 262.09,132.89 262.09,132.64 261.96,132.52 261.96,132.32 262.11,132.17 262.11,131.29 261.98,131.17 261.98,130.92 262.16,130.74 262.16,129.92 261.96,129.72 261.96,129.49 262.11,129.34 262.11,129.17 261.93,128.99 261.93,128.77 262.16,128.54 262.16,127.87 261.96,127.67 261.96,127.37 262.23,127.09 262.23,126.52 261.96,126.24 261.96,125.99 262.16,125.79 262.16,125.07 261.96,124.87 261.96,124.59 262.14,124.42 262.14,123.64 261.96,123.47 261.96,123.22 262.11,123.07 262.11,122.89 261.96,122.74 261.96,122.47 262.39,122.04 262.58,122.04
GND on BOTTOM: 85.69,76.53 86.46,76.53 86.58,76.41 86.58,74.63 86.46,74.5 85.69,74.5 85.57,74.63 85.57,76.41
GND on BOTTOM: outline of 185 points within 235.17,110.44 273.15,152.86 ; 3 cut-outs
GND on BOTTOM: 46.58,91.01 46.58,90.58 46.5,90.5 46.17,90.5 46.07,90.61 46.07,90.71 45.84,90.94 45,90.94 44.55,91.39 40.48,91.39 40.35,91.52 40.35,93.04 40.61,93.3 44.16,93.3 46.2,91.27 46.32,91.27
GND on BOTTOM: 274.29,182.96 276.7,182.96 276.96,182.71 276.96,178.64 276.57,178.26 275.05,178.26 274.8,178.51 274.8,180.29 274.54,180.55 273.4,180.55 273.27,180.67 273.27,181.94
GND on BOTTOM: 98.39,11.38 98.9,11.89 98.9,13.92 99.28,14.3 104.49,14.3 105.12,13.67 105.12,5.29 104.62,4.78 103.35,4.78 102.33,3.76 99.28,3.76 96.64,6.4 96.64,11.1 96.92,11.38
GND on BOTTOM: 257.78,73.87 257.52,73.61 253.84,73.61 253.46,73.99 253.46,76.41 253.71,76.66 257.52,76.66 257.78,76.41
GND on BOTTOM: 277.34,179.53 278.86,179.53 279.11,179.28 279.11,178.39 279.37,178.13 279.37,177.75 278.99,177.37 277.16,177.37 277.04,177.5 277.04,177.83 277.21,178 277.21,179.4
GND on BOTTOM: 207.61,68.66 207.61,83.9 207.74,84.03 208.77,84.03 209.02,83.77 209.02,68.55 208.88,68.41 207.87,68.41
GND on BOTTOM: 12.03,43.51 12.03,41.74 11.91,41.61 10.64,41.61 10.51,41.74 10.51,43.39 10.76,43.64 11.91,43.64
GND on BOTTOM: 288.51,55.83 289.53,54.82 289.53,53.8 289.02,53.29 288.51,53.29 288.39,53.17 288.39,52.78 288.64,52.53 290.29,52.53 290.8,53.04 290.8,56.09 290.54,56.34 288.77,56.34 288.51,56.09
GND on BOTTOM: 226.28,52.02 227.43,52.02 227.55,51.9 227.55,51.77 227.43,51.64 227.17,51.64 226.92,51.39 226.92,50.37 226.28,49.74 226.28,49.1 226.16,48.97 225.27,48.97 224.63,48.34 224.63,48.09 224.5,47.96 223.23,47.96 223.11,48.09 223.11,49.48 223.23,49.61 224.25,49.61 225.24,50.6 225.27,50.6 225.27,51.01
GND on BOTTOM: 284.58,54.18 284.7,54.05 284.7,47.58 284.32,47.2 280.26,47.2 280.13,47.32 280.13,50.5 280.12,50.51 280.12,53.81 280.49,54.18
GND on BOTTOM: 127.98,140.41 127.73,140.16 126.59,140.16 126.33,140.41 126.33,145.62 126.59,145.88 127.48,145.88 127.6,145.75 127.6,144.1 127.98,143.72
GND on BOTTOM: 274.8,109.05 276.45,109.05 277.84,107.65 277.84,102.95 277.46,102.57 275.05,102.57 274.8,102.82
GND on BOTTOM: 66.26,16.97 66.14,17.1 66.14,18.75 65.88,19 59.79,19 59.53,19.26 59.53,22.94 59.91,23.32 65.5,23.32 65.88,22.94 65.88,20.02 66.64,19.26 68.42,19.26 68.53,19.15 68.53,17.71 67.79,16.97
GND on BOTTOM: 253.86,125.73 253.86,128.49 253.18,129.17 253.18,129.44 253.23,129.49 253.23,129.82 252.79,130.27 252.79,130.37 253.91,131.49 253.91,132.19 254.01,132.29 254.18,132.29 254.28,132.19 254.28,131.27 253.58,130.57 253.58,129.84 253.46,129.72 253.46,129.49 254.28,128.67 254.28,127.29 254.61,126.97 254.61,126.74 254.31,126.44 254.31,125.72 254.23,125.63 253.96,125.63
GND on BOTTOM: 128.24,195.02 128.75,194.52 128.75,192.61 129,192.36 129.25,192.36 129.38,192.23 129.38,190.96 129.25,190.83 129.25,188.67 129.13,188.55 128.11,188.55 127.73,188.93 123.77,188.93 123.77,189.03 123.29,189.51 123.29,192.1 123.41,192.23 123.41,194.64 123.79,195.02
GND on BOTTOM: 297.15,37.33 297.1,37.29 294.11,37.29 293.85,37.54 293.85,38.69 294.28,39.12 296.95,39.12 297.15,38.92
GND on BOTTOM: 202.28,98.33 202.28,94.06 201.52,93.3 198.04,93.3 197.94,93.4 197.94,95.25 197.59,95.6 197.59,98.01 197.58,98.02 197.58,98.43 197.73,98.58 202.03,98.58
GND on BOTTOM: 267.05,36.4 267.05,33.99 267.3,33.73 267.3,32.97 266.92,32.59 266.92,31.58 266.67,31.32 265.27,31.32 265.14,31.45 263.75,31.45 263.04,32.16 263.04,36.2 263.75,36.91 266.54,36.91
GND on BOTTOM: 109.95,167.47 109.57,167.85 109.57,205.57 109.95,205.95 132.56,205.95 133.95,204.55 133.95,202.64 133.57,202.26 130.91,202.26 130.78,202.39 120.49,202.39 116.81,198.71 114.14,198.71 113.38,197.95 113.38,183.09 115.03,181.44 115.03,171.4 114.65,171.02 114.65,168.48 113.63,167.47
GND on BOTTOM: 298.12,71.33 302.99,71.33 303.5,70.82 303.5,58.63 302.1,57.23 300.7,57.23 299.94,56.47 295.62,56.47 295.12,56.98 295.12,60.33 296.04,61.24 296.04,66.04 294.89,67.18 291.18,67.18 290.8,67.56 290.8,69.29 291.69,70.18 291.69,71.58 291.73,71.62 291.73,73.41 292.1,73.79 294.51,73.79 295.15,73.15 296.8,73.15 297.94,72.01 297.94,71.5
GND on BOTTOM: 274.8,91.01 276.07,91.01 276.32,90.76 276.32,89.87 276.19,89.74 274.8,89.74 274.54,90 274.54,90.76
GND on BOTTOM: 261.46,182.71 263.37,182.71 264,182.07 264,178.64 263.75,178.39 260.7,178.39 260.45,178.64 260.45,181.69
GND on BOTTOM: 262.48,83.01 254.48,83.01 254.41,83.07 251.62,83.07 251.56,83.01 247.49,83.01 245.59,84.92 245.59,85.3 246.09,85.8 246.09,89.11 247.11,90.12 250.67,90.12 251.05,90.5 251.05,97.62 251.94,98.5 265.02,98.5 265.65,97.87 265.65,92.92 264,91.27 264,90.25 265.27,90.25 265.4,90.12 270.99,90.12 271.88,89.23 271.88,84.53 271.37,84.03 271.37,82.88 271.11,82.63 268.57,82.63 268.32,82.88 264.13,82.88 263.75,82.5 262.99,82.5
GND on BOTTOM: 106.78,75.26 105,75.26 105,79.58 104.87,79.71 104.87,82.76 105,82.88 106.65,82.88 106.78,83.01 106.78,86.69 106.39,87.07 105.38,87.07 105.12,86.82 102.33,86.82 101.7,86.19 101.7,77.04 102.84,75.9 102.84,69.29 103.47,68.66 105,68.66 105.25,68.91 106.65,68.91 106.78,69.04 106.78,69.17 106.65,69.29 105.12,69.29 105,69.42 105,70.18 105.12,70.31 106.65,70.31 106.78,70.44 106.78,70.69 106.65,70.82 105.25,70.82 105.12,70.95 105.12,71.83 106.65,71.83 106.78,71.96 106.78,72.22 105.25,72.22 105.12,72.34 105.12,73.36 106.65,73.36 106.78,73.49 106.78,73.74 105.25,73.74 105.12,73.87 105.12,74.76 105.25,74.88 106.78,74.88
GND on BOTTOM: 196.31,194.01 197.07,194.01 197.33,193.75 198.22,193.75 198.22,192.74 197.96,192.48 196.44,192.48 196.31,192.61
GND on BOTTOM: 252.83,122.47 252.83,122.69 253.01,122.87 253.01,123.09 252.83,123.27 252.83,123.44 252.99,123.59 252.99,124.39 252.86,124.52 252.86,124.89 253.23,125.27 253.51,125.27 253.58,125.19 253.58,124.92 253.51,124.84 253.51,124.59 253.58,124.52 253.58,124.22 253.48,124.12 253.48,123.89 253.61,123.77 253.61,123.54 253.51,123.44 253.51,123.17 253.58,123.09 253.58,122.84 253.46,122.72 253.46,122.52 253.64,122.34 253.64,122.17 253.53,122.07 253.23,122.07
GND on BOTTOM: 279.24,176.61 279.88,176.61 280.26,176.99 280.26,177.63 280.51,177.88 281.65,177.88 281.91,177.63 281.91,175.97 282.04,175.85 282.04,174.96 281.78,174.7 279.37,174.7 278.86,174.2 278.61,174.2 278.35,174.45 278.35,175.85 278.1,176.1 278.1,176.48 278.35,176.74 279.11,176.74
GND on BOTTOM: 212.19,125.43 212.06,125.3 210.15,125.3 210.03,125.17 209.14,125.17 209.01,125.3 209.01,127.21 209.26,127.46 211.68,127.46 212.19,126.95
GND on BOTTOM: 33.78,14.35 30.48,14.35 29.46,13.34 29.46,9.91 29.84,9.53 33.78,9.53 34.04,9.78 34.04,14.1
GND on BOTTOM: 33.5,26.24 34.84,27.59 34.84,36.22 34.41,36.66 23.39,36.66 22.75,36.02 20.42,36.02 20.16,35.77 20.16,31.7 20.92,30.94 22.19,30.94 22.45,30.69 22.45,27.26 23.46,26.24
GND on BOTTOM: 250.44,122.09 250.44,139.87 250.53,139.97 250.71,139.97 251.11,139.57 251.11,139.32 251.01,139.22 251.01,138.97 251.13,138.84 251.13,138.59 250.91,138.37 250.91,137.59 251.04,137.47 251.04,137.12 250.86,136.94 250.86,136.29 251.09,136.07 251.09,135.74 250.81,135.47 250.81,134.97 251.11,134.67 251.11,134.37 250.83,134.09 250.83,133.57 251.09,133.32 251.09,132.24 250.93,132.09 250.93,131.32 251.13,131.12 251.13,130.92 250.91,130.69 250.91,129.94 251.11,129.74 251.11,128.82 250.93,128.64 250.93,127.79 251.11,127.62 251.11,127.37 250.99,127.24 250.99,126.39 251.11,126.27 251.11,125.99 250.96,125.84 250.96,125.02 251.11,124.87 251.11,124.59 250.93,124.41 250.93,123.78 250.9,123.75 250.93,123.72 250.93,123.62 251.09,123.47 251.09,123.14 250.96,123.02 250.96,122.87 251.09,122.74 251.09,122.49 250.91,122.32 250.91,122.17 250.79,122.04 250.48,122.04
GND on BOTTOM: 192.17,198.25 192.37,198.45 192.37,199.93 192.45,200 194.15,200 194.2,199.95 194.2,198.61 194.35,198.45 194.79,198.45 194.91,198.58 194.91,199.95 194.96,200 196.69,200 196.72,199.98 196.72,198.1 196.44,197.82 196.44,196.29 196.06,195.91 192.37,195.91 192.17,196.12
GND on BOTTOM: 94.2,64.85 94.58,64.85 94.65,64.79 98.84,64.79 102.08,61.55 106.78,61.55 106.9,61.42 106.9,58.5 106.78,58.37 100.93,58.37 98.01,61.29 94.08,61.29 93.95,61.42 93.57,61.42 93.57,64.21
GND on BOTTOM: 263.87,26.11 265.14,26.11 265.53,26.5 265.53,27.89 265.4,28.02 263.75,28.02 263.62,27.89 263.62,26.37
GND on BOTTOM: 200.76,191.98 205.71,191.98 205.96,192.23 205.96,193.63 205.71,193.88 201.01,193.88 200.63,193.5 200.63,192.1
GND on BOTTOM: 237.89,72.32 238.37,72.32 238.78,71.91 239.97,71.91 240.35,72.29 240.66,72.29 241.07,71.89 241.83,71.89 242.16,71.56 242.41,71.56 242.95,72.09 243.96,72.09 244.11,71.94 244.11,71.58 243.66,71.12 243,71.12 242.61,70.74 241.29,70.74 241.07,70.51 239.59,70.51 239.21,70.13 238.18,70.13 237.87,70.44 237.87,72.29
GND on BOTTOM: 201.01,112.47 201.01,114 201.26,114.25 202.91,114.25 203.04,114.13 203.04,112.22 202.91,112.09 201.39,112.09
GND on BOTTOM: 272.51,85.3 272.76,85.3 273.02,85.04 273.65,85.04 273.78,85.17 274.8,85.17 274.92,85.04 274.92,84.79 275.81,83.9 276.7,83.9 276.96,83.65 276.96,83.01 276.32,82.38 274.29,82.38 274.03,82.63 274.03,83.9 273.4,84.53 272.76,84.53 272.38,84.92 272.38,85.17
GND on BOTTOM: 94.46,79.71 94.46,78.57 94.58,78.44 96.62,78.44 96.87,78.69 96.87,79.84 96.74,79.96 94.71,79.96
GND on BOTTOM: 93.69,99.39 93.69,97.74 97.63,97.74 97.63,99.39
GND on BOTTOM: 292.35,18.8 292.1,18.54 289.05,18.54 288.8,18.8 288.8,20.19 289.05,20.45 289.43,20.45 289.69,20.7 289.69,22.35 289.94,22.61 292.1,22.61 292.35,22.35
GND on BOTTOM: 36.42,80.98 37.18,80.98 37.31,81.11 37.31,81.82 36.42,82.38 35.4,82.38 35.15,82.12 35.15,81.74 35.27,81.61 35.78,81.61
GND on BOTTOM: 195.68,61.67 195.68,63.33 196.06,63.71 196.31,63.71 196.44,63.58 196.44,60.53 196.69,60.28 197.71,60.28 198.09,60.66 201.39,60.66 201.77,60.28 201.77,56.21 201.52,55.96 196.56,55.96 196.18,56.34 196.18,58.12 194.66,59.64 194.6,59.58 190.66,59.58 190.6,59.64 135.35,59.64 135.35,56.85 134.4,55.9 128.56,55.9 127.98,56.47 127.98,60.66 129,61.67
GND on BOTTOM: 298.58,83.95 295.78,83.95 295.66,83.82 295.66,82.55 295.78,82.42 298.58,82.42 298.7,82.55 298.7,83.82
GND on BOTTOM: 219.42,151.84 220.44,151.84 220.57,151.72 220.57,150.83 220.44,150.7 219.42,150.7 219.3,150.83 219.3,151.72
GND on BOTTOM: 217.01,125.94 220.57,125.94 220.82,126.19 221.2,126.19 221.46,125.94 221.46,124.79 221.2,124.54 217.01,124.54 216.88,124.67 216.88,125.81
GND on BOTTOM: 302.48,104.35 302.36,104.22 300.7,104.22 300.58,104.35 300.58,107.52 300.7,107.65 302.23,107.65 302.48,107.39
GND on BOTTOM: 255.69,122.14 255.69,122.42 255.58,122.52 255.58,122.79 255.71,122.92 255.71,123.79 255.61,123.89 255.61,124.22 255.71,124.32 255.71,125.14 255.53,125.32 255.53,125.52 255.69,125.67 255.69,126.59 255.56,126.72 255.56,126.92 255.71,127.07 255.71,127.24 255.56,127.39 255.56,127.64 255.69,127.77 255.69,139.87 255.56,139.99 255.44,139.99 255.01,139.57 255.01,138.57 255.18,138.39 255.18,137.67 254.99,137.47 254.99,137.12 255.16,136.94 255.16,136.24 255.01,136.09 255.01,135.72 255.13,135.59 255.13,134.87 254.93,134.67 254.93,134.42 255.16,134.19 255.16,133.42 254.93,133.19 254.93,133.04 255.09,132.89 255.09,132.64 254.96,132.52 254.96,132.32 255.11,132.17 255.11,131.29 254.99,131.17 254.99,130.92 255.16,130.74 255.16,129.92 254.96,129.72 254.96,129.49 255.11,129.34 255.11,129.17 254.93,128.99 254.93,128.77 255.16,128.54 255.16,127.87 254.96,127.67 254.96,127.37 255.23,127.09 255.23,126.52 254.96,126.24 254.96,125.99 255.16,125.79 255.16,125.07 254.96,124.87 254.96,124.59 255.13,124.42 255.13,123.64 254.96,123.47 254.96,123.22 255.11,123.07 255.11,122.89 254.96,122.74 254.96,122.47 255.39,122.04 255.58,122.04
GND on BOTTOM: 269.59,33.1 270.61,34.12 270.61,38.05 271.24,38.69 272.41,38.69 272.82,39.09 274.68,39.09 275.13,38.63 275.13,38.35 274.03,37.26 274.03,34.24 275.56,32.72 277.21,32.72 277.59,33.1 277.59,41.69 276.96,42.32 269.14,42.32 268.32,43.13 268.32,46.69 270.1,48.47 273.4,48.47 273.65,48.72 276.07,48.72 276.57,48.21 276.57,46.94 280.13,43.39 280.13,30.69 280,30.56 279.75,30.56 278.61,29.42 275.18,29.42 275.18,27.89 274.92,27.64 274.67,27.64 273.78,26.75 273.78,26.37 273.53,26.11 269.97,26.11 269.59,26.5
GND on BOTTOM: 255.62,64.34 256.64,64.34 256.76,64.21 256.76,61.29 256.79,61.27 256.79,60.99 256.64,60.84 254.91,60.84 254.65,61.09 254.65,63.66 254.96,63.96 255.24,63.96
GND on BOTTOM: 248.25,182.71 249.9,182.71 250.16,182.45 250.16,178.77 249.78,178.39 246.98,178.39 246.48,178.9 246.48,180.93
GND on BOTTOM: 188.7,156.33 188.4,156.63 188.4,157.81 188.83,158.24 191.73,158.24 192.11,157.87 192.11,157.18 190.84,155.91 189.83,155.91 189.71,156.04 189.71,156.29 189.66,156.33
GND on BOTTOM: 83.92,11 83.92,8.08 86.71,8.08 86.71,11
GND on BOTTOM: outline of 90 points within 230.09,163.91 276.45,180.29
GND on BOTTOM: 245.46,72.6 245.46,72.47 245.62,72.3 246.01,72.3 246.22,72.09 247.11,72.09 247.43,71.77 247.63,71.77 247.9,71.5 248.13,71.5 248.19,71.57 248.19,71.7 248.25,71.76 248.25,71.83 249.27,72.85 249.27,73.87 249.14,73.99 246.86,73.99
GND on BOTTOM: 218.92,154.26 218.92,157.69 219.3,158.07 221.46,158.07 221.71,157.81 221.71,154.38 221.33,154 219.17,154
GND on BOTTOM: 223.23,182.83 225.27,182.83 226.03,182.07 226.03,179.66 226.28,179.4 226.28,176.74 225.77,176.23 221.96,176.23 221.71,176.48 221.71,179.91 222.47,180.67 222.47,182.07
GND on BOTTOM: 308.45,107.14 308.45,99.27 308.71,99.01 310.1,99.01 310.36,99.27 310.36,107.27 309.98,107.65 308.96,107.65
GND on BOTTOM: 242.67,103.2 242.41,102.95 241.52,102.95 241.14,103.33 241.14,105.24 241.01,105.36 241.01,107.27 241.14,107.39 241.65,107.39 242.67,106.38
GND on BOTTOM: 66.52,12.32 66.52,11 65.5,9.99 64.36,9.99 64.1,10.24 64.1,11.26 63.6,11.76 63.6,12.42 63.75,12.57 66.26,12.57
GND on BOTTOM: 285.75,14.99 283.21,14.99 282.7,15.49 281.05,15.49 280.92,15.37 280.92,13.97 281.18,13.72 283.03,13.72 283.21,13.54 283.21,12.06 283.46,11.81 285.75,11.81 286,12.06 286,14.73
GND on BOTTOM: 235.3,182.83 236.95,182.83 237.97,181.82 237.97,180.67 237.71,180.42 237.2,180.42 237.08,180.29 237.08,178.77 236.7,178.39 234.54,178.39 234.16,178.77 234.16,181.69
GND on BOTTOM: 260.19,68.91 262.6,68.91 262.73,68.79 262.73,67.52 260.06,67.52 259.94,67.64 259.94,68.66
GND on BOTTOM: 283.34,22.86 278.64,22.86 278.51,22.73 278.51,18.92 278.64,18.8 283.34,18.8 283.46,18.92 283.46,22.73
GND on BOTTOM: 202.41,185.75 205.84,185.75 205.96,185.88 207.74,185.88 207.87,186.01 207.87,188.34 207.72,188.5 203.03,188.5 202.27,189.26 201.47,189.26 201.34,189.13 201.34,188.22 200.72,187.6 200.72,186.35 200.82,186.25 201.91,186.25
GND on BOTTOM: 286.71,43.36 286.3,42.95 284.22,42.95 283.89,43.29 283.89,44.38 284.12,44.61 286.53,44.61 286.71,44.43
GND on BOTTOM: 174.47,176.36 174.47,173.31 174.97,172.8 174.97,170.01 175.1,169.88 176.63,169.88 176.88,170.13 176.88,172.55 176.24,173.18 176.24,176.1 175.86,176.48 174.59,176.48
GND on BOTTOM: 234.26,68.63 238.47,68.63 238.75,68.91 240,68.91 240.33,69.24 240.33,69.78 240.15,69.96 234.28,69.96 234.03,69.7 234.03,68.86
GND on BOTTOM: outline of 198 points within 130.4,184.08 197.83,205.57
GND on BOTTOM: 273.81,61.04 271.72,61.04 271.27,61.5 271.27,62.79 271.55,63.07 273.98,63.07 274.09,62.97 274.09,61.32
GND on BOTTOM: 111.86,77.3 111.86,75.01 115.54,71.33 116.3,71.33 116.43,71.45 116.43,71.58 115.92,72.09 115.92,73.23 115.28,73.87 115.28,79.96 114.65,80.6 112.7,80.6 112.24,81.05 112.24,82.07 112.47,82.3 113.05,82.3 113.13,82.37 113.13,85.68 112.87,85.93 111.86,85.93 111.6,85.68 110.84,85.68 110.83,85.69 110.74,85.6 110.74,81.15 109.85,80.26 109.85,79.3
GND on BOTTOM: 295.24,80.98 295.37,81.11 297.78,81.11 298.04,80.85 298.04,76.66 295.91,76.66 292.79,79.78 289.97,79.78 289.64,80.11 289.64,80.7 289.92,80.98
GND on BOTTOM: 48.16,81.35 47.8,81.71 47.8,82.32 46.25,83.87 46.25,88.07 46.5,88.31 46.5,88.42 46.63,88.55 46.73,88.55 46.93,88.75 46.93,89.53 48.16,90.75 55.34,90.75 55.34,91.14 55.72,91.52 56.48,91.52 56.74,91.27 56.74,91.14 56.1,90.5 55.58,90.5 55.32,90.24 55.32,89.11 55.59,88.83 55.59,81.61 55.62,81.59 55.62,81.41 55.57,81.36 54.91,81.36 54.4,81.87 54.15,81.87 53.94,81.66 53.62,81.66 53.31,81.35 ; 2 cut-outs
GND on BOTTOM: 291.94,104.14 291.94,100.58 291.64,100.28 286.61,100.28 286.35,100.03 286.35,97.62 286.86,97.11 288.8,97.11 289.05,97.36 289.05,97.66 289.31,97.92 292.73,97.92 292.86,97.79 292.86,97.03 292.61,96.77 292.2,96.77 291.94,96.52 291.94,93.47 291.96,93.46 291.96,91.71 292.1,91.57 294.13,91.57 294.26,91.69 294.26,105.41 294.13,105.54 292.99,105.54 292.86,105.41 292.86,104.52 292.73,104.39 292.2,104.39
GND on BOTTOM: 247.64,122.09 247.64,139.87 247.74,139.97 247.91,139.97 248.31,139.57 248.31,139.32 248.21,139.22 248.21,138.97 248.34,138.84 248.34,138.59 248.11,138.37 248.11,137.59 248.23,137.47 248.23,137.12 248.06,136.94 248.06,136.29 248.28,136.07 248.28,135.74 248.01,135.47 248.01,134.97 248.31,134.67 248.31,134.37 248.04,134.09 248.04,133.57 248.28,133.32 248.28,132.24 248.13,132.09 248.13,131.32 248.34,131.12 248.34,130.92 248.11,130.69 248.11,129.94 248.31,129.74 248.31,128.82 248.13,128.64 248.13,127.79 248.31,127.62 248.31,127.37 248.18,127.24 248.18,126.39 248.31,126.27 248.31,125.99 248.16,125.84 248.16,125.02 248.31,124.87 248.31,124.59 248.28,124.57 248.28,123.14 248.16,123.02 248.16,122.87 248.28,122.74 248.28,122.49 248.11,122.32 248.11,122.17 247.99,122.04 247.69,122.04
GND on BOTTOM: 63.09,40.08 63.09,37.93 63.47,37.54 65.12,37.54 65.25,37.67 65.25,38.94 65.12,39.07 64.1,39.07 63.85,39.32 63.85,40.08 63.72,40.21 63.21,40.21
GND on BOTTOM: 292.86,87.25 295.78,87.25 295.91,87.12 295.91,86.74 295.78,86.61 293.62,86.61 292.86,85.85 291.21,85.85 290.83,85.47 290.19,85.47 290.07,85.6 290.07,86.49 290.32,86.74 292.35,86.74
GND on BOTTOM: 289.27,45.67 289.27,50.5 289.78,51.01 291.69,51.01 292.2,50.5 292.2,49.1 292.45,48.85 295.88,48.85 296.13,49.1 296.13,50.75 296.51,51.13 298.04,51.13 298.42,50.75 298.42,48.09 298.16,47.83 294.23,47.83 292.07,45.67
GND on BOTTOM: 261.28,122.14 261.28,122.42 261.18,122.52 261.18,122.79 261.31,122.92 261.31,123.79 261.21,123.89 261.21,124.22 261.31,124.32 261.31,125.14 261.14,125.32 261.14,125.52 261.28,125.67 261.28,126.59 261.16,126.72 261.16,126.92 261.31,127.07 261.31,127.24 261.16,127.39 261.16,127.64 261.28,127.77 261.28,139.87 261.16,139.99 261.04,139.99 260.61,139.57 260.61,138.57 260.79,138.39 260.79,137.67 260.58,137.47 260.58,137.12 260.76,136.94 260.76,136.24 260.61,136.09 260.61,135.72 260.74,135.59 260.74,134.87 260.53,134.67 260.53,134.42 260.76,134.19 260.76,133.42 260.53,133.19 260.53,133.04 260.69,132.89 260.69,132.64 260.56,132.52 260.56,132.32 260.71,132.17 260.71,131.29 260.58,131.17 260.58,130.92 260.76,130.74 260.76,129.92 260.56,129.72 260.56,129.49 260.71,129.34 260.71,129.17 260.53,128.99 260.53,128.77 260.83,128.47 260.83,125.14 260.56,124.87 260.56,124.59 260.74,124.42 260.74,123.64 260.56,123.47 260.56,123.22 260.71,123.07 260.71,122.89 260.56,122.74 260.56,122.47 260.99,122.04 261.18,122.04
GND on BOTTOM: 98.52,92.54 98.52,96.6 100.55,98.63 101.95,98.63 103.22,97.36 103.22,95.2 100.55,92.54
GND on BOTTOM: 154.66,168.6 156.18,167.08 156.18,166.58 155.92,166.32 145.26,166.32 142.34,169.24 142.34,171.02 143.73,172.42 153.97,172.42 154.66,171.73
GND on BOTTOM: 159.1,185.75 162.53,185.75 162.66,185.88 164.43,185.88 164.56,186.01 164.56,188.45 164.59,188.47 164.56,188.5 159.74,188.5 159.36,188.88 157.43,188.88 156.71,188.16 155.83,188.16 154.95,187.28 154.95,187.28 154.68,187 154.68,186.29 154.92,186.05 156.26,186.05 156.43,185.88 156.43,185.6 156.56,185.47 158.82,185.47
GND on BOTTOM: 33.12,53.17 33.88,53.17 34,53.29 34,53.42 34.13,53.55 34.39,53.55 34.51,53.42 34.51,51.9 34.39,51.77 34.13,51.77 34,51.9 34,52.02 33.88,52.15 33.12,52.15 32.99,52.28 32.99,53.04
GND on BOTTOM: 234.82,87.25 235.08,87.5 236.85,87.5 236.98,87.63 236.98,88.9 236.47,89.41 236.47,91.82 236.09,92.2 231.82,92.2 230.5,90.88 226.19,90.88 225.93,91.14 225.93,91.95 225.68,92.2 219.17,92.2 218.92,92.46 218.92,94.46 219.2,94.74 222.71,94.74 222.99,94.46 222.99,93.88 223.27,93.6 225.09,93.6 225.42,93.93 226.03,93.93 226.28,93.68 226.28,93.17 226.41,93.04 227.55,93.04 227.68,93.17 227.68,95.84 227.62,95.9 226.6,95.9 226.16,96.35 226.16,98.39 226.44,98.68 230.76,98.68 231.01,98.42 231.01,94.87 231.19,94.69 234.95,94.69 235.08,94.57 235.08,93.98 235.33,93.73 236.35,93.73 236.47,93.85 236.47,94.36 236.81,94.69 238.35,94.69 238.47,94.57 238.47,93.93 238.73,93.68 239.62,93.68 239.74,93.55 239.74,91.82 238.89,90.96 238.89,90.17 239.78,89.28 239.78,87.88 237.87,85.98 234.95,85.98 234.82,86.11
GND on BOTTOM: 306.49,5.8 306.35,5.45 306,5.31 292.86,5.31 292.07,6.1 292.07,10.44 293.04,11.4 298.96,11.4 300.56,13 301.32,13 301.75,13.44 301.75,20.57 301.37,20.57 301.12,20.32 300.23,20.32 299.97,20.07 299.72,20.07 299.59,20.19 299.59,22.73 299.72,22.86 304.65,22.86 304.9,23.11 304.9,26.72 304.67,26.95 304.42,26.95 304.22,27.15 304.22,27.51 304.39,27.69 304.7,27.69 304.9,27.89 304.9,44.12 304.06,44.96 303.15,44.96 303.02,45.09 303.02,46.66 303.76,47.4 311.16,47.4 311.49,47.07 311.49,11.5 311.35,11.15 311,11.01 308,11.01 306.93,10.57 306.49,9.5
GND on BOTTOM: 128.92,151.95 133.73,151.95 133.83,152.05 133.83,153.93 133.75,154 129.41,154 128.77,154.64 128.37,154.64 127.73,154 126.59,154 126.46,153.88 126.46,151.46 126.84,151.08 128.49,151.08 128.65,151.24 128.65,151.67
GND on BOTTOM: 162.4,175.97 164.05,175.97 164.31,175.72 164.31,175.09 164.18,174.96 164.18,173.18 164.56,172.8 164.56,168.48 164.43,168.35 162.4,168.35 161.77,168.99 161.77,174.45 161.89,174.58 161.89,175.47
GND on BOTTOM: 259.88,122.14 259.88,122.42 259.79,122.52 259.79,122.79 259.91,122.92 259.91,123.79 259.81,123.89 259.81,124.22 259.91,124.32 259.91,125.14 259.74,125.32 259.74,125.52 259.88,125.67 259.88,126.59 259.76,126.72 259.76,126.92 259.91,127.07 259.91,127.24 259.76,127.39 259.76,127.64 259.88,127.77 259.88,139.87 259.76,139.99 259.63,139.99 259.21,139.57 259.21,138.57 259.39,138.39 259.39,137.67 259.18,137.47 259.18,137.12 259.36,136.94 259.36,136.24 259.21,136.09 259.21,135.72 259.34,135.59 259.34,134.87 259.14,134.67 259.14,134.42 259.36,134.19 259.36,133.42 259.14,133.19 259.14,133.04 259.28,132.89 259.28,132.64 259.16,132.52 259.16,132.32 259.31,132.17 259.31,131.29 259.18,131.17 259.18,130.92 259.36,130.74 259.36,129.92 259.16,129.72 259.16,129.49 259.31,129.34 259.31,129.17 259.14,128.99 259.14,128.77 259.44,128.47 259.44,125.14 259.16,124.87 259.16,124.59 259.34,124.42 259.34,123.64 259.16,123.47 259.16,123.22 259.31,123.07 259.31,122.89 259.16,122.74 259.16,122.47 259.58,122.04 259.79,122.04
GND on BOTTOM: 291.85,15.88 290.19,15.88 289.94,15.62 289.94,13.59 290.19,13.34 291.85,13.34 292.1,13.59 292.1,15.62
GND on BOTTOM: 32.1,73.87 32.1,75.14 32.23,75.26 32.23,75.64 31.59,76.28 31.59,76.91 31.72,77.04 31.85,77.04 32.61,76.28 33.37,76.28 33.62,76.03 34.77,76.03 35.15,76.41 35.53,76.41 35.66,76.28 35.66,76.15 35.3,75.8 35.2,75.8 35.1,75.7 34.82,75.7 34.64,75.52 34.64,75.39 34.77,75.26 35.4,75.26 35.53,75.14 35.53,74.12 35.4,73.99 33.37,73.99 33.12,73.74 32.23,73.74
GND on BOTTOM: 186.53,175.59 186.53,168.74 186.91,168.35 188.56,168.35 189.2,168.99 189.2,175.09 188.44,175.85 186.79,175.85
GND on BOTTOM: 257.09,122.14 257.09,122.42 256.99,122.52 256.99,122.79 257.11,122.92 257.11,123.79 257.01,123.89 257.01,124.22 257.11,124.32 257.11,125.14 256.93,125.32 256.93,125.52 257.09,125.67 257.09,126.59 256.96,126.72 256.96,126.92 257.11,127.07 257.11,127.24 256.96,127.39 256.96,127.64 257.09,127.77 257.09,139.87 256.96,139.99 256.83,139.99 256.41,139.57 256.41,138.57 256.58,138.39 256.58,137.67 256.39,137.47 256.39,137.12 256.56,136.94 256.56,136.24 256.41,136.09 256.41,135.72 256.53,135.59 256.53,134.87 256.34,134.67 256.34,134.42 256.56,134.19 256.56,133.42 256.34,133.19 256.34,133.04 256.48,132.89 256.48,132.64 256.36,132.52 256.36,132.32 256.51,132.17 256.51,131.29 256.39,131.17 256.39,130.92 256.56,130.74 256.56,129.92 256.36,129.72 256.36,129.49 256.51,129.34 256.51,129.17 256.34,128.99 256.34,128.77 256.56,128.54 256.56,127.87 256.36,127.67 256.36,127.37 256.63,127.09 256.63,126.52 256.36,126.24 256.36,125.99 256.56,125.79 256.56,125.07 256.36,124.87 256.36,124.59 256.53,124.42 256.53,123.64 256.36,123.47 256.36,123.22 256.51,123.07 256.51,122.89 256.36,122.74 256.36,122.47 256.79,122.04 256.99,122.04
GND on BOTTOM: 134.97,91.52 135.1,91.39 145.13,91.39 145.26,91.27 147.8,91.27 147.92,91.39 149.19,91.39 149.32,91.27 151.1,91.27 151.23,91.39 172.05,91.39 172.43,91.77 175.23,91.77 175.74,91.27 194.66,91.27 194.79,91.14 194.79,90.25 194.66,90.12 194.66,89.11 195.17,88.6 195.55,88.6 195.8,88.85 195.8,89.61 195.42,90 195.42,92.03 195.55,92.15 195.55,93.12 194.86,93.81 137.89,93.81 135.73,95.96 135.73,97.74 135.22,98.25 130.02,98.25 129.13,97.36 129.13,91.9 129.51,91.52
GND on BOTTOM: 208.63,158.96 209.14,159.46 212.06,159.46 212.44,159.08 212.44,158.45 212.31,158.32 211.3,158.32 211.17,158.19 211.17,153.37 210.79,152.99 209.14,152.99 208.63,153.5
GND on BOTTOM: 246.23,122.09 246.23,139.87 246.34,139.97 246.51,139.97 246.91,139.57 246.91,139.32 246.81,139.22 246.81,138.97 246.93,138.84 246.93,138.59 246.71,138.37 246.71,137.59 246.83,137.47 246.83,137.12 246.66,136.94 246.66,136.29 246.88,136.07 246.88,135.74 246.61,135.47 246.61,134.97 246.91,134.67 246.91,134.37 246.64,134.09 246.64,133.57 246.88,133.32 246.88,132.24 246.74,132.09 246.74,131.32 246.93,131.12 246.93,130.92 246.71,130.69 246.71,129.94 246.91,129.74 246.91,128.82 246.74,128.64 246.74,127.79 246.91,127.62 246.91,127.37 246.78,127.24 246.78,126.39 246.91,126.27 246.91,125.99 246.76,125.84 246.76,125.02 246.91,124.87 246.91,124.59 246.58,124.27 246.58,123.87 246.74,123.72 246.74,123.62 246.88,123.47 246.88,123.14 246.76,123.02 246.76,122.87 246.88,122.74 246.88,122.49 246.71,122.32 246.71,122.17 246.58,122.04 246.29,122.04
GND on BOTTOM: 285.97,36.66 290.04,36.66 290.67,36.02 290.67,31.45 290.54,31.32 286.1,31.32 285.34,30.56 284.96,30.56 284.83,30.69 284.83,35.51
GND on BOTTOM: 68.93,76.28 70.96,76.28 71.09,76.15 71.09,75.01 70.96,74.88 69.06,74.88 68.8,75.14 68.8,76.15
GND on BOTTOM: 216.63,121.75 216.88,121.49 216.88,120.09 216.76,119.97 214.09,119.97 213.96,119.84 213.96,118.32 213.84,118.19 213.33,118.19 212.19,119.33 210.79,119.33 210.15,119.97 209.39,119.97 209.26,120.09 209.26,120.73 209.14,120.86 209.01,120.86 208.76,121.11 208.76,122.13 209.52,122.13 209.85,121.79 209.85,121.46 210.16,121.16 212.09,121.16 212.67,121.75
GND on BOTTOM: 44.8,60.4 44.8,64.6 44.93,64.72 49.5,64.72 49.63,64.6 49.63,64.34 49.24,63.96 49.24,60.02 49.12,59.9 45.43,59.9 45.05,60.28 44.93,60.28
GND on BOTTOM: 198.09,175.72 199.36,175.72 199.87,175.21 199.87,171.91 200.76,171.02 200.76,166.58 201.26,166.07 201.26,161.88 200.76,161.37 199.99,161.37 197.2,164.16 197.2,174.83
GND on BOTTOM: 290.54,186.01 290.54,182.58 293.97,182.58 293.97,186.01
GND on BOTTOM: 277.97,167.97 277.97,162.39 280.89,159.46 280.89,155.78 281.78,154.89 287.12,154.89 287.88,155.65 293.59,155.65 293.59,159.97 293.34,160.23 284.7,160.23 281.4,163.53 281.4,170.39 281.02,170.77 277.84,170.77 277.59,170.51 277.59,168.35
GND on BOTTOM: 210.28,168.61 210.03,168.35 207.99,168.35 207.74,168.61 207.74,171.15 207.87,171.28 208.05,171.28 208.28,171.51 208.28,175.72 208.4,175.83 208.83,175.83 208.86,175.87 209.86,175.87 210.28,175.44
GND on BOTTOM: outline of 148 points within 204.57,197.44 269.59,205.95
GND on BOTTOM: 43.66,15.19 43.66,12.65 43.69,12.65 43.69,9.53 43.81,9.4 46.35,9.4 46.74,9.78 46.74,12.54 45.94,13.34 45.94,15.19
GND on BOTTOM: outline of 118 points within 227.65,53.78 251.25,70.62 ; 2 cut-outs
GND on BOTTOM: 300.3,108.41 301.21,108.41 301.59,108.03 302.48,108.03 302.74,108.28 302.74,109.81 304.39,111.46 304.39,157.05 301.72,159.72 296.64,159.72 296.64,159.08 295.62,158.07 295.62,144.99 294.99,144.35 294.99,140.67 295.62,140.03 295.62,133.56 295.24,133.18 294.35,133.18 293.59,132.41 288.26,132.41 287.24,131.4 287.24,129.24 286.48,128.48 286.48,120.35 287.5,119.33 287.5,119.08 288.39,118.19 295.5,118.19 295.62,118.06 295.62,114 296.01,113.62 296.01,109.81 296.51,109.3 296.51,109.17 297.4,108.28 298.55,108.28 298.93,107.9 299.79,107.9
GND on BOTTOM: 298.96,92.08 295.91,92.08 295.66,91.82 295.66,90.81 295.91,90.55 298.96,90.55 299.21,90.81 299.21,91.82
GND on BOTTOM: 251.83,122.09 251.83,139.87 251.93,139.97 252.11,139.97 252.51,139.57 252.51,139.32 252.41,139.22 252.41,138.97 252.53,138.84 252.53,138.59 252.31,138.37 252.31,137.59 252.44,137.47 252.44,137.12 252.26,136.94 252.26,136.29 252.48,136.07 252.48,135.74 252.21,135.47 252.21,134.97 252.51,134.67 252.51,134.37 252.23,134.09 252.23,133.57 252.48,133.32 252.48,132.24 252.34,132.09 252.34,131.32 252.53,131.12 252.53,130.92 252.31,130.69 252.31,129.94 252.51,129.74 252.51,128.82 252.34,128.64 252.34,127.79 252.51,127.62 252.51,127.37 252.39,127.24 252.39,126.39 252.51,126.27 252.51,125.99 252.36,125.84 252.36,125.02 252.51,124.87 252.51,124.59 252.18,124.27 252.18,122.17 252.06,122.04 251.88,122.04
GND on BOTTOM: outline of 84 points within 257.74,122.04 258.51,139.99
GND on GND02, GND04, GND09: outline of 299 points within 0.51,0.51 311.49,205.99 ; 1 cut-out
GND on IN03: 288.39,107.52 295.75,107.52 296.01,107.27 296.01,101.68 295.5,101.17 290.8,101.17 290.54,100.92 290.54,100.28 290.8,100.03 291.69,100.03 291.94,100.28 294.99,100.28 295.75,99.52 295.75,92.79 295.37,92.41 287.37,92.41 286.48,93.3 286.48,105.62
GND on IN03: 219.04,89.87 217.77,91.14 217.77,100.54 218.41,101.17 239.49,101.17 240.13,100.54 240.13,92.28 237.71,89.87
GND on IN03: 5.18,84.89 7.84,84.89 8.07,84.66 12.49,84.66 12.49,84.66 14.13,84.66 15.32,83.47 15.32,76.99 11.97,73.63 2.98,73.63 1.9,74.7 1.9,79.81 1.9,79.81 1.9,82.25 2.64,82.99 3.89,82.99 3.9,82.98 3.91,82.99 4.03,82.99 4.66,83.61 4.66,84.37
GND on IN03: 1.62,166.7 2.76,167.85 3.78,167.85 4.03,168.1 4.03,174.2 4.67,174.83 18.26,174.83 18.76,174.32 18.76,163.15 17.11,161.5 17.11,150.7 15.59,149.18 14.19,149.18 12.03,147.02 10.13,147.02 8.99,145.88 8.99,143.34 11.78,140.54 11.78,126.7 10.64,125.56 10.64,123.9 10.13,123.4 1.62,123.4 1.11,123.9 1.11,139.78 3.14,141.81 3.14,147.65 1.62,149.18
GND on IN03: 269.46,199.85 269.46,194.77 268.7,194.01 262.86,194.01 261.59,195.28 261.59,200.23 261.46,200.36 259.81,200.36 259.56,200.1 259.56,196.8 259.05,196.29 249.9,196.29 249.52,196.68 249.52,200.23 249.4,200.36 247.75,200.36 247.62,200.23 247.62,196.68 247.24,196.29 237.84,196.29 237.46,196.68 237.46,200.1 237.33,200.23 235.68,200.23 235.55,200.1 235.55,196.8 235.05,196.29 225.52,196.29 225.01,196.8 225.01,200.36 224.89,200.49 222.73,200.49 222.35,200.1 222.35,195.66 222.09,195.41 215.87,195.41 212.69,198.58 212.69,200.23 212.82,200.36 221.84,200.36 222.09,200.61 268.7,200.61
GND on IN05: 187.07,188.67 187.98,189.59 190.09,189.59 190.8,188.88 196.51,188.88 197.61,187.79 202.36,187.79 202.64,187.51 208.6,187.51 209.37,186.74 209.37,184.41 208.81,183.85 208.81,179.43 207.28,177.91 168.5,177.91 166.87,179.53 155.67,179.53 155.48,179.72 153.19,179.72 151.86,181.05 151.86,188.17 152.37,188.67
GND on IN05: 218.54,117.43 222.09,117.43 222.22,117.3 222.22,113.49 221.71,112.98 217.65,112.98 217.39,113.24 217.39,116.28
GND on VCC06: outline of 268 points within 1.02,5.82 310.98,205.48 ; 3 cut-outs
GND on VCC07: outline of 130 points within 1.02,15.52 137.51,205.48
GND on VCC07: outline of 148 points within 166.85,5.82 310.98,205.48
GND on VCC07: 207.97,86.57 205.45,89.08 205.45,92.64 204.54,93.55 196.92,93.55 196.31,94.16 196.31,103.31 192.35,107.27 118.08,107.27 118.08,110.46 125.32,117.7 125.32,159.36 131.52,165.56 160.26,165.56 169.13,156.69 169.13,156.57 169.26,156.44 169.26,155.22 169.77,154.71 169.77,152.41 169.26,151.9 169.26,142.88 169.01,142.63 169.01,139.22 169.26,138.97 169.26,138.79 169.77,138.28 169.77,138.02 170.04,137.75 184.86,137.75 185.52,138.4 185.52,139.91 204.46,139.91 204.95,139.42 204.95,114.66 205.6,114 231.26,114 231.62,113.64 231.62,110.34 234.43,107.52 241.78,107.52 241.78,88.47 212.46,88.47 210.56,86.57
GND on IN08: 289.91,107.65 294.61,107.65 295.24,107.01 295.24,92.28 294.61,91.65 288.26,91.65 286.86,93.04 286.86,106.63 288,107.78 289.78,107.78
GND on IN08: 222.22,195.91 214.85,195.91 211.17,199.6 211.17,205.82 211.34,205.99 268.28,205.99 268.32,205.95 268.32,204.93 267.81,204.42 222.73,204.42 221.46,203.15 221.46,202.14 222.09,201.5 223.49,201.5 224.89,202.9 232.38,202.9 233.78,201.5 235.68,201.5 237.08,202.9 244.7,202.9 245.84,201.76 247.87,201.76 248.89,202.77 257.65,202.77 258.54,201.88 260.83,201.88 261.46,202.52 269.84,202.52 271.24,201.12 271.24,198.07 270.86,197.69 262.35,197.69 261.72,198.33 261.72,199.98 261.59,200.1 260.45,200.1 260.19,199.85 260.19,198.71 259.3,197.82 250.29,197.82 249.52,198.58 249.52,200.1 249.4,200.23 248.38,200.23 248.13,199.98 248.13,198.58 247.36,197.82 237.84,197.82 237.46,198.2 237.46,200.1 237.33,200.23 236.19,200.23 236.06,200.1 236.06,197.82 235.68,197.44 225.9,197.44 225.52,197.82 225.52,198.83 225.01,199.34 223.87,199.34 223.36,198.83 223.36,197.06 ; 1 cut-out
GND on IN08: 239.49,87.33 236.7,90.12 221.08,90.12 219.68,91.52 219.68,94.69 219.93,94.95 219.93,97.49 220.95,98.5 239.62,98.5 240.63,97.49 240.63,87.96 240,87.33
GND on IN10: 291.97,89.76 291.97,86.84 292.53,86.28 297.59,86.28 298.12,86.82 298.12,89.66 297.59,90.2 292.4,90.2
GND on IN10: 292.96,107.39 295.37,107.39 296.39,106.38 296.39,92.66 295.88,92.15 288.89,92.15 287.75,93.3 287.75,103.71 288.51,104.47 290.04,104.47
GND on IN10: 109.57,205.57 109.95,205.95 132.56,205.95 133.95,204.55 133.95,202.64 133.57,202.26 130.91,202.26 130.78,202.39 120.49,202.39 116.81,198.71 114.14,198.71 113.38,197.95 113.38,183.09 115.03,181.44 115.03,171.4 114.4,170.77 109.82,170.77 109.57,171.02 ; 2 cut-outs
GND on IN10: 4.36,84.92 6.78,84.92 7.03,84.66 9.32,84.66 10.08,83.9 10.08,82.88 9.7,82.5 8.3,82.5 7.28,81.49 6.65,81.49 6.27,81.11 6.27,76.41 5.89,76.03 3.73,76.03 3.22,76.53 3.22,82.88 3.85,83.52 3.85,84.41
GND on IN10: 285.97,37.54 289.91,37.54 290.29,37.16 290.29,31.58 290.04,31.32 286.1,31.32 285.85,31.58 285.85,37.42
GND on IN10: 220.57,95.84 236.95,95.84 237.71,95.08 237.71,90.63 236.95,89.87 221.08,89.87 219.81,91.14 219.81,95.08
GND on IN10: 13.05,84.03 13.05,82.38 13.43,81.99 14.95,81.99 15.46,82.5 15.46,83.9 15.08,84.28 13.3,84.28
GND on IN10: 237.46,185.75 214.34,185.75 213.71,185.12 213.71,183.21 212.06,181.56 212.06,176.36 212.82,175.59 224.63,175.59 228.7,179.66 235.3,179.66 235.43,179.53 237.46,179.53 237.84,179.91 237.84,185.37
GND on IN10: 41.88,84.03 41.88,81.87 42.26,81.49 44.04,81.49 44.55,81.99 44.55,84.15 44.16,84.53 42.39,84.53
GND on GND11: outline of 299 points within 0.51,0.51 311.49,205.99 ; 21 cut-outs
VBAT on TOP: 110.9,26.56 110.97,26.5 110.97,23.32 110.2,22.56 108.05,22.56 107.92,22.43 106.01,22.43 105.51,21.92 102.33,21.92 100.3,23.96 100.3,26.75 100.55,27 110.71,27 110.9,26.81
VBAT on BOTTOM: 100.43,28.53 109.32,28.53 110.08,27.77 110.08,24.34 109.44,23.7 94.51,23.7 93.11,22.3 83.41,22.3 82.77,22.94 82.77,27.77 82.8,27.79 82.8,28.93 83.28,29.42 99.54,29.42
VBAT on IN03: 99.92,27.38 99.92,23.32 110.46,23.32 110.46,27.38
VCC0V9_CIO on TOP: 52.17,87.73 52.17,87.5 51.96,87.29 51.96,87 51.81,86.85 51.43,86.85 51.33,86.74 51.33,86.52 51.73,86.11 52.01,86.11 52.09,86.15 52.11,86.19 52.55,86.19 52.67,86.31 52.67,86.69 52.67,86.95 52.72,87 52.72,87.79 52.65,87.86 52.3,87.86
VCC0V9_CIO on BOTTOM: 51.84,88.14 52.42,88.14 52.72,87.84 52.72,87.1 52.65,87.02 52.65,86.59 52.7,86.54 52.7,86.13 52.5,85.93 51.99,85.93 51.63,86.29 51.63,86.47 51.76,86.59 51.76,88.07
VCC0V9_DP on TOP: 53.52,85.78 53.52,87.72 53.44,87.81 53.44,87.96 53.05,88.34 52.93,88.34 52.8,88.22 52.8,87.61 52.83,87.58 52.83,86.82 52.93,86.72 52.93,86.19 52.8,86.06 52.29,86.06 52.24,86.01 52.24,85.63 52.34,85.53 53.27,85.53
VCC0V9_DP on BOTTOM: 50.16,88.8 50.95,88.8 51.07,88.67 51.07,87.81 50.72,87.46 50.16,87.46 50.13,87.43 50.13,87.15 50.54,86.74 50.54,86.11 50.39,85.96 50.06,85.96 49.73,86.29 49.73,87.43 49.68,87.48 49.68,87.84 49.83,87.99 50.01,87.99 50.21,88.19 50.21,88.45 50.11,88.55 50.11,88.75
VCC0V9_DP on BOTTOM: 53,87.25 53.26,87.25 53.59,86.92 53.59,85.42 53.46,85.3 53.33,85.3 52.72,85.91 52.72,86.97
VCC0V9_DP on IN03: 49.5,85.8 49.5,88.6 49.75,88.85 52.29,88.85 53.44,87.71 53.44,86.31 53.31,86.19 52.93,86.19 52.8,86.31 51.78,86.31 50.9,85.42 49.88,85.42
VCC0V9_LVR_OUT on TOP: 48.77,82.9 48.77,83.74 48.41,83.74 47.97,84.18 47.44,84.18 47.34,84.28 45.94,84.28 45.56,83.9 45.56,83.26 45.69,83.14 47.09,83.14 47.6,82.62 48.49,82.62
VCC0V9_PCIE on TOP: 50.25,83.12 49.89,82.75 49.62,82.75 49.37,82.5 49.37,81.87 49.12,81.61 49.12,79.91 49.17,79.86 50.06,79.86 50.13,79.94 50.13,81.61 50.9,82.38 50.9,85.02 50.84,85.07 50.36,85.07 50.25,84.96
