# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE4_TBT_TX_DP3: length 238
  IN05 w0.114: v2(49.31,75.18) 49.46,75.18 49.56,75.28 49.56,76.22 49.37,76.41 48.99,76.41 48.61,76.03 48.61,75.14 49.61,74.13 50.24,74.13 51.77,72.61 52.66,72.61 53.19,72.07 53.19,69.91 57.88,65.23 58.77,65.23 59.66,64.34 59.66,62.69 60.93,61.42 60.93,58.47 63.69,55.71 63.98,55.71 64.36,55.33 64.36,54.81 65.87,53.31 71.33,53.31 72.72,51.91 75.9,51.91 76.79,51.02 78.47,51.02 78.98,51.53 90.88,51.53 91.27,51.15 93.84,51.15 95.36,52.67 97.27,52.67 99.43,54.83 101.58,54.83 104.99,58.23 104.99,61.02 105.37,61.4 105.37,65.09 108.39,68.11 119.67,68.11 120.25,67.53 135.79,67.53 136.8,68.55 136.8,73.24 138.08,74.51 144.91,74.51 146.18,75.78 146.42,75.78 146.9,76.26 146.9,77.06 149.17,79.34 207,79.34 207.38,79.72 221.49,79.72 222.36,80.59 236.83,80.59 238.35,79.07 238.35,77.47 237.98,77.11 237.98,75.7 237.74,75.46 237.74,75.3 237.86,75.19 238.37,75.19 238.53,75.03 238.53,74.74 238.27,74.48 238.02,74.48 v3(237.74,74.76)
  BOTTOM w0.104: U2.A21 238.14,73.1 238.14,74.35 v3(237.74,74.76) ; C2039.2 49.4,76.46 49.59,76.27 49.59,75.46 v2(49.31,75.18)
PCIE9_SSD2_RX_DN0: length 146.2
  IN05 w0.076: v3(232.63,70.55) 232.39,70.3 232.31,70.3 232.21,70.41 232.21,70.83 232.26,70.88 232.26,70.9
  IN05 w0.114: v2(118.31,55.15) 118.06,55.15 117.91,55 117.91,53.59 120.26,51.24 150.76,51.24 153.65,54.12 186.98,54.12 188.76,55.9 213.68,55.9 220.41,62.63 221.02,62.63 222.24,63.86 222.24,64.82 222.63,65.21 222.63,71.48 225.37,74.22 228.54,74.22 230.11,72.65 231.05,72.65 232.26,71.44 232.26,70.9
  BOTTOM w0.104: v3(232.63,70.55) 233,70.55 233.11,70.44 U2.G31 ; R482.1 110.36,57.18 111.04,57.18 111.37,56.84 111.37,55.83 114.16,53.04 116.79,53.04 118.03,54.27 118.03,54.87 v2(118.31,55.15)
PCIE9_SSD2_RX_DP0: length 146.2
  IN05 w0.076: v3(232.63,69.9) 232.39,70.15 232.25,70.15 232.05,70.34 232.05,70.83 232,70.88 232,70.9
  IN05 w0.114: 232,70.9 232,71.33 230.94,72.39 230,72.39 228.43,73.95 225.48,73.95 222.89,71.36 222.89,65.09 222.51,64.71 222.51,63.74 221.13,62.36 220.52,62.36 213.79,55.64 188.87,55.64 187.09,53.86 153.76,53.86 150.87,50.97 120.15,50.97 117.64,53.48 117.64,55 v2(117.49,55.15)
  BOTTOM w0.104: v2(117.49,55.15) 117.66,55.15 117.77,55.05 117.77,54.38 116.68,53.29 114.27,53.29 111.63,55.93 v2(111.63,56.21) 111.63,56.95 111.14,57.43 110.38,57.43 110.15,57.66 R481.1 ; U2.H31 232.77,69.9 v3(232.63,69.9)
PCIE9_SSD2_RX_R_DN0: length 27.6
  BOTTOM w0.104: JSSD2.43 105.25,76.04 105.13,75.92 102.73,75.92 102.05,75.24 102.05,63.73 103.6,62.18 106.4,62.18 107.21,61.37 107.21,58.19 v2(107.71,57.69) 108.22,57.18 109.04,57.18 R482.2
PCIE9_SSD2_RX_R_DP0: length 27.6
  BOTTOM w0.104: JSSD2.41 105.25,75.54 105.13,75.66 102.84,75.66 102.31,75.13 102.31,63.84 103.71,62.44 106.5,62.44 107.46,61.48 107.46,58.3 108.32,57.44 108.55,57.44 108.66,57.54 108.66,58.14 108.83,58.32 109.04,58.32 109.24,58.12 R481.2
PCIE9_SSD2_TX_C_DN0: length 2.6
  BOTTOM w0.104: C197.1 107.93,76.31 107.6,76.64 107.31,76.64 107.08,76.86 107.08,77.11 107,77.19 106.82,77.19 106.67,77.04 JSSD2.47
PCIE9_SSD2_TX_C_DP0: length 2.6
  BOTTOM w0.104: C198.1 107.93,77.23 107.59,76.89 107.42,76.89 107.34,76.97 107.34,77.22 107.11,77.45 106.78,77.45 106.69,77.54 JSSD2.49
PCIE9_SSD2_TX_DN0: length 153.1
  IN05 w0.114: v3(217.01,74.5) 217.14,74.63 217.14,74.98 216.88,75.24 213.81,75.24 212.82,74.25 202.41,74.25 201.52,73.36 183.36,73.36 183.03,73.03 168.68,73.03 168.43,72.78 149.89,72.78 149.57,72.47 149.57,68.28 148.3,67.01 146.15,67.01 145.06,65.92 143.03,65.92 140.04,62.93 114.79,62.93 v2(113.89,63.83)
  BOTTOM w0.076: U2.C31 233.42,72.39 233.42,73.04 232.49,73.97 232.49,74.32 232.55,74.37 232.55,74.38
  BOTTOM w0.104: 232.55,74.38 232.55,74.84 232.13,75.26 232.13,76.34 227.86,80.6 221.84,80.6 217.14,75.9 217.14,74.63 v3(217.01,74.5) ; C197.2 108.84,76.52 109.06,76.73 109.64,76.73 109.82,76.55 109.82,74.89 113.86,70.84 v2(113.86,67.52) 113.86,67.03 114.29,66.61 114.29,63.98 114.14,63.83 v2(113.89,63.83)
PCIE9_SSD2_TX_DP0: length 153.2
  IN05 w0.114: v3(217.77,74.5) 217.55,74.5 217.41,74.64 217.41,75.09 217,75.51 213.7,75.51 212.71,74.51 202.3,74.51 201.41,73.63 183.25,73.63 182.92,73.3 168.57,73.3 168.32,73.05 149.78,73.05 149.31,72.58 149.31,68.39 148.19,67.28 146.04,67.28 144.95,66.19 142.92,66.19 139.93,63.2 114.9,63.2 114.71,63.39 v2(114.71,63.83)
  BOTTOM w0.076: 232.29,74.38 232.29,74.37 232.34,74.32 232.34,73.9 233.27,72.98 233.27,72.47 233.19,72.39 233.12,72.39 233.05,72.47 U2.B31
  BOTTOM w0.104: 232.29,74.38 232.29,74.74 231.87,75.15 231.87,76.23 227.76,80.34 227.47,80.34 227.34,80.22 226.93,80.22 226.8,80.34 226.38,80.34 226.26,80.22 225.84,80.22 225.72,80.34 225.3,80.34 225.18,80.22 224.76,80.22 224.64,80.34 221.94,80.34 217.4,75.79 217.4,75.01 217.47,74.93 217.92,74.93 217.98,74.88 217.98,74.58 217.9,74.5 v3(217.77,74.5) ; C198.2 109.15,76.99 109.75,76.99 110.08,76.66 110.08,74.99 114.12,70.95 114.12,67.14 114.54,66.72 114.54,64 v2(114.71,63.83)
PCIE10_SSD2_RX_DN1: length 162.9
  IN05 w0.076: 234.26,71.27 234.26,71.26 234.26,71.18 234.44,71.01 234.44,70.37 234.17,70.11 233.95,70.11 v3(233.78,69.93)
  IN05 w0.114: 234.26,71.27 234.17,71.36 234.17,71.5 229.79,75.88 224.44,75.88 221.1,72.54 221.1,66.25 218.94,64.09 218.93,64.09 212.52,57.68 194.95,57.68 194.64,57.99 188.19,57.99 186.86,56.66 153.66,56.66 150.08,53.09 123.97,53.09 122.99,54.06 122.99,54.86 122.99,54.86 v2(123.21,55.08)
  BOTTOM w0.104: v3(233.78,69.93) 234,69.93 234.25,70.18 U2.G29 ; v2(123.21,55.08) 122.96,54.82 122.96,53.99 122.64,53.67 122.03,53.67 121.51,54.19 121.51,57.23 117.7,61.04 113.76,61.04 111.4,63.4 v2(111.4,69.8) 111.4,70.52 109.25,72.66 106.77,72.66 106.65,72.54 JSSD2.29
PCIE10_SSD2_RX_DP1: length 162.9
  IN05 w0.076: v3(233.78,70.56) 233.78,70.44 233.95,70.26 234.11,70.26 234.28,70.44 234.28,70.95 234.16,71.07 234.07,71.07 234.07,71.08
  IN05 w0.114: 234.07,71.08 233.99,71.16 233.9,71.25 233.9,71.39 229.68,75.61 224.55,75.61 221.37,72.43 221.37,66.14 219.05,63.82 219.04,63.82 212.63,57.41 194.84,57.41 194.53,57.73 188.3,57.73 186.97,56.4 153.77,56.4 150.19,52.82 123.86,52.82 122.73,53.95 122.73,54.75 v2(122.39,55.08)
  BOTTOM w0.104: v3(233.78,70.56) 233.78,70.64 U2.E29 ; JSSD2.31 106.66,73.04 106.78,72.92 109.36,72.92 111.65,70.62 111.65,63.51 113.87,61.3 117.8,61.3 121.76,57.34 121.76,54.3 122.14,53.93 122.53,53.93 122.7,54.1 122.7,54.36 122.57,54.49 122.27,54.49 122.12,54.64 122.12,54.8 v2(122.39,55.08)
PCIE10_SSD2_TX_C_DN1: length 2
  BOTTOM w0.104: JSSD2.35 106.66,74.04 106.78,74.16 107.45,74.16 C199.1
PCIE10_SSD2_TX_C_DP1: length 2
  BOTTOM w0.104: C200.1 107.4,74.42 106.79,74.42 106.66,74.54 JSSD2.37
PCIE10_SSD2_TX_DN1: length 152.6
  IN05 w0.114: v2(112.26,63.83) 112.41,63.68 112.41,63.15 113.52,62.04 142.22,62.04 144.37,64.19 144.37,64.74 144.66,65.03 145.66,65.03 146.75,66.12 148.94,66.12 149.7,66.88 182.49,66.88 184.12,68.51 184.12,71.96 184.63,72.47 196.95,72.47 197.83,71.58 200.65,71.58 203.57,68.66 206.11,68.66 207.88,70.43 210.52,70.43 213.43,73.33 216.14,73.33 v3(216.25,73.22)
  BOTTOM w0.076: U2.C32 232.33,72.14 232.33,72.71 232.12,72.91 232.12,73.24 231.72,73.65 231.72,73.89 231.26,74.35 231.26,75.17 231.21,75.22 231.21,75.24
  BOTTOM w0.104: C199.2 108.58,73.94 108.58,74.15 108.72,74.29 109.28,74.29 112.62,70.95 v2(112.62,70.18) 112.62,64.19 v2(112.26,63.83) ; v3(216.25,73.22) 216.49,73.46 218.41,73.46 219.55,74.6 219.55,76.68 221.95,79.07 227.78,79.07 231.21,75.65 231.21,75.24
PCIE10_SSD2_TX_DP1: length 152.6
  IN05 w0.114: v2(113.08,63.83) 112.92,63.83 112.68,63.59 112.68,63.26 113.63,62.31 142.11,62.31 144.1,64.3 144.1,64.85 144.55,65.3 145.55,65.3 146.64,66.39 148.83,66.39 149.59,67.15 182.38,67.15 183.85,68.62 183.85,72.07 184.52,72.74 197.06,72.74 197.95,71.85 200.76,71.85 203.68,68.93 206,68.93 207.77,70.69 210.41,70.69 213.32,73.6 216.03,73.6 216.25,73.82 v3(216.25,74)
  BOTTOM w0.076: U2.B32 232.56,72.69 232.28,72.98 232.28,73.31 231.87,73.71 231.87,73.96 231.41,74.41 231.41,75.18 231.47,75.23 231.47,75.24
  BOTTOM w0.104: v3(216.25,74) 216.25,73.82 216.35,73.72 218.3,73.72 219.3,74.71 219.3,76.79 221.84,79.33 227.89,79.33 231.47,75.75 231.47,75.24 ; C200.2 108.87,74.54 109.38,74.54 112.87,71.05 112.87,64.04 v2(113.08,63.83)
PCIE11_SSD2_RX_DN2: length 159.4
  IN05 w0.076: 233.2,69.29 233.2,69.29 233.14,69.23 233.14,68.6 232.92,68.38 232.76,68.38 v3(232.53,68.15)
  IN05 w0.114: 233.2,69.29 233.2,69.42 233.33,69.55 233.33,71.4 232.77,71.96 232.69,71.96 229.56,75.09 224.97,75.09 221.86,71.98 221.86,65.66 221.09,64.89 221.09,64.6 213.28,56.79 188.39,56.79 186.61,55.01 153.26,55.01 150.41,52.16 122.34,52.16 120.45,54.05 120.45,54.88 v2(120.73,55.15)
  BOTTOM w0.104: U2.L31 232.64,68.05 v3(232.53,68.15) ; v2(120.73,55.15) 120.6,55.02 120.6,54.68 120.3,54.39 119.3,54.39 118.84,54.84 118.84,56.59 116.68,58.75 113.75,58.75 108.93,63.57 108.93,68.32 107.72,69.54 JSSD2.17
PCIE11_SSD2_RX_DP2: length 159.4
  IN05 w0.076: v3(232.53,68.91) 232.51,68.89 232.51,68.66 232.63,68.53 232.86,68.53 232.99,68.66 232.99,69.22 232.93,69.28 232.93,69.29
  IN05 w0.114: v2(119.91,55.15) 120.19,54.88 120.19,53.94 122.23,51.9 150.52,51.9 153.38,54.75 186.72,54.75 188.5,56.52 213.39,56.52 221.36,64.49 221.36,64.78 222.13,65.55 222.13,71.87 225.08,74.83 229.45,74.83 232.58,71.7 232.66,71.7 233.06,71.29 233.06,69.66 232.93,69.53 232.93,69.29
  BOTTOM w0.104: v2(119.91,55.15) 120.13,55.15 120.34,54.94 120.34,54.79 120.19,54.64 119.4,54.64 119.1,54.95 119.1,56.7 116.79,59.01 113.86,59.01 109.19,63.68 v2(109.19,65.99) 109.19,68.43 107.58,70.04 JSSD2.19 ; U2.K31 232.64,68.81 v3(232.53,68.91)
PCIE11_SSD2_TX_C_DN2: length 2
  BOTTOM w0.104: JSSD2.23 106.68,71.04 106.8,71.16 107.49,71.16 107.74,70.91 C201.1
PCIE11_SSD2_TX_C_DP2: length 2
  BOTTOM w0.104: JSSD2.25 106.67,71.54 106.79,71.42 107.32,71.42 C202.1
PCIE11_SSD2_TX_DN2: length 145.8
  IN05 w0.114: v3(216.25,71.25) 216.15,71.35 214.62,71.35 210.41,67.14 186.4,67.14 185.19,65.92 150.14,65.92 149.45,65.23 147.12,65.23 146.65,64.77 146.65,63.2 144.61,61.15 111.1,61.15 110.12,62.13 110.12,63.46 v2(109.95,63.63)
  BOTTOM w0.076: 230.23,75.37 230.24,75.37 230.31,75.37 230.47,75.2 230.47,74.63 230.72,74.38 231.34,73.77 231.34,73.49 231.67,73.16 231.67,72.45 U2.C33
  BOTTOM w0.104: v3(216.25,71.25) 216.25,71.26 216.42,71.43 218.11,71.43 220.34,73.66 220.34,75.55 222.98,78.18 227.42,78.18 230.23,75.37 ; C201.2 108.61,70.86 108.61,71.21 108.78,71.38 109.14,71.38 110.2,70.31 v2(110.2,68.28) 110.2,63.89 v2(109.95,63.63)
PCIE11_SSD2_TX_DP2: length 145.8
  IN05 w0.114: v3(216.25,72.04) 216.25,71.83 216.03,71.62 214.51,71.62 210.3,67.4 186.29,67.4 185.08,66.19 150.03,66.19 149.34,65.5 147.01,65.5 146.39,64.88 146.39,63.31 144.5,61.42 111.21,61.42 110.39,62.24 110.39,63.41 110.61,63.63 v2(110.76,63.63)
  BOTTOM w0.076: 230.41,75.55 230.42,75.54 230.42,75.47 230.49,75.4 230.63,75.26 230.63,74.69 230.83,74.49 231.49,73.83 231.49,73.55 231.82,73.22 231.82,72.7 231.94,72.58 U2.B33
  BOTTOM w0.104: v3(216.25,72.04) 216.25,71.83 216.4,71.68 218,71.68 220.09,73.77 220.09,75.65 222.87,78.44 227.52,78.44 230.41,75.55 ; v2(110.76,63.63) 110.46,63.93 110.46,70.42 109.24,71.63 108.86,71.63 C202.2
PCIE12_SSD2_RX_DN3: length 154.8
  IN05 w0.114: v2(116.41,55.17) 116.66,55.17 116.76,55.07 116.76,54.89 116.53,54.66 116.19,54.66 116.01,54.49 116.01,53.2 118.89,50.32 151.11,50.32 153.26,52.47 186.59,52.47 189.13,55.01 214.47,55.01 220.64,61.18 220.94,61.18 223.39,63.63 223.39,70.97 225.04,72.62 229.08,72.62 229.77,71.93 230.77,71.93 231.27,71.43 231.27,70.73 231.36,70.64 231.57,70.64 v3(231.62,70.69)
  BOTTOM w0.104: v2(116.41,55.17) 116.29,55.05 116.29,54.19 115.97,53.88 114.97,53.88 112.49,56.36 112.49,58.63 107.46,63.66 107.46,66.35 107.15,66.66 106.78,66.66 106.66,66.54 JSSD2.5 ; v3(231.62,70.69) 232.12,70.19 U2.G33
PCIE12_SSD2_RX_DP3: length 154.8
  IN05 w0.114: v2(115.59,55.17) 115.74,55.02 115.74,53.09 118.78,50.06 151.22,50.06 153.38,52.21 186.7,52.21 189.24,54.75 214.58,54.75 220.75,60.91 221.05,60.91 223.65,63.52 223.65,70.86 225.15,72.35 228.97,72.35 229.65,71.66 230.66,71.66 231.01,71.32 231.01,70.59 231.62,69.98 v3(231.62,69.85)
  BOTTOM w0.104: v3(231.62,69.85) 231.62,69.8 232,69.41 U2.H33 ; v2(115.59,55.17) 115.44,55.02 115.44,54.79 115.61,54.61 115.93,54.61 116.03,54.51 116.03,54.3 115.87,54.13 115.08,54.13 112.74,56.47 v2(112.74,57.74) 112.74,58.74 107.72,63.76 107.72,66.46 107.25,66.92 106.78,66.92 106.66,67.04 JSSD2.7
PCIE12_SSD2_TX_C_DN3: length 14.6
  BOTTOM w0.104: JSSD2.11 105.25,68.04 105.13,68.16 103.59,68.16 103.35,67.92 103.35,63.94 104.22,63.07 107.27,63.07 v2(108.08,62.26) 108.89,61.45 108.89,60.69 108.95,60.62 109.18,60.62 109.29,60.73 C203.1
PCIE12_SSD2_TX_C_DP3: length 14.5
  BOTTOM w0.104: C204.1 108.63,60.94 108.63,61.34 107.16,62.82 104.11,62.82 103.09,63.83 103.09,68.02 103.49,68.42 105.12,68.42 105.24,68.54 JSSD2.13
PCIE12_SSD2_TX_DN3: length 137.5
  IN05 w0.114: v3(216.25,69.67) 216.25,69.8 216,70.05 214.97,70.05 211.17,66.25 186.79,66.25 185.57,65.03 150.9,65.03 150.6,64.74 150.6,64.36 149.71,63.47 149.71,62.83 148.19,61.31 148.19,60.17 147.79,59.77 134.85,59.77 134.35,60.27 109.81,60.27 108.85,59.3 108.85,59.14 109.07,58.92 v2(109.28,58.92)
  BOTTOM w0.076: 226.95,77.29 226.97,77.29 227.02,77.35 227.18,77.35 230.96,73.57 230.96,72.97 U2.B35
  BOTTOM w0.104: v3(216.25,69.67) 216.4,69.82 217.92,69.82 v2(220.71,72.61) 221.08,72.98 221.08,75.01 223.36,77.29 226.95,77.29 ; C203.2 109.3,59.82 109,59.52 109,59.2 v2(109.28,58.92)
PCIE12_SSD2_TX_DP3: length 137.5
  IN05 w0.114: v3(216.25,70.45) 216.12,70.31 214.86,70.31 211.06,66.51 186.68,66.51 185.46,65.3 150.79,65.3 150.34,64.85 150.34,64.47 149.45,63.58 149.45,62.94 147.92,61.42 147.92,60.28 147.68,60.04 134.96,60.04 134.46,60.53 109.7,60.53 108.58,59.41 108.58,59.04 v2(108.46,58.92)
  BOTTOM w0.076: U2.A35 231.22,73 231.11,73.1 231.11,73.64 227.25,77.5 227.02,77.5 226.97,77.55 226.95,77.55
  BOTTOM w0.104: v3(216.25,70.45) 216.25,70.32 216.49,70.08 217.81,70.08 220.82,73.08 220.82,75.12 223.25,77.55 226.95,77.55 ; v2(108.46,58.92) 108.74,59.2 108.74,59.52 108.44,59.82 C204.2
PCIE13_SSD1_RX_DN0: length 173.5
  IN05 w0.114: v2(103.35,50.8) 103.17,50.63 101.54,50.63 99.38,48.47 99.38,39.86 101.96,37.28 109.83,37.28 118.71,46.16 152.55,46.16 153.71,47.32 172.18,47.32 173,48.14 187.79,48.14 189.76,50.12 217.77,50.12 220.81,53.15 222.46,53.15 223.12,53.82 223.12,54.83 223.57,55.29 225.61,55.29 228.07,57.75 228.07,61.15 227.53,61.7 227.53,64.7 228.16,65.33 228.16,67.01 229.58,68.43 229.58,69.68 229.96,70.05 230.52,70.05 v3(230.57,70.01)
  BOTTOM w0.104: JSSD1.41 105.27,51.17 105.02,51.41 102.58,51.41 102.43,51.26 102.43,50.59 102.7,50.33 102.83,50.33 102.97,50.46 102.97,50.56 102.86,50.66 102.86,50.89 102.99,51.02 103.12,51.02 v2(103.35,50.8) ; U2.G35 230.8,70.34 230.57,70.1 v3(230.57,70.01)
PCIE13_SSD1_RX_DP0: length 173.5
  IN05 w0.114: v3(230.57,70.64) 230.57,70.74 230.49,70.82 230.25,70.82 230.18,70.74 230.18,70.39 230.1,70.31 229.85,70.31 229.32,69.79 229.32,68.54 227.9,67.12 227.9,65.44 227.26,64.81 227.26,61.59 227.81,61.04 227.81,57.86 225.5,55.55 223.46,55.55 222.85,54.94 222.85,53.93 222.35,53.42 220.69,53.42 217.66,50.38 189.65,50.38 187.68,48.41 172.89,48.41 172.07,47.59 153.6,47.59 152.44,46.43 118.6,46.43 109.71,37.54 102.07,37.54 99.65,39.97 99.65,48.36 101.65,50.36 103.31,50.36 103.42,50.24 103.42,50.04 v2(103.35,49.97)
  BOTTOM w0.104: U2.E35 230.67,70.64 v3(230.57,70.64) ; JSSD1.43 102.48,51.67 102.18,51.37 102.18,50.48 102.69,49.97 v2(103.35,49.97)
PCIE13_SSD1_TX_C_DN0: length 2.8
  BOTTOM w0.104: JSSD1.47 106.68,52.67 106.81,52.79 107.26,52.79 107.64,52.41 108.07,52.41 C189.1
PCIE13_SSD1_TX_C_DP0: length 2.9
  BOTTOM w0.104: JSSD1.49 106.69,53.17 106.81,53.05 107.36,53.05 107.75,52.66 108.1,52.66 108.45,53.02 C190.1
PCIE13_SSD1_TX_DN0: length 140
  IN05 w0.114: v2(110.05,52.03) 110.42,52.39 111.08,52.39 111.87,53.18 111.87,56.99 113.76,58.88 127.42,58.88 127.7,59.16 129.1,59.16 129.37,58.88 148.16,58.88 149.7,60.42 149.7,61.04 151.1,62.44 185.39,62.44 186.28,63.33 186.28,64.39 187.24,65.36 212.25,65.36 215.03,68.14 215.88,68.14 v3(216.25,67.77)
  BOTTOM w0.076: U2.C36 230.55,72.43 230.55,72.8 230.63,72.88 230.63,73.35 230.1,73.87 229.95,74.02 229.81,74.02 227.37,76.46 227.17,76.46 227.11,76.41 227.1,76.41
  BOTTOM w0.104: C189.2 109.72,52.38 109.93,52.38 110.05,52.25 v2(110.05,52.03) ; v3(216.25,67.77) 216.43,67.95 217.32,67.95 219.55,70.18 220.44,70.18 v2(221.31,71.05) 221.51,71.25 221.51,71.9 221.96,72.36 221.96,74.63 223.74,76.41 227.1,76.41
PCIE13_SSD1_TX_DP0: length 139.9
  IN05 w0.114: v3(216.25,68.79) 215.87,68.41 214.92,68.41 212.14,65.62 187.13,65.62 186.01,64.5 186.01,63.44 185.28,62.7 150.99,62.7 149.44,61.15 149.44,60.53 148.05,59.15 129.48,59.15 129.21,59.42 127.59,59.42 127.31,59.15 113.65,59.15 111.6,57.1 111.6,53.29 110.97,52.66 110.44,52.66 v2(110.05,53.04)
  BOTTOM w0.076: 227.1,76.66 227.11,76.66 227.17,76.61 227.44,76.61 229.88,74.17 230.02,74.17 230.21,73.98 230.78,73.41 230.78,72.62 U2.B36
  BOTTOM w0.104: C190.2 109.7,52.71 109.95,52.71 110.05,52.81 v2(110.05,53.04) ; 227.1,76.66 223.64,76.66 221.71,74.74 221.71,72.47 221.25,72.01 221.25,71.36 220.33,70.44 219.45,70.44 217.21,68.21 216.45,68.21 216.25,68.41 v3(216.25,68.79)
PCIE14_SSD1_RX_DN1: length 161.1
  IN05 w0.076: v3(228.92,71.45) 228.92,71.53 228.85,71.6 228.63,71.6 228.56,71.53 228.56,70.43 228.42,70.29 228.42,69.97 227.36,68.91 227.26,68.91 227.21,68.97 227.2,68.97
  IN05 w0.114: v2(103.07,47.55) 102.79,47.84 102.29,47.84 101.58,47.13 101.58,41.57 104.71,38.43 109.29,38.43 118.2,47.34 151.9,47.34 153.86,49.3 187.31,49.3 189.89,51.88 216.88,51.88 218.92,53.93 219.94,53.93 221.22,55.21 221.47,55.21 222.59,56.32 222.59,56.96 224.27,58.64 225.41,58.64 226.38,59.61 226.38,65.15 226.85,65.62 226.85,66.87 226.63,67.1 226.63,68.63 226.97,68.97 227.2,68.97
  BOTTOM w0.104: v2(103.07,47.55) 103.41,47.89 104.14,47.89 104.49,48.24 105.18,48.24 105.25,48.17 JSSD1.29 ; U2.D39 229.47,71.42 229.57,71.52 229.57,71.7 229.46,71.8 229.05,71.8 228.92,71.67 v3(228.92,71.45)
PCIE14_SSD1_RX_DP1: length 161.1
  IN05 w0.076: v3(228.92,70.82) 228.71,70.6 228.71,70.36 228.57,70.22 228.57,69.9 227.43,68.76 227.26,68.76 227.21,68.7 227.2,68.7
  IN05 w0.114: v2(103.07,48.38) 102.79,48.1 102.18,48.1 101.31,47.24 101.31,41.46 104.6,38.17 109.4,38.17 118.31,47.07 152.01,47.07 153.97,49.03 187.42,49.03 190.01,51.62 216.99,51.62 219.03,53.66 220.05,53.66 221.33,54.94 221.58,54.94 222.85,56.21 222.85,56.85 224.38,58.37 225.52,58.37 226.65,59.5 226.65,65.04 227.12,65.51 227.12,66.98 226.9,67.21 226.9,68.52 227.08,68.7 227.2,68.7
  BOTTOM w0.104: U2.E37 229.71,70.82 v3(228.92,70.82) ; JSSD1.31 105.26,48.67 105.09,48.5 104.38,48.5 104.03,48.15 103.3,48.15 v2(103.07,48.38)
PCIE14_SSD1_TX_C_DN1: length 2.7
  BOTTOM w0.104: JSSD1.35 106.69,49.67 106.81,49.79 107.56,49.79 107.64,49.87 108.07,49.87 C191.1
PCIE14_SSD1_TX_C_DP1: length 2.7
  BOTTOM w0.104: JSSD1.37 106.69,50.17 106.81,50.05 107.46,50.05 107.53,50.12 108.07,50.12 C192.1
PCIE14_SSD1_TX_DN1: length 145.3
  IN05 w0.114: v3(216.25,66.88) 216.35,66.88 216.48,66.75 216.48,66.42 216.35,66.29 214.06,66.29 211.61,63.83 202.41,63.83 201.04,62.46 186.43,62.46 185.53,61.56 153.42,61.56 152.96,61.11 152.95,61.11 150.1,58.26 129.21,58.26 128.98,58.03 128.01,58.03 127.79,58.26 114.54,58.26 112.87,56.6 112.87,50.24 111.35,48.72 108.68,48.72 108.55,48.85 108.55,49.75 108.67,49.86 109.77,49.86 110.05,49.58 v2(110.05,49.49)
  BOTTOM w0.076: 227.01,75.85 227.02,75.85 227.07,75.8 227.53,75.8 229.58,73.74 229.58,73.32 229.71,73.19 229.71,72.68 U2.B38
  BOTTOM w0.104: v2(110.05,49.49) 110.05,49.71 109.93,49.84 109.72,49.84 C191.2 ; 227.01,75.85 224.09,75.85 222.6,74.35 222.6,72.11 222.17,71.68 222.17,70.75 221.02,69.6 219.98,69.6 216.76,66.38 216.4,66.38 216.25,66.53 v3(216.25,66.88)
PCIE14_SSD1_TX_DP1: length 145.3
  IN05 w0.114: v3(216.25,65.87) 216.09,66.03 214.17,66.03 211.72,63.57 202.52,63.57 201.15,62.2 186.54,62.2 185.64,61.29 153.53,61.29 153.07,60.84 153.06,60.84 150.21,57.99 129.32,57.99 129.09,57.76 127.9,57.76 127.67,57.99 114.65,57.99 113.14,56.48 113.14,50.13 111.46,48.45 108.57,48.45 108.29,48.74 108.29,49.86 108.56,50.13 109.68,50.13 v2(110.05,50.5)
  BOTTOM w0.076: 227.01,75.59 227.02,75.59 227.07,75.64 227.46,75.64 229.43,73.68 229.43,73.26 229.56,73.13 229.56,72.32 U2.C38
  BOTTOM w0.104: C192.2 109.7,50.17 109.95,50.17 110.05,50.27 v2(110.05,50.5) ; 227.01,75.59 224.2,75.59 222.85,74.25 222.85,72.01 222.42,71.58 222.42,70.64 221.12,69.34 v2(220.69,69.34) 220.09,69.34 216.79,66.04 216.42,66.04 v3(216.25,65.87)
PCIE15_SSD1_RX_DN2: length 153.4
  IN05 w0.076: v3(228.01,70.92) 228.1,70.83 228.1,70.71 227.96,70.56 227.96,70.17 227.51,69.73 226.95,69.73 226.9,69.78 226.89,69.78
  IN05 w0.114: v2(104.08,44.89) 104.29,44.69 104.29,44.43 104.21,44.35 103.7,44.35 103.61,44.44 103.61,45.28 103.44,45.45 103.18,45.45 102.98,45.24 102.98,44.59 103.09,44.48 103.09,44.02 102.98,43.9 102.98,43.45 103.09,43.33 103.09,42.88 102.98,42.76 102.98,41.62 105.27,39.32 108.91,39.32 117.93,48.34 151.65,48.34 153.75,50.44 187.19,50.44 189.67,52.91 215.61,52.91 218.28,55.58 219.81,55.58 223.27,59.05 223.27,61 225.27,63 225.27,65.18 225.69,65.6 225.69,65.88 225.52,66.04 225.52,66.63 225.83,66.93 225.83,68.92 226.69,69.78 226.89,69.78
  BOTTOM w0.104: v3(228.01,70.92) 228.35,70.92 228.44,70.83 U2.F41 ; v2(104.08,44.89) 104.43,45.23 105.15,45.23 105.21,45.17 JSSD1.17
PCIE15_SSD1_RX_DP2: length 153.3
  IN05 w0.076: 226.89,69.52 226.91,69.52 226.96,69.57 227.58,69.57 228.11,70.11 228.11,70.5 228.38,70.77 228.38,71.16 v3(228.01,71.53)
  IN05 w0.114: 226.89,69.52 226.8,69.52 226.09,68.81 226.09,66.82 225.79,66.52 225.79,66.15 225.95,65.99 225.95,65.48 225.53,65.07 225.53,62.89 223.54,60.89 223.54,58.94 219.92,55.31 218.39,55.31 215.73,52.65 189.78,52.65 187.31,50.17 153.86,50.17 151.76,48.07 118.04,48.07 109.02,39.06 105.16,39.06 102.71,41.51 102.71,45.36 103.07,45.72 v2(104.08,45.72)
  BOTTOM w0.104: JSSD1.19 105.26,45.67 105.08,45.49 104.31,45.49 v2(104.08,45.72) ; U2.E41 228.26,71.28 v3(228.01,71.53)
PCIE15_SSD1_TX_C_DN2: length 2.7
  BOTTOM w0.104: C193.1 108.07,46.69 107.64,46.69 107.54,46.79 106.81,46.79 106.68,46.67 JSSD1.23
PCIE15_SSD1_TX_C_DP2: length 2.7
  BOTTOM w0.104: C194.1 108.07,46.95 107.75,46.95 107.65,47.05 106.81,47.05 106.69,47.17 JSSD1.25
PCIE15_SSD1_TX_DN2: length 141.3
  IN05 w0.114: v2(110.05,46.31) 110.47,46.73 112.26,46.73 114.15,48.62 114.15,56.23 114.9,56.98 127.25,56.98 127.85,56.38 129.39,56.38 129.99,56.98 150.57,56.98 153.24,59.64 185.39,59.64 187.05,61.31 195.27,61.31 195.73,60.84 201.06,60.84 202.64,62.42 211.97,62.42 213.89,64.34 214.09,64.34 v3(214.47,63.96)
  BOTTOM w0.076: 226.64,74.86 226.66,74.86 226.71,74.91 227.53,74.91 229.05,73.38 229.05,72.7 U2.B39
  BOTTOM w0.104: 226.64,74.86 224.73,74.86 223.74,73.87 223.74,71.47 223.36,71.09 223.36,69.95 221.42,68 v2(220.69,68) 220.02,68 216.21,64.19 214.71,64.19 v3(214.47,63.96) ; v2(110.05,46.31) 110.05,46.54 109.93,46.66 109.72,46.66 C193.2
PCIE15_SSD1_TX_DP2: length 141.3
  IN05 w0.114: v2(110.05,47.33) 110.05,47.25 110.31,47 112.15,47 113.89,48.73 113.89,56.34 114.79,57.24 127.36,57.24 127.96,56.64 129.28,56.64 129.88,57.24 150.46,57.24 153.13,59.91 185.28,59.91 186.94,61.57 195.38,61.57 195.84,61.11 200.95,61.11 202.53,62.69 211.86,62.69 213.78,64.61 214.1,64.61 v3(214.47,64.98)
  BOTTOM w0.076: 226.64,75.11 226.66,75.11 226.71,75.06 227.59,75.06 229.2,73.45 229.2,73.1 U2.A39
  BOTTOM w0.104: C194.2 109.7,46.99 109.95,46.99 110.05,47.1 v2(110.05,47.33) ; 226.64,75.11 224.63,75.11 223.49,73.97 223.49,71.58 223.11,71.2 223.11,70.06 221.31,68.26 219.91,68.26 216.1,64.45 214.71,64.45 214.47,64.68 v3(214.47,64.98)
PCIE16_SSD1_RX_DN3: length 144.3
  IN05 w0.114: v3(226.87,71.1) 227.04,71.28 227.04,71.48 226.92,71.61 226.56,71.61 226.44,71.48 226.44,70.66 224.57,68.8 224.57,63.55 222.41,61.39 222.41,60.34 221.98,59.91 221.35,59.91 220.56,59.12 220.56,57.59 219.57,56.61 217.32,56.61 214.84,54.12 189.49,54.12 186.95,51.58 153.63,51.58 151.4,49.36 117.67,49.36 109.16,40.85 106.99,40.85 106.56,41.27 106.56,41.78 107.07,42.28 107.96,42.28 108.12,42.12 v2(108.12,42.01)
  BOTTOM w0.104: v2(108.12,42.01) 107.84,42.29 106.81,42.29 106.69,42.17 JSSD1.5 ; v3(226.87,71.1) 227.1,71.33 227.1,71.47 U2.D43
PCIE16_SSD1_RX_DP3: length 144.3
  IN05 w0.114: v2(108.12,42.83) 107.84,42.55 106.96,42.55 106.3,41.89 106.3,41.16 106.87,40.58 109.27,40.58 117.78,49.09 151.51,49.09 153.74,51.32 187.06,51.32 189.6,53.86 214.95,53.86 217.43,56.34 219.68,56.34 220.82,57.48 220.82,59.01 221.46,59.64 222.09,59.64 222.68,60.23 222.68,61.28 224.83,63.44 224.83,68.69 226.82,70.67 227.27,70.67 v3(227.43,70.82)
  BOTTOM w0.104: v2(108.12,42.83) 107.84,42.55 106.8,42.55 106.68,42.67 JSSD1.7 ; U2.E42 227.6,71 v3(227.43,70.82)
PCIE16_SSD1_TX_C_DN3: length 2.8
  BOTTOM w0.104: JSSD1.11 106.69,43.67 106.81,43.79 107.23,43.79 107.59,44.15 108.07,44.15 C195.1
PCIE16_SSD1_TX_C_DP3: length 2.8
  BOTTOM w0.104: C196.1 108.07,44.41 107.48,44.41 107.13,44.05 106.81,44.05 106.68,44.17 JSSD1.13
PCIE16_SSD1_TX_DN3: length 141.9
  IN05 w0.114: v2(110.05,43.77) 110.05,43.86 110.33,44.14 111.23,44.14 115.04,47.95 115.04,55.6 115.41,55.96 126.29,55.96 126.85,55.4 130.72,55.4 131.28,55.96 150.82,55.96 153.1,58.25 186.15,58.25 187.41,59.5 192.25,59.5 193.16,60.42 194.5,60.42 195.72,59.19 209.96,59.19 210.66,59.9 211.71,59.9 211.93,59.67 v3(211.93,59.52)
  BOTTOM w0.076: U2.A41 228.41,73 228.49,73.07 228.49,73.22 227.44,74.27 225.72,74.27 225.67,74.22 225.65,74.22
  BOTTOM w0.104: C195.2 109.72,44.12 109.93,44.12 110.05,44 v2(110.05,43.77) ; 225.65,74.22 225.37,74.22 224.63,73.49 224.63,71.14 224.28,70.79 224.28,69.07 221.96,66.75 v2(221.08,66.75) 220.04,66.75 213.18,59.9 212.15,59.9 211.93,59.68 v3(211.93,59.52)
PCIE16_SSD1_TX_DP3: length 141.9
  IN05 w0.114: v2(110.05,44.79) 110.44,44.4 111.12,44.4 114.78,48.06 114.78,55.71 115.3,56.23 126.4,56.23 126.96,55.66 130.6,55.66 131.17,56.23 150.71,56.23 152.99,58.51 186.04,58.51 187.3,59.77 192.14,59.77 193.05,60.68 194.61,60.68 195.83,59.46 209.85,59.46 210.55,60.16 211.8,60.16 211.93,60.29 v3(211.93,60.53)
  BOTTOM w0.076: 225.65,74.48 225.66,74.48 225.71,74.43 227.5,74.43 228.64,73.29 228.64,73.1 U2.A40
  BOTTOM w0.104: v2(110.05,44.79) 110.05,44.56 109.95,44.45 109.7,44.45 C196.2 ; 225.65,74.48 225.26,74.48 224.38,73.59 224.38,71.25 224.02,70.89 224.02,69.18 221.86,67.01 219.94,67.01 214.83,61.91 213.08,60.15 212.31,60.15 v3(211.93,60.53)
PCIE_AR_RST_N: length 16.7
  TOP w0.097: R2101.1 v2(61.82,92.03)
  IN03 w0.091: v2(61.82,92.03) 61.82,91.77 58.77,88.73 56.61,88.73 55.34,90 55.34,90.5 54.83,91.01 50.79,91.01 50.29,90.5 50.29,90 v1(49.92,89.63)
  BOTTOM w0.178: U2005.L4 v1(49.92,89.63)
PCIE_CR_RX_DN: length 94
  IN10 w0.114: v2(290.54,43.58) 290.23,43.89 289.16,43.89 287.94,45.12 287.94,50.69 287.38,51.25 286.11,51.25 283.19,54.17 281.66,54.17 276.58,59.25 267.96,59.25 266.56,60.65 263.73,60.65 261.67,58.59 258.59,58.59 257.78,59.39 254.87,59.39 254.59,59.67 249.75,59.67 249.4,60.02 247.7,60.02 246.33,61.4 244.6,61.4 244.32,61.67 237.2,61.67 236.56,62.32 236.56,67.12 237.77,68.33 237.77,70.44 237.65,70.56 237.46,70.56 v3(237.33,70.44)
  BOTTOM w0.104: v3(237.33,70.44) 237.5,70.61 237.62,70.61 U2.G22 ; v2(290.54,43.58) 290.81,43.84 293.65,43.84 293.95,44.15 296.36,44.15 298.45,42.06 298.45,37.59 299.03,37.01 299.03,36.06 300.31,34.78 JIO1.24
PCIE_CR_RX_DP: length 94
  IN10 w0.114: v3(237.33,71.05) 237.55,70.83 237.76,70.83 238.04,70.55 238.04,68.22 236.82,67.01 236.82,62.43 237.32,61.94 244.43,61.94 244.71,61.66 246.44,61.66 247.81,60.29 249.51,60.29 249.86,59.94 254.7,59.94 254.98,59.66 257.89,59.66 258.7,58.85 261.56,58.85 263.62,60.91 266.67,60.91 268.07,59.52 276.69,59.52 281.77,54.44 283.3,54.44 286.22,51.51 287.49,51.51 288.2,50.8 288.2,45.23 289.27,44.16 290.32,44.16 v2(290.54,44.39)
  BOTTOM w0.104: v3(237.33,71.05) 237.51,70.87 237.62,70.87 U2.E22 ; v2(290.54,44.39) 290.54,44.29 290.74,44.1 293.54,44.1 293.85,44.4 296.46,44.4 298.7,42.16 298.7,37.69 299.28,37.11 299.28,36.17 300.27,35.18 JIO1.23
PCIE_CR_TX_C_DN: length 12.4
  BOTTOM w0.104: C181.1 299.61,47.14 299.61,46.89 299.46,46.74 299.46,37.82 299.82,37.46 299.82,36.47 300.31,35.98 JIO1.21
PCIE_CR_TX_C_DP: length 12.4
  BOTTOM w0.104: JIO1.20 300.27,36.38 300.08,36.58 300.08,37.57 299.72,37.92 299.72,38.15 299.85,38.28 299.85,38.51 299.72,38.64 299.72,38.87 299.85,39 299.85,39.23 299.72,39.35 299.72,39.59 299.85,39.71 299.85,39.94 299.72,40.07 299.72,45.03 299.82,45.14 299.82,45.42 299.72,45.52 299.72,45.75 299.82,45.85 299.82,46.13 299.72,46.24 299.72,46.64 299.86,46.78 299.86,47.14 C182.1
PCIE_CR_TX_DN: length 95
  IN10 w0.114: v2(243.3,76.58) 243.47,76.42 243.47,75.76 243.24,75.53 242.68,75.53 242.25,75.09 242.25,73.19 243.89,71.54 243.89,70.36 245.71,68.54 247.08,68.54 248.43,67.19 248.43,64.51 249.46,63.49 253.75,63.49 254.6,64.34 254.6,64.98 256.24,66.62 263.99,66.62 266.03,68.66 279.11,68.66 280.32,67.46 280.32,63.58 281.73,62.17 285.86,62.17 289.66,58.37 290.67,58.37 292.88,56.16 292.88,54.61 296.98,50.52 299.16,50.52 299.66,50.03 299.66,49.57 299.38,49.29 v2(299.33,49.29)
  BOTTOM w0.076: U2.B22 237.43,72.77 237.43,73.68 237.36,73.75 237.36,74.91 237.97,75.52 237.97,75.83 238.02,75.88 238.02,75.9
  BOTTOM w0.104: v2(299.33,49.29) 299.61,49.01 299.61,48.68 C181.2 ; v2(243.3,76.58) 243.36,76.58 243.61,76.83 243.61,76.97 243.45,77.13 243.07,77.13 242.93,76.99 242.66,76.99 242.51,77.13 242.25,77.13 242.11,76.99 241.84,76.99 241.69,77.13 240.78,77.13 240.57,77.34 238.27,77.34 238.02,77.09 238.02,75.9
PCIE_CR_TX_DP: length 95
  IN10 w0.114: v2(243.94,76.58) 243.84,76.58 243.74,76.48 243.74,75.65 243.35,75.26 242.79,75.26 242.51,74.98 242.51,73.3 244.16,71.65 244.16,70.47 245.82,68.81 247.19,68.81 248.05,67.95 248.7,67.3 248.7,64.62 249.57,63.76 253.64,63.76 254.34,64.45 254.34,65.09 256.13,66.88 263.88,66.88 265.92,68.93 279.23,68.93 280.58,67.57 280.58,63.69 281.84,62.44 285.97,62.44 289.77,58.64 290.78,58.64 293.15,56.27 293.15,54.72 297.09,50.79 299.28,50.79 299.92,50.14 299.92,49.52 v2(300.15,49.29)
  BOTTOM w0.076: U2.A23 237.28,73.06 237.28,73.62 237.2,73.69 237.2,74.97 237.81,75.58 237.81,75.84 237.76,75.89 237.76,75.9
  BOTTOM w0.104: v2(300.15,49.29) 299.86,49.01 299.86,48.68 C182.2 ; 237.76,75.9 237.76,77.2 238.16,77.6 240.67,77.6 240.88,77.39 243.55,77.39 243.86,77.08 243.86,76.66 v2(243.94,76.58)
PCIE_LAN_RX_C_DN: length 2.3
  TOP w0.104: U6.29 48.36,59.41 48.43,59.34 48.43,59.08 48.1,58.75 48.1,58.45 C274.2
PCIE_LAN_RX_C_DP: length 2.3
  TOP w0.104: C275.2 48.36,58.45 48.36,58.65 48.69,58.98 48.69,59.34 48.76,59.41 U6.30
PCIE_LAN_RX_DN: length 208.1
  TOP w0.104: C274.1 48.01,56.87 48.01,56.56 48.36,56.21 51.64,56.21 52.66,57.23 54.76,57.23 v2(55.13,57.61) 56.59,59.06 56.59,60.78 v2(56.79,60.99)
  IN03 w0.114: v3(236.16,69.22) 236.16,69 236.02,68.87 235.55,68.87 235.26,68.58 235.26,66.97 233.81,65.52 233.81,64.25 233.64,64.08 227.29,64.08 226.68,63.47 225.16,63.47 224.39,62.7 223.51,62.7 221.98,61.18 214.2,61.18 209.9,65.48 128.37,65.48 126.97,66.88 117.69,66.88 116.54,68.04 111.84,68.04 110.07,69.8 106.65,69.8 105.9,69.05 90.03,69.05 84.19,63.21 72.72,63.21 70.56,65.37 62.09,65.37 57.12,60.4 56.62,60.4 56.39,60.63 56.39,60.82 56.56,60.99 v2(56.79,60.99)
  BOTTOM w0.104: U2.K24 v3(236.16,69.22)
PCIE_LAN_RX_DP: length 208.1
  TOP w0.104: v2(55.97,60.99) 56.22,60.99 56.33,60.88 56.33,59.16 v2(56.01,58.85) 54.65,57.49 52.55,57.49 51.53,56.47 48.46,56.47 48.26,56.67 48.26,57.3 48.34,57.38 48.51,57.38 C275.1
  IN03 w0.114: v2(55.97,60.99) 56.12,60.84 56.12,60.52 56.51,60.13 57.23,60.13 62.2,65.1 70.45,65.1 72.61,62.94 84.3,62.94 90.14,68.79 106.01,68.79 106.76,69.54 109.96,69.54 111.73,67.77 116.43,67.77 117.58,66.62 126.86,66.62 128.26,65.22 209.79,65.22 214.09,60.91 222.09,60.91 223.62,62.44 224.5,62.44 225.27,63.2 226.79,63.2 227.4,63.81 233.75,63.81 234.08,64.14 234.08,65.41 235.53,66.86 235.53,68.47 235.66,68.6 236.01,68.6 v3(236.16,68.45)
  BOTTOM w0.104: U2.L24 v3(236.16,68.45)
PCIE_LAN_TX_C_DN: length 2.5
  TOP w0.104: U6.36 50.12,62.89 50.19,62.82 51.05,62.82 51.27,62.6 51.49,62.6 C185.1
PCIE_LAN_TX_C_DP: length 2.5
  TOP w0.104: C186.1 51.52,62.34 51.16,62.34 50.94,62.56 50.19,62.56 50.12,62.49 U6.35
PCIE_LAN_TX_DN: length 244.5
  TOP w0.104: v2(82.14,57.61) 81.89,57.36 81.23,57.36 79.38,59.21 76.39,59.21 75.55,58.38 73.76,58.38 72.86,57.48 72.86,56.83 70.09,54.06 62.18,54.06 59.66,56.58 59.66,61.12 58.16,62.62 53.03,62.62 C185.2
  IN05 w0.114: v2(82.14,57.61) 82.27,57.48 83.28,57.48 84.66,56.1 88.63,56.1 90.16,57.62 92.95,57.62 95.24,59.91 95.87,59.91 96.48,60.52 96.48,61.91 97.24,62.68 98,62.68 99.42,64.1 99.42,65.47 100.67,66.71 100.67,68.14 104,71.47 105.05,71.47 106.32,72.74 109.59,72.74 110.09,73.24 113.65,73.24 114.41,74.01 119.97,74.01 120.22,73.75 125.02,73.75 128.35,77.07 128.82,77.07 130.96,79.21 133.97,79.21 135.74,80.99 142.1,80.99 142.96,81.85 142.96,86.01 144.16,87.21 145.53,87.21 146.8,88.48 194.04,88.48 194.39,88.84 194.39,90.11 195.75,91.46 203.37,91.46 203.93,90.9 210.52,90.9 212.06,89.36 212.06,87.84 213.58,86.31 237.46,86.31 243.96,79.82 243.96,79.21 v2(244.09,79.07)
  BOTTOM w0.076: U2.C24 236.3,72.36 236.3,75.85 236.25,75.91 236.25,75.92
  BOTTOM w0.104: v2(244.09,79.07) 243.88,79.28 243.88,79.49 243.44,79.93 236.98,79.93 236.25,79.21 236.25,75.92
PCIE_LAN_TX_DP: length 244.5
  TOP w0.104: C186.2 53.03,62.36 58.06,62.36 59.4,61.02 59.4,56.47 62.07,53.8 70.2,53.8 73.12,56.72 73.12,57.37 73.86,58.12 75.66,58.12 76.5,58.95 79.27,58.95 81.12,57.1 81.88,57.1 v2(82.14,56.85)
  IN05 w0.114: v2(82.14,56.85) 82.14,57 82.35,57.21 83.17,57.21 84.55,55.83 88.74,55.83 90.27,57.36 93.06,57.36 95.35,59.64 95.98,59.64 96.74,60.4 96.74,61.8 97.35,62.41 98.11,62.41 99.69,63.99 99.69,65.36 100.93,66.6 100.93,68.02 104.11,71.2 105.16,71.2 106.43,72.47 109.7,72.47 110.2,72.98 113.76,72.98 114.52,73.74 119.86,73.74 120.11,73.49 125.13,73.49 128.46,76.81 128.93,76.81 131.07,78.95 134.08,78.95 135.85,80.72 142.21,80.72 143.22,81.74 143.22,85.9 144.27,86.95 145.64,86.95 146.91,88.22 194.15,88.22 194.66,88.73 194.66,90 195.86,91.2 203.26,91.2 203.82,90.63 210.41,90.63 211.79,89.25 211.79,87.73 213.47,86.05 237.35,86.05 243.69,79.7 243.69,79.25 243.51,79.07 v2(243.27,79.07)
  BOTTOM w0.076: 236.51,75.92 236.51,75.91 236.46,75.85 236.46,72.62 236.5,72.58 U2.B24
  BOTTOM w0.104: 236.51,75.92 236.51,77.49 236.64,77.62 236.64,77.91 236.51,78.04 236.51,78.32 236.64,78.46 236.64,78.74 236.51,78.87 236.51,79.1 237.08,79.68 237.28,79.68 237.42,79.53 237.73,79.53 237.88,79.68 238.11,79.68 238.25,79.53 238.56,79.53 238.71,79.68 238.94,79.68 239.09,79.53 239.4,79.53 239.54,79.68 239.78,79.68 239.92,79.53 240.23,79.53 240.37,79.68 240.61,79.68 240.75,79.53 241.06,79.53 241.21,79.68 241.44,79.68 241.59,79.53 241.9,79.53 242.04,79.68 242.27,79.68 242.42,79.53 242.73,79.53 242.87,79.68 243.33,79.68 243.63,79.38 243.63,79.1 243.53,79 243.35,79 v2(243.27,79.07)
PCIE_RBIAS: length 1.2
  TOP w0.254: R2015.1 51.28,83.73 v1(51.22,83.78)
  BOTTOM w0.178: v1(51.22,83.78) 51.55,84.11 U2005.N16
PCIE_RCOMPN: length 3.7
  BOTTOM w0.104: 240.07,74.32 239.89,74.14 239.89,72.64 U2.B18
  BOTTOM w0.305: 240.07,74.32 240.38,74.63 v1(240.38,75.06) 240.38,75.82 R129.1
PCIE_RCOMPP: length 5.4
  BOTTOM w0.104: 240.39,73.99 240.15,73.75 240.15,72.49 239.96,72.31 U2.C17
  BOTTOM w0.305: 240.39,73.99 240.84,74.44 240.84,75.77 R129.2 v1(242.08,76.03)
PCIE_SSD1_CLKREQ_N: length 3.9
  BOTTOM w0.097: Q9.1 95.29,53.79 R512.1 v1(96.79,54.23) 97.12,54.23 97.44,53.92 JSSD1.52
PCIE_SSD1_RST_N: length 98.4
  IN05 w0.091: v2(32.48,61.67) 33.24,61.67 33.88,61.04 33.88,60.02 34.13,59.77 35.27,59.77 35.78,59.26 36.93,59.26 37.94,60.28 39.34,60.28 40.61,59.01 40.61,58.12 41.48,57.24 45.7,57.24 46.83,58.37 51.79,58.37 52.42,57.74 52.42,54.94 54.91,52.45 55.5,52.45 61.3,46.65 71.76,46.65 72.23,46.18 75.03,46.18 77.06,44.15 81.5,44.15 83.66,46.3 89.13,46.3 90.14,45.29 92.81,45.29 97.5,40.59 97.5,39.65 v2(97.83,39.32)
  IN10 w0.091: v2(97.83,39.32) 97.83,40.01 96.7,41.15 96.7,52.94 v2(97,53.24)
  BOTTOM w0.097: v2(32.48,61.67) 32.81,61.67 R478.1 ; v2(97,53.24) 97.17,53.42 JSSD1.50
PCIE_SSD2_CLKREQ_N: length 33.5
  IN10 w0.091: v2(95.22,76.15) 95.22,73.49 94.08,72.34 94.08,64.98 93.49,64.39 93.49,52.7 v2(92.55,51.77)
  BOTTOM w0.097: JSSD2.52 96.97,78.29 96.87,78.18 96.37,78.18 95.22,77.04 v2(95.22,76.15) ; R508.1 93.44,50.88 v2(92.55,51.77) 93.58,52.79 Q9.4
PCIE_SSD2_RST_N: length 3.8
  BOTTOM w0.097: R483.1 96.11,77.39 v1(96.14,77.42) 96.14,77.42 96.51,77.79 JSSD2.50
PCIE_WAKE_N: length 349.3
  TOP w0.097: R459.1 265.65,77.93 265.91,78.18 269.72,78.18 270.22,77.68 270.22,73.87 272.26,71.83 276.45,71.83 276.7,71.58 276.7,66.5 v2(276.32,66.12) ; R2094.2 58.77,90.12 58.39,89.74 v1(57.86,89.74) ; v3(241.65,49.86) 241.27,49.86 240.63,49.23 240.63,48.85 240.13,48.34 R138.1
  IN03 w0.091: v2(257.65,60.15) 257.65,59.52 258.67,58.5 258.67,51.64 255.85,48.82 255.85,46.44 249.05,39.64 215.17,39.64 209.82,44.99 159.65,44.99 152.88,51.77 118.21,51.77 112.11,45.67 109.82,45.67 107.92,43.77 106.97,43.77 105.7,42.5 91.54,42.5 90.95,43.09 83.11,43.09 82.26,42.24 78.45,42.24 76.93,43.77 71.44,43.77 70.93,43.26 68.86,43.26 67.11,45 67.11,46.15 v2(65.53,47.74)
  IN05 w0.091: v2(257.65,60.15) 257.65,62.31 258.57,63.23 258.57,63.74 259.02,64.19 259.43,64.19 259.67,64.43 274.25,64.43 275.94,66.12 v2(276.32,66.12)
  IN08 w0.091: v3(241.65,49.86) 242.16,50.37 245.46,50.37 245.59,50.5 251.68,50.5 251.94,50.24 257.02,50.24 258.92,52.15 258.92,59.64 258.67,59.9 257.91,59.9 v2(257.65,60.15)
  IN10 w0.091: v2(65.53,47.74) 66.05,47.74 67.53,49.22 67.53,51.36 65.72,53.17 62.33,53.17 60.93,54.56 60.93,63.99 60.04,64.88 60.04,74.07 58.9,75.21 58.9,78.82 57.86,79.86 v1(57.86,89.74)
  BOTTOM w0.097: v3(241.65,49.86) 241.65,50.24 242.03,50.62 242.03,51.61 242.13,51.72 242.13,52 242.36,52.23 U2.BC13
PCIE_WLAN_RX_DN: length 44.8
  IN10 w0.114: v3(238.47,68.45) 238.98,68.96 238.98,69.69 239.2,69.91 239.2,71.8 240.25,72.85 240.25,74.5 242.79,77.04 245.59,77.04 246.35,76.28 262.35,76.28 263.11,77.04 270.35,77.04 271.01,76.38 271.52,76.38 v2(271.75,76.15)
  BOTTOM w0.104: v3(238.47,68.45) 238.09,68.07 U2.L22 ; v2(271.75,76.15) 271.54,76.36 270.93,76.36 270.25,77.03 JWLAN1.43
PCIE_WLAN_RX_DP: length 44.8
  IN10 w0.114: v3(238.47,69.22) 238.62,69.22 238.72,69.31 238.72,69.8 238.93,70.02 238.93,71.91 239.99,72.96 239.99,74.61 242.68,77.31 245.7,77.31 246.46,76.55 262.24,76.55 263,77.31 270.46,77.31 271.12,76.65 271.69,76.65 271.85,76.81 271.85,76.94 v2(271.75,77.04)
  BOTTOM w0.104: JWLAN1.41 270.75,78.06 270.51,77.81 270.51,77.14 271.04,76.61 271.65,76.61 271.8,76.76 271.8,76.99 v2(271.75,77.04) ; v3(238.47,69.22) 238.09,68.83 U2.K22
PCIE_WLAN_TX_C_DN: length 3.8
  BOTTOM w0.104: JWLAN1.37 271.75,79.76 271.87,79.88 271.87,81.23 271.7,81.41 271.09,81.41 270.96,81.28 270.96,81.08 C183.1
PCIE_WLAN_TX_C_DP: length 3.8
  BOTTOM w0.104: JWLAN1.35 272.25,79.76 272.13,79.88 272.13,81.34 271.8,81.66 271.27,81.66 C184.1
PCIE_WLAN_TX_DN: length 45.3
  IN08 w0.114: v2(256.7,77.17) 256.38,77.49 256.38,77.68 256.12,77.94 253.22,77.94 252.09,76.81 244.82,76.81 244.57,77.07 244.57,77.57 v2(244.81,77.8)
  BOTTOM w0.076: U2.C23 237.11,71.98 236.82,72.27 236.82,75.23 237.08,75.48 237.08,75.85 237.03,75.91 237.03,75.92
  BOTTOM w0.104: 237.03,75.92 237.03,77.66 237.98,78.62 v2(239.62,78.62) 244.37,78.62 244.65,78.34 244.65,77.96 v2(244.81,77.8) ; C183.2 269.68,81.45 261.3,81.45 258.29,78.44 256.89,78.44 256.19,77.74 256.19,77.51 256.53,77.17 v2(256.7,77.17)
PCIE_WLAN_TX_DP: length 45.3
  IN08 w0.114: v2(255.87,77.17) 256.12,77.41 256.12,77.57 256,77.68 253.33,77.68 252.2,76.55 244.71,76.55 244.3,76.96 244.3,77.49 244.21,77.58 v2(243.99,77.8)
  BOTTOM w0.076: U2.B23 236.98,72.55 236.98,75.16 237.23,75.42 237.23,75.86 237.28,75.91 237.28,75.92
  BOTTOM w0.104: C184.2 269.98,81.7 261.19,81.7 258.18,78.7 256.78,78.7 255.93,77.84 255.93,77.23 v2(255.87,77.17) ; v2(243.99,77.8) 243.86,77.68 243.86,77.42 244.01,77.27 244.27,77.27 244.39,77.39 244.39,78.23 244.26,78.36 v2(243.94,78.36) 238.09,78.36 237.28,77.55 237.28,75.92
PEG_PRX_C_GTX_N0: length 18.3
  TOP w0.104: v3(238.41,130.37) 238.58,130.2 238.58,130.08 238.47,129.98 238.24,129.98 237.72,130.51 236.59,130.51 235.99,129.9 233.42,129.9 233.06,130.25 230.39,130.25 229.82,129.68 224.04,129.68 223.37,130.36 222.7,130.36 222.6,130.46 222.6,130.69 C662.1
  BOTTOM w0.104: G2.BH26 238.69,130.64 238.41,130.37 v3(238.41,130.37)
PEG_PRX_C_GTX_N1: length 16.5
  TOP w0.104: C664.1 226.32,131.4 227.15,130.57 229.57,130.57 229.99,130.99 233.39,130.99 233.82,130.56 235.61,130.56 236.06,131.01 239.51,131.01 239.73,131.24 240.23,131.24 240.49,130.98 v3(240.49,130.37)
  BOTTOM w0.104: G2.BE26 v3(240.49,130.37)
PEG_PRX_C_GTX_N2: length 18.8
  TOP w0.104: v3(239.09,131.67) 239.29,131.67 239.41,131.55 239.41,131.38 239.31,131.28 236.56,131.28 236.37,131.46 229.44,131.46 229.17,131.19 227.39,131.19 226.56,132.03 223.94,132.03 223.29,132.68 222.86,132.68 222.68,132.5 C654.1
  BOTTOM w0.104: v3(239.09,131.67) 239.39,131.37 G2.BG27
PEG_PRX_C_GTX_N3: length 14.2
  TOP w0.104: C671.1 226.46,133.81 226.56,133.71 226.56,133.28 226.67,133.18 227.01,133.18 227.8,132.38 232.01,132.38 232.12,132.49 232.53,132.49 232.64,132.38 233.06,132.38 233.17,132.49 233.58,132.49 233.69,132.38 234.11,132.38 234.21,132.49 234.63,132.49 234.74,132.38 235.15,132.38 235.26,132.49 235.68,132.49 235.79,132.38 236.43,132.38 236.72,132.67 238.15,132.67 v3(238.44,132.39)
  BOTTOM w0.117: v3(238.44,132.39) 238.44,132.52 G2.BH29
PEG_PRX_C_GTX_N4: length 20.5
  TOP w0.104: v3(241.09,132.47) 240.97,132.58 240.97,132.96 240.6,133.33 239.89,133.33 239.65,133.15 229.11,133.15 228.7,133.56 227.98,133.56 226.84,134.7 224.11,134.7 223.44,135.37 222.88,135.37 222.68,135.58 C673.1
  BOTTOM w0.104: G2.BE29 v3(241.09,132.47)
PEG_PRX_C_GTX_N5: length 15.3
  TOP w0.076: v3(239.09,133.77) 239.16,133.77 239.24,133.84 239.24,134.06 239.16,134.14 238.93,134.14 238.6,133.81
  TOP w0.104: 238.6,133.81 238.43,133.64 236.39,133.64 236.04,133.99 229.38,133.99 227.5,135.87 226.46,135.87 C675.1
  BOTTOM w0.117: G2.BG30 v3(239.09,133.77)
PEG_PRX_C_GTX_N6: length 18.3
  TOP w0.104: v3(238.44,134.49) 238.33,134.38 238.18,134.38 237.82,134.75 229.87,134.75 227.5,137.12 224.18,137.12 223.93,137.37 223.28,137.37 223.06,137.6 222.6,137.6 222.5,137.7 222.5,137.93 222.57,138 C680.1
  BOTTOM w0.104: G2.BH32 238.69,134.74 v3(238.44,134.49)
PEG_PRX_C_GTX_N7: length 17.3
  TOP w0.104: v3(241.09,134.57) 240.98,134.68 240.98,134.96 240.69,135.25 236.5,135.25 236.29,135.45 230.41,135.45 227.46,138.4 226.35,138.4 C682.1
  BOTTOM w0.104: G2.BE32 v3(241.09,134.57)
PEG_PRX_C_GTX_N8: length 19.3
  TOP w0.104: v3(239.09,135.87) 239.09,136 238.98,136.11 238.79,136.11 238.42,135.74 236.84,135.74 236.45,136.13 230.97,136.13 227.58,139.53 223.98,139.53 223.72,139.78 223.23,139.78 223.13,139.89 223.13,140.23 223.02,140.34 222.75,140.34 C868.1
  BOTTOM w0.104: G2.BG33 v3(239.09,135.87)
PEG_PRX_C_GTX_N9: length 15.4
  TOP w0.104: C870.1 226.49,140.54 227.47,140.54 231.39,136.62 237.92,136.62 238.03,136.51 238.03,136.27 238.18,136.12 238.33,136.12 238.44,136.22 v3(238.44,136.42)
  BOTTOM w0.104: G2.BH35 238.44,136.72 v3(238.44,136.42)
PEG_PRX_C_GTX_N10: length 21.5
  TOP w0.104: C875.1 222.91,142.46 223.53,142.46 224.05,141.94 227.68,141.94 232.01,137.6 236.21,137.6 236.47,137.34 240.75,137.34 241.05,137.04 241.05,136.71 v3(241.09,136.67)
  BOTTOM w0.104: G2.BE35 v3(241.09,136.67)
PEG_PRX_C_GTX_N11: length 16.8
  TOP w0.104: v3(239.09,137.97) 239.12,138 239.28,138 239.41,137.87 239.41,137.64 239.34,137.56 236.82,137.56 236.3,138.09 232.41,138.09 227.5,143 226.53,143 C877.1
  BOTTOM w0.104: G2.BG36 v3(239.09,137.97)
PEG_PRX_C_GTX_N12: length 19.5
  TOP w0.104: C879.1 222.83,145.09 223.02,145.09 223.12,144.98 223.12,144.71 223.22,144.61 223.99,144.61 224.25,144.35 227.78,144.35 233.14,138.99 233.79,138.99 233.92,139.12 234.21,139.12 234.34,138.99 234.62,138.99 234.75,139.12 235.04,139.12 235.17,138.99 235.46,138.99 235.58,139.12 235.87,139.12 236,138.99 237.79,138.99 238.19,138.6 238.33,138.6 v3(238.42,138.69)
  BOTTOM w0.104: G2.BH38 238.44,138.82 238.44,138.7 v3(238.42,138.69)
PEG_PRX_C_GTX_N13: length 18.9
  TOP w0.076: 240.05,138.91 240.05,138.49 240.16,138.37 240.78,138.37 v3(241.13,138.72)
  TOP w0.104: 240.05,138.91 239.76,139.2 236.5,139.2 236.17,139.53 233.49,139.53 227.68,145.33 226.4,145.33 226.18,145.11 C881.1
  BOTTOM w0.104: v3(241.13,138.72) G2.BE38
PEG_PRX_C_GTX_N14: length 20.9
  TOP w0.104: C884.1 223.03,147.43 223.35,147.43 223.88,146.9 227.72,146.9 234.06,140.56 236.28,140.56 236.87,139.98 238.47,139.98 238.94,140.45 239.17,140.45 239.28,140.34 239.28,140.17 239.17,140.07 v3(239.09,140.07)
  BOTTOM w0.117: G2.BG39 v3(239.09,140.07)
PEG_PRX_C_GTX_N15: length 16.8
  TOP w0.104: v3(239.09,140.87) 239.06,140.87 238.58,140.39 238.26,140.39 237.59,141.05 234.45,141.05 227.77,147.74 226.43,147.74 226.22,147.53 C885.1
  BOTTOM w0.117: v3(239.09,140.87) 239.09,140.94 239.31,141.17 G2.BG41
PEG_PRX_C_GTX_P0: length 18.3
  TOP w0.104: v3(239.09,130.37) 239.09,130.22 238.66,129.8 238.12,129.8 237.67,130.25 236.7,130.25 236.09,129.65 233.31,129.65 232.96,130 230.5,130 229.92,129.42 223.94,129.42 223.29,130.08 223.03,130.08 222.83,129.87 C650.1
  BOTTOM w0.104: G2.BG26 v3(239.09,130.37)
PEG_PRX_C_GTX_P1: length 16.5
  TOP w0.104: v3(239.79,130.37) 239.94,130.37 240.23,130.66 240.23,130.88 240.12,130.98 239.84,130.98 239.61,130.76 236.16,130.76 235.71,130.31 233.71,130.31 233.28,130.73 230.1,130.73 229.67,130.31 227.04,130.31 226.48,130.87 226.34,130.87 226.23,130.76 226.23,130.64 C663.1
  BOTTOM w0.104: G2.BF26 v3(239.79,130.37)
PEG_PRX_C_GTX_P2: length 18.8
  TOP w0.076: v3(239.79,131.67) 239.39,132.06 238.93,132.06 238.41,131.53 238.36,131.53
  TOP w0.104: 238.36,131.53 236.67,131.53 236.48,131.72 229.33,131.72 229.06,131.45 227.5,131.45 226.66,132.29 224.04,132.29 223.39,132.94 222.91,132.94 C653.1
  BOTTOM w0.104: v3(239.79,131.67) 240.09,131.37 G2.BF27
PEG_PRX_C_GTX_P3: length 14.3
  TOP w0.104: C670.1 226.9,132.92 227.7,132.13 236.54,132.13 236.83,132.42 237.71,132.42 238.14,131.98 238.58,131.98 239.06,132.47 v3(239.09,132.47)
  BOTTOM w0.117: v3(239.09,132.47) 239.09,132.56 239.29,132.77 G2.BG29
PEG_PRX_C_GTX_P4: length 20.4
  TOP w0.104: C672.1 222.68,134.83 222.96,135.12 223.33,135.12 224,134.45 226.73,134.45 227.88,133.3 228.6,133.3 229,132.9 239.78,132.9 239.93,133.04 239.98,133.08 240.5,133.08 240.72,132.86 240.72,132.59 240.59,132.47 v3(240.39,132.47)
  BOTTOM w0.117: G2.BF29 v3(240.39,132.47)
PEG_PRX_C_GTX_P5: length 15.3
  TOP w0.104: C674.1 226.38,135.61 227.39,135.61 229.27,133.73 235.94,133.73 236.29,133.38 239.4,133.38 v3(239.79,133.77)
  BOTTOM w0.117: G2.BF30 v3(239.79,133.77)
PEG_PRX_C_GTX_P6: length 18.3
  TOP w0.104: C679.1 223.82,137.11 224.07,136.86 227.39,136.86 229.76,134.49 237.71,134.49 238.11,134.09 238.61,134.09 v3(239.09,134.57)
  BOTTOM w0.104: G2.BG32 239.32,134.87 239.09,134.63 v3(239.09,134.57)
PEG_PRX_C_GTX_P7: length 17.2
  TOP w0.104: C681.1 226.1,137.86 226.39,138.14 227.36,138.14 230.3,135.2 236.19,135.2 236.39,134.99 240.58,134.99 240.71,134.86 240.71,134.65 240.58,134.52 240.43,134.52 v3(240.39,134.57)
  BOTTOM w0.104: G2.BF32 v3(240.39,134.57)
PEG_PRX_C_GTX_P8: length 19.4
  TOP w0.104: v3(239.79,135.87) 239.4,135.48 236.73,135.48 236.34,135.88 230.86,135.88 227.47,139.27 223.87,139.27 223.62,139.53 C869.1
  BOTTOM w0.104: G2.BF33 v3(239.79,135.87)
PEG_PRX_C_GTX_P9: length 15.4
  TOP w0.104: C874.1 226.36,140.8 227.58,140.8 231.5,136.88 238.61,136.88 238.98,136.51 v3(238.98,136.51)
  BOTTOM w0.104: v3(238.98,136.51) 238.98,136.51 239.39,136.91 G2.BG35
PEG_PRX_C_GTX_P10: length 21.5
  TOP w0.104: v3(240.39,136.67) 240.59,136.67 240.73,136.81 240.73,136.98 240.63,137.08 236.37,137.08 236.1,137.35 231.91,137.35 227.57,141.68 223.94,141.68 223.42,142.21 222.91,142.21 222.68,141.97 C876.1
  BOTTOM w0.104: G2.BF35 v3(240.39,136.67)
PEG_PRX_C_GTX_P11: length 16.8
  TOP w0.104: C878.1 226.31,143.25 227.61,143.25 232.52,138.34 236.4,138.34 236.92,137.82 238.4,137.82 238.93,138.36 239.39,138.36 v3(239.79,137.97)
  BOTTOM w0.104: G2.BF36 v3(239.79,137.97)
PEG_PRX_C_GTX_P12: length 19.6
  TOP w0.104: v3(239.07,138.76) 239.04,138.76 238.56,138.28 238.12,138.28 237.67,138.73 233.04,138.73 227.68,144.1 224.14,144.1 223.89,144.35 C880.1
  BOTTOM w0.104: v3(239.07,138.76) 239.07,138.85 239.29,139.07 G2.BG38
PEG_PRX_C_GTX_P13: length 18.8
  TOP w0.104: v3(240.42,138.74) 240.68,139 240.76,139 240.9,139.15 240.9,139.29 240.73,139.46 236.6,139.46 236.28,139.78 233.6,139.78 227.79,145.59 226.52,145.59 C882.1
  BOTTOM w0.104: v3(240.42,138.74) 240.09,139.07 G2.BF38
PEG_PRX_C_GTX_P14: length 20.9
  TOP w0.104: C883.1 222.96,147.17 223.24,147.17 223.77,146.64 227.62,146.64 233.95,140.31 236.18,140.31 236.76,139.72 238.89,139.72 238.95,139.66 239.38,139.66 v3(239.79,140.07)
  BOTTOM w0.117: G2.BF39 v3(239.79,140.07)
PEG_PRX_C_GTX_P15: length 16.8
  TOP w0.104: C886.1 226.1,148.15 226.26,148 227.87,148 234.56,141.31 238.58,141.31 238.71,141.17 238.71,140.98 238.52,140.79 v3(238.44,140.79)
  BOTTOM w0.117: G2.BH41 238.44,140.92 v3(238.44,140.79)
PEG_PRX_GTX_N0: length 38.1
  TOP w0.104: v3(187.67,136.32) 187.55,136.32 187.45,136.42 187.45,136.6 187.55,136.71 187.88,136.71 188.23,136.35 189.09,136.35 190.18,135.27 v2(201.39,135.27) 207.93,135.27 212.76,130.45 221.45,130.45 C662.2
  BOTTOM w0.104: v3(187.67,136.32) 187.35,136.64 U1.E10
PEG_PRX_GTX_N1: length 41.6
  TOP w0.076: 190.09,136.6 190.09,136.62 190.04,136.68 190.04,136.85 189.23,137.66 188.14,137.66 187.92,137.43 187.92,137.35 v3(187.67,137.1)
  TOP w0.104: 190.09,136.6 190.09,136.25 190.19,136.15 v2(207.87,136.15) 208.43,136.15 213.05,131.53 v2(217.65,131.53) 220.99,131.53 221.12,131.65 223.41,131.65 223.98,131.08 224.87,131.08 C664.2
  BOTTOM w0.104: v3(187.67,137.1) 187.35,137.43 U1.E11
PEG_PRX_GTX_N2: length 37.5
  TOP w0.076: v3(187.67,137.89) 187.64,137.92 187.64,138.05 187.72,138.13 189.77,138.13 190.43,137.47 190.67,137.47 190.72,137.42 190.74,137.42
  TOP w0.104: C654.2 221.34,132.29 221.24,132.39 221.24,132.82 221.14,132.92 220.72,132.92 220.46,133.18 212.69,133.18 209.08,136.78 v2(198.85,136.78) 191.51,136.78 190.87,137.42 190.74,137.42
  BOTTOM w0.104: U1.E12 187.35,138.22 v3(187.67,137.89)
