# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ROM_CS_R: length 2.7
  BOTTOM w0.097: R2168.1 R944.1 U2021.1
ROM_SCLK: length 84.8
  TOP w0.097: R2154.2 240.2,107.12 240.43,106.89 240.43,106 R2155.2 ; R2155.2 240.3,105.57 240.63,105.24 240.89,105.24 241.14,104.98 241.14,103.06 v2(241.5,102.7) ; R2155.2 239.92,106.25 239.49,106.25 238.98,106.76 238.98,107.01 238.47,107.52 238.47,110.44 236.6,112.31 236.6,113.2 236.57,113.24 236.57,113.87 236.96,114.27 v3(236.99,114.27)
  IN10 w0.091: v2(276.45,80.72) 274.85,79.12 260.5,79.12 259.99,78.62 250.74,78.62 249.02,80.34 241.33,80.34 240.86,80.82 237.97,83.71 237.97,99.14 239.49,100.66 239.49,100.68 v2(241.5,102.7)
  BOTTOM w0.097: v2(276.45,80.72) 276.7,80.47 277.97,80.47 279.42,81.92 v1(279.42,83.26) 279.42,83.9 279.37,83.95 R2209.1 ; G2.BK3 v3(236.99,114.27)
ROM_SCLK_R: length 13.6
  BOTTOM w0.097: U2021.6 287.12,86.44 286.68,86.87 286.68,87.76 285.46,88.98 280.51,88.98 279.37,87.84 v1(279.37,86.95) R2209.2
ROM_SI: length 84.6
  TOP w0.097: v2(241.52,101.93) 241.98,102.39 241.98,102.87 241.52,103.33 241.52,104.85 241.88,105.21 242.59,105.21 242.84,105.46 242.84,105.82 v1(242.41,106.25) 242.03,106.63 241.27,106.63 240.76,107.14 240.76,108.03 240.38,108.41 R2150.2 R2151.2 240.2,109.86 239.19,110.87 238.42,110.87 236.82,112.47 236.82,113.11 236.99,113.27 v3(236.99,113.57)
  IN10 w0.091: v2(275.18,80.72) 275.18,80.22 274.3,79.34 259.83,79.34 259.39,78.91 250.81,78.91 249.12,80.6 241.44,80.6 239.63,82.41 238.22,83.82 238.22,98.63 v2(241.52,101.93)
  BOTTOM w0.097: v2(275.18,80.72) 277.72,83.26 R929.1 ; G2.BK2 v3(236.99,113.57)
ROM_SI_R: length 13.4
  BOTTOM w0.097: U2021.5 287.5,87.71 285.97,89.23 279.5,89.23 278.61,90.12 v1(277.72,90.12) R929.2
ROM_SO: length 87.5
  TOP w0.097: v3(236.99,114.97) 237,114.97 237.46,114.51 237.46,113.74 237.59,113.61 237.59,112.47 238.25,111.81 238.75,111.81 241.19,109.38 R2153.2 R2152.2 241.19,107.22 241.52,106.89 242.41,106.89 242.89,106.4 242.89,106.15 243.06,105.98 243.06,105.37 242.67,104.98 242.03,104.98 241.78,104.73 241.78,103.46 242.41,102.82 v2(242.41,102.7)
  IN10 w0.091: v2(242.41,102.7) 241.95,102.24 241.95,101.73 238.47,98.25 238.47,83.92 240.3,82.09 241.54,80.85 249.23,80.85 250.95,79.13 259.23,79.13 259.66,79.56 273.91,79.56 274.42,80.07 v2(274.42,80.72)
  BOTTOM w0.097: R928.1 280.26,85.68 280,85.42 280,81.99 278.23,80.22 274.92,80.22 v2(274.42,80.72) ; G2.BK4 v3(236.99,114.97)
ROM_SO_R: length 2
  BOTTOM w0.097: U2021.2 282.24,85.17 R928.2
RTCRST_N: length 81.6
  TOP w0.097: v3(244.57,52.76) 244.29,52.49 244.29,51.92 v1(244.32,51.9) 244.32,50.24 244.65,49.91 C188.1 244.65,48.59 R163.1 245.33,47.91 245.33,47.32 244.82,46.82 Q12.1
  IN05 w0.091: v3(244.57,52.76) 244.57,52.03 245.08,51.51 249.27,51.51 249.65,51.13 251.05,51.13 251.68,51.77 251.68,54.69 252.62,55.62 257.19,55.62 262.1,60.53 266.03,60.53 267.3,59.26 275.05,59.26 275.94,58.37 287.62,58.37 v2(287.75,58.25)
  BOTTOM w0.097: v3(244.57,52.76) 244.55,52.78 243.94,52.78 243.54,52.39 U2.BC10 ; v2(287.75,58.25) 289.27,58.25 293.08,54.44 300.73,54.44 302.26,55.96 304.22,55.96 TP77.1
RTD3_CIO_PWR_EN_R: length 21.3
  TOP w0.097: R2282.1 61.44,93.3 v2(61.82,92.92) R2042.1 R2041.1
  IN03 w0.089: 48.84,92.05 49.63,91.27 55.09,91.27
  IN03 w0.091: v2(61.82,92.92) 61.18,92.28 61.18,91.52 58.64,88.98 56.74,88.98 55.59,90.12 55.59,90.76 55.09,91.27 ; v1(47.87,92.15) 48.74,92.15 48.84,92.05
  BOTTOM w0.102: v1(47.87,92.15) 47.87,91.75 48.14,91.49 U2005.F1
RTD3_USB_PWR_EN_R: length 3.5
  TOP w0.102: v1(46.72,89.63) 46.52,89.44 R2044.1 45.43,88.8 45.43,88.6 45.21,88.37 44.34,88.37 R2043.1
  BOTTOM w0.178: v1(46.72,89.63) 47,89.91 U2005.D4
SATA_A_DE: length 2.9
  TOP w0.097: U14.9 282.79,61.38 R472.2 R466.1
SATA_A_EQ1: length 4.8
  TOP w0.097: v1(285.21,67.52) R470.1 R476.2 283.46,67.85 283.46,67.75 282.79,67.08 U14.17
SATA_A_EQ2: length 3.3
  TOP w0.097: R475.2 R469.1 282.87,68.38 282.87,67.67 282.29,67.08 U14.18
SATA_B_DE: length 2.7
  TOP w0.097: R465.1 R471.2 U14.8
SATA_B_EQ1: length 3.4
  TOP w0.097: U14.19 281.79,67.25 v2(282.44,67.9)
  BOTTOM w0.097: R474.2 282.92,68.71 R468.1 282.75,68.2 v2(282.44,67.9)
SATA_B_EQ2: length 6.5
  TOP w0.097: U14.13 v2(285.21,64.72)
  IN08 w0.091: v2(285.21,64.72) 285.21,66.63 v2(286.48,67.9)
  BOTTOM w0.097: R467.1 R473.2 286.35,68.02 v2(286.48,67.9)
SATA_REXT: length 3.2
  TOP w0.097: R463.1 279.62,61.9 279.85,62.13 281.05,62.13 281.29,62.38 U14.6
SATA_RX__R_N0: length 2.2
  TOP w0.104: U14.12 284.58,64.22 284.7,64.1 284.95,64.1 285.34,63.71 285.65,63.71 R2234.1
SATA_RX__R_P0: length 2.1
  TOP w0.104: R2115.1 285.77,63.45 285.23,63.45 284.84,63.84 284.7,63.84 284.58,63.72 U14.11
SATA_RX_C_DN0: length 1.9
  TOP w0.104: C567.2 279.19,63.84 279.39,63.84 279.64,64.09 279.85,64.09 279.98,64.22 U14.4
SATA_RX_C_DP0: length 1.9
  TOP w0.104: C571.2 279.19,63.58 279.49,63.58 279.75,63.83 279.88,63.83 279.98,63.72 U14.5
SATA_RX_C_N0: length 2.6
  BOTTOM w0.104: C569.2 292.43,87.82 292.99,87.82 293,87.83 293.84,87.83 293.91,87.9 JHDD1.4
SATA_RX_C_P0: length 2.6
  BOTTOM w0.104: C570.2 292.43,87.56 293.1,87.56 293.11,87.57 293.84,87.57 293.91,87.5 JHDD1.5
SATA_RX_DN0: length 69.6
  TOP w0.104: v2(277.21,63.96) 277.46,64.21 C567.1
  IN03 w0.114: v3(228.7,69.42) 229.11,69.54 229.29,69.54 229.29,69.54 229.45,69.38 229.45,69.04 229.72,68.77 230.62,68.77 230.97,68.42 230.97,67.55 231.82,66.7 231.82,66.43 232.2,66.04 233.19,66.04 234.35,67.2 234.35,69.11 234.68,69.44 235.19,69.44 235.6,69.85 235.6,71.25 235.71,71.36 236.85,71.36 238.08,72.58 239.73,72.58 240.51,73.36 240.51,74.5 241.33,75.32 244.29,75.32 244.48,75.13 245.13,75.13 246.08,74.18 246.08,73.38 246.87,72.58 248.9,72.58 251.19,70.3 270.88,70.3 274.8,66.38 274.8,64.34 276.7,62.44 277.72,62.44 278.23,62.94 278.23,63.45 277.96,63.72 277.45,63.72 v2(277.21,63.96)
  BOTTOM w0.104: U2.H42 228.61,69.5 v3(228.7,69.42) ; v2(277.21,63.96) 277.46,64.21 C567.1
SATA_RX_DP0: length 69.5
  TOP w0.104: C571.1 277.84,63.14 277.39,63.14 v2(277.2,63.33)
  IN03 w0.114: v3(229.2,70.34) 228.82,70.34 228.67,70.19 228.67,69.94 228.8,69.81 229.36,69.81 229.46,69.75 229.71,69.49 229.71,69.16 229.83,69.04 230.73,69.04 231.24,68.53 231.24,67.66 232.09,66.81 232.09,66.54 232.32,66.31 233.08,66.31 234.08,67.31 234.08,69.22 234.57,69.71 235.08,69.71 235.34,69.96 235.34,71.36 235.6,71.62 236.74,71.62 237.97,72.85 239.62,72.85 240.24,73.47 240.24,74.61 241.22,75.59 244.4,75.59 244.59,75.4 245.24,75.4 246.35,74.29 246.35,73.49 246.98,72.85 249.01,72.85 251.3,70.56 270.99,70.56 275.06,66.49 275.06,64.45 276.81,62.7 277.61,62.7 277.96,63.06 277.96,63.34 277.84,63.45 277.33,63.45 v2(277.2,63.33)
  BOTTOM w0.104: C571.1 277.33,63.2 v2(277.2,63.33) ; U2.H40 229.11,69.83 229.29,70.01 229.29,70.25 v3(229.2,70.34)
SATA_RX_N0: length 33.9
  TOP w0.104: v2(287.57,63.96) 287.57,63.83 287.5,63.76 287.5,63.76 287.03,63.76 286.94,63.86 R2234.2
  IN08 w0.114: v2(287.57,63.96) 287.82,63.71 290.3,63.71 292.18,65.6 292.18,71.55 292.82,72.18 292.82,76.73 290.67,78.88 290.67,80.22 289.14,81.75 289.14,87.48 289.49,87.84 289.79,87.84 v2(290.16,88.22)
  BOTTOM w0.104: v2(287.57,63.96) 287.57,63.93 287.35,63.71 287.16,63.71 286.94,63.93 R2234.2 ; C569.1 290.88,87.82 290.57,87.82 v2(290.16,88.22)
SATA_RX_P0: length 33.9
  TOP w0.104: v2(287.57,63.2) 287.57,63.32 287.39,63.5 287.05,63.5 286.94,63.39 R2115.2
  IN08 w0.114: v2(290.16,87.2) 289.79,87.58 289.6,87.58 289.4,87.37 289.4,81.86 290.94,80.33 290.94,78.99 293.08,76.84 293.08,72.07 292.45,71.44 292.45,65.48 290.41,63.45 287.69,63.45 287.57,63.33 v2(287.57,63.2)
  BOTTOM w0.104: C570.1 290.88,87.56 290.52,87.56 v2(290.16,87.2) ; R2115.2 287.19,63.45 287.5,63.45 287.57,63.38 v2(287.57,63.2)
SATA_TX__R_N0: length 2
  TOP w0.104: R2113.1 285.77,65.23 285.34,65.23 285.22,65.34 284.95,65.34 284.83,65.22 U14.14
SATA_TX__R_P0: length 2.1
  TOP w0.104: R2112.1 285.65,65.49 285.44,65.49 285.33,65.6 284.95,65.6 284.83,65.72 U14.15
SATA_TX_C_DN0: length 1.8
  TOP w0.104: C566.2 279.13,65.55 279.46,65.55 279.62,65.39 279.85,65.39 280.01,65.22 U14.2
SATA_TX_C_DP0: length 1.8
  TOP w0.104: C565.2 279.25,65.81 279.57,65.81 279.7,65.67 279.96,65.67 280,65.72 U14.1
SATA_TX_C_N0: length 4.1
  BOTTOM w0.104: C568.2 291.44,89.95 291.94,89.95 293.12,88.77 293.84,88.77 293.91,88.7 JHDD1.2
SATA_TX_C_P0: length 4.1
  BOTTOM w0.104: JHDD1.1 293.91,89.1 293.84,89.03 293.22,89.03 292.05,90.2 291.44,90.2 C564.2
SATA_TX_DN0: length 70.7
  TOP w0.104: v2(277.22,65.33) 277.32,65.23 C566.1
  IN03 w0.114: v3(225.44,71.3) 225.67,71.3 227.22,72.85 229.33,72.85 229.84,72.34 234.03,72.34 234.92,73.23 236.45,73.23 236.68,73.47 236.68,77.03 237.4,77.74 239.81,77.74 240.2,77.35 245.66,77.35 247.6,75.4 250.15,75.4 250.79,74.76 250.79,73.74 253.08,71.45 276.83,71.45 279.38,68.9 279.38,66.87 277.84,65.33 v2(277.22,65.33)
  BOTTOM w0.104: U2.E45 226.28,71.03 225.71,71.03 v3(225.44,71.3) ; v2(277.22,65.33) 277.32,65.23 C566.1
SATA_TX_DP0: length 70.7
  TOP w0.104: C565.1 277.85,66.2 277.26,66.2 v2(277.21,66.25)
  IN03 w0.114: v2(277.21,66.25) 277.21,65.96 277.58,65.6 277.73,65.6 279.11,66.98 279.11,68.79 276.72,71.19 252.97,71.19 250.53,73.63 250.53,74.65 250.04,75.14 247.49,75.14 245.55,77.08 240.09,77.08 239.7,77.48 237.51,77.48 236.95,76.92 236.95,73.36 236.56,72.97 235.03,72.97 234.14,72.08 229.73,72.08 229.22,72.58 227.33,72.58 225.83,71.08 225.83,70.68 225.7,70.56 v3(225.44,70.56)
  BOTTOM w0.104: U2.F45 226.26,70.77 225.66,70.77 v3(225.44,70.56) ; C565.1 v2(277.21,66.25)
SATA_TX_N0: length 33.4
  TOP w0.104: R2113.2 287.19,65.23 287.5,65.23 287.57,65.15 v2(287.57,64.98)
  IN08 w0.114: v2(289.15,89.49) 288.77,89.86 288.55,89.86 288.4,89.72 288.4,81.47 289.92,79.95 289.92,78.69 291.81,76.8 291.81,72.98 290.43,71.59 290.43,65.62 290.04,65.23 287.83,65.23 v2(287.57,64.98)
  BOTTOM w0.104: v2(289.15,89.49) 289.58,89.92 289.92,89.92 C568.1 ; R2113.2 287.22,65.26 287.45,65.26 287.57,65.13 v2(287.57,64.98)
SATA_TX_P0: length 33.4
  TOP w0.104: v2(287.57,65.75) 287.57,65.71 287.35,65.49 287.24,65.49 286.94,65.79 R2112.2
  IN08 w0.114: v2(287.57,65.75) 287.83,65.5 289.92,65.5 290.16,65.73 290.16,71.7 291.55,73.09 291.55,76.69 289.66,78.58 289.66,79.84 288.13,81.36 288.13,89.83 288.44,90.13 288.77,90.13 v2(289.15,90.5)
  BOTTOM w0.104: R2112.2 287.29,65.51 287.41,65.51 287.57,65.68 v2(287.57,65.75) ; C564.1 289.87,90.18 289.47,90.18 v2(289.15,90.5)
SERIRQ: length 256.2
  TOP w0.097: v3(239.62,53.55) 239.87,53.29 R179.1
  IN03 w0.091: v2(140.43,38.81) 139.8,39.45 139.8,40.47 135.02,45.24 119.92,45.24 107.65,32.97 96.77,32.97 96.44,32.64 96.44,31 95.75,30.31 85.19,30.31 84.8,29.92 73.84,29.92 70.79,32.97 58.52,32.97 57.88,33.61 47.59,33.61 45.31,35.89 44.6,35.89 44.29,36.2 43.48,36.2 42.39,37.29 v2(42.39,37.42)
  IN05 w0.091: v2(42.39,37.42) 40.74,37.42 39.21,35.89 30.89,35.89 28.38,38.41 28.38,39.11 27.45,40.04 26.94,40.04 26.77,40.21 26.77,50.5 26.26,51.01 v2(26.13,51.01)
  IN10 w0.091: v3(239.62,53.55) 239.36,53.55 238.86,53.04 237.97,53.04 237.59,53.42 236.44,53.42 236.13,53.1 235.59,53.1 234.44,51.95 232.17,51.95 231.98,51.77 229.1,51.77 228.59,51.26 227.62,51.26 226.47,52.4 225.52,52.4 225.15,52.77 223.48,52.77 220.97,55.28 220.97,55.29 220.37,55.89 205.33,55.89 204.51,55.07 197.01,55.07 196.11,54.17 196.11,53.2 194.75,51.84 180.11,51.84 179.67,52.28 175.69,52.28 174.79,51.38 171.04,51.38 170.03,50.37 149.63,50.37 141.07,41.81 141.07,39.45 v2(140.43,38.81)
  BOTTOM w0.097: v2(26.13,51.01) 26.26,51.13 R294.1 ; v3(239.62,53.55) 239.86,53.55 U2.BA17
SERIRQ_R: length 6
  BOTTOM w0.076: 31.77,53.17 32.51,53.17 32.77,52.91 U5.G2
  BOTTOM w0.097: 31.77,53.17 31.49,53.44 31.01,53.44 v1(30.48,52.91) 28.7,51.13 R294.2
SLP_S3_N: length 277.8
  TOP w0.097: R2033.1 v2(26.13,87.07) ; v2(238.6,46.69) 238.35,46.94 R144.2
  IN03 w0.091: v2(41.75,45.8) 42.18,45.37 45.01,45.37 46.07,46.43 46.58,46.43 46.78,46.24 52.91,46.24 53.39,46.72 60.71,46.72 63.5,49.52 71.12,49.52 75.03,53.42 87.01,53.42 89.97,56.39 104.78,56.39 105.88,57.48 125.89,57.48 127.42,55.96 155.42,55.96 161,50.37 175.4,50.37 176.17,49.61 201.01,49.61 201.26,49.86 216.5,49.86 217.9,48.47 217.9,48.09 216.76,46.94 216.76,43.18 217.27,42.67 222.77,42.67 223.87,43.77 235.68,43.77 v2(238.6,46.69)
  IN10 w0.089: 32.18,80.72 33.65,79.25 33.88,79.25 34.26,78.87 34.26,78.08 35.91,76.43 35.91,70.82 36.29,70.44 36.29,68.91 ; 37.18,58.63 37.18,57.1 36.48,56.4 33.81,56.4 31.59,54.18 31.59,50.5 33.24,48.85 38.07,48.85 v1(38.2,48.97)
  IN10 w0.091: v2(26.13,87.07) 26.7,86.5 26.83,86.5 27.97,85.36 30.89,85.36 31.97,84.28 31.97,80.93 32.18,80.72 ; 37.18,58.63 37.18,63.71 36.29,64.6 36.29,68.91
  BOTTOM w0.089: v1(38.2,48.97) 37.81,48.59 37.81,48.21 38.7,47.32 39.59,47.32 40.23,46.69
  BOTTOM w0.097: v1(38.2,48.97) 38.2,48.98 37.78,49.4 U5.A12 ; v2(41.75,45.8) 41.12,45.8 40.23,46.69
SLP_S3_N_R: length 9.1
  TOP w0.097: v3(240.76,54.56) 240.13,53.93 240.13,53.42 241.01,52.53 241.01,50.5 v1(240.51,49.99) 240,49.99 238.35,48.34 R144.1
  BOTTOM w0.097: v3(240.76,54.56) 241.29,54.03 U2.AW15
SLP_S4_N: length 290.6
  IN03 w0.089: v3(38.83,48.34) 40.48,46.69
  IN03 w0.091: v2(239.87,46.69) 239.24,47.32 238.6,47.32 235.35,44.07 223.67,44.07 222.48,42.89 217.65,42.89 217.14,43.4 217.14,47.01 218.28,48.16 218.28,48.85 216.5,50.63 212.69,50.63 212.19,51.13 v2(200.93,51.13) 199.66,49.86 176.24,49.86 175.48,50.63 161.13,50.63 155.54,56.21 127.63,56.21 126.11,57.74 105.68,57.74 104.55,56.6 89.64,56.6 86.71,53.67 74.9,53.67 70.96,49.74 63.22,49.74 60.43,46.94 53.3,46.94 52.92,46.56 46.79,46.56 46.66,46.69 45.79,46.69 45.43,46.33 40.84,46.33 40.48,46.69
  BOTTOM w0.097: v3(38.83,48.34) 38.78,48.39 38.78,49.41 U5.A13 ; PD401.1 208.63,109.23 208.63,108.03 207.64,107.04 207.64,102.68 207.41,102.44 206.09,102.44 205.58,101.93 205.58,96.85 204.44,95.71 204.44,87.2 207.49,84.15 209.01,84.15 209.26,83.9 209.26,68.53 203.55,62.82 203.55,57.48 200.93,54.87 v2(200.93,51.13) ; R145.2 240.13,46.94 v2(239.87,46.69)
SLP_S4_N_R: length 4
  BOTTOM w0.097: U2.BD15 241.36,51.26 241.27,51.17 241.27,49.74 240.51,48.97 240.51,48.67 R145.1
SLP_S5_N: length 2.3
  TOP w0.097: v3(241.9,53.8) 241.4,54.31 TP71.1
  BOTTOM w0.097: U2.BA13 242.28,53.43 v3(241.9,53.8)
SLP_SUS_N: length 1.4
  TOP w0.097: TP74.1 v3(242.79,53.42)
  BOTTOM w0.097: v3(242.79,53.42) 242.79,53.29 242.28,52.78 U2.BB13
SMB_CLK: length 220
  TOP w0.097: v2(104.74,81.87) 105,82.13 105,84.08 PR430.1 ; R153.1 v3(224,54.05)
  IN08 w0.091: v2(98.14,32.46) 98.77,32.46 99.16,32.08 99.16,29.11 101.26,27 111.22,27 113.1,28.88 121.36,28.88 121.61,29.14 121.61,40.95 123.25,42.59 135.99,42.59 138.53,40.05 138.53,39.45 v2(139.16,38.81)
  IN10 w0.091: v3(224,54.05) 223.95,54.05 222.91,55.09 222.91,55.57 221.63,56.85 204.67,56.85 203.98,56.16 195.88,56.16 v2(193.14,53.42) 192.63,52.91 180.94,52.91 179.62,54.23 177.51,54.23 176.19,52.91 175.36,52.91 174.72,52.28 170.53,52.28 169.31,51.06 149.17,51.06 139.67,41.55 139.67,39.32 v2(139.16,38.81) ; v2(104.74,81.87) 104.74,80.34 103.99,79.59 103.99,62.3 105.63,60.66 105.63,42.88 98.14,35.39 v2(98.14,32.46)
  BOTTOM w0.097: U2.AW44 226.86,54.24 226.54,54.56 224.76,54.56 224.5,54.31 224.25,54.31 v3(224,54.05) ; v2(193.14,53.42) 193.64,52.91 194.79,52.91 195.04,53.16 195.04,53.8 Q1.6
SMB_CLK_GPU: length 24.1
  TOP w0.097: v3(237.69,117.77) 237.39,118.06 235.96,118.06 R2294.1 234.31,116.41 233.77,116.41 233.52,116.66 233.52,117.48 233.45,117.55 229.2,117.55 228.44,118.32 224.88,118.32 223.87,119.33 220.82,119.33 v1(220.44,118.95) 220.31,118.82 219.23,118.82 218.57,119.49 218.57,120.5 218.35,120.72 Q80.1
  BOTTOM w0.1: G2.BJ8 v3(237.69,117.77)
SMB_DATA: length 224.3
  TOP w0.097: v3(227.81,53.04) 227.68,52.91 224.83,52.91 R155.1 ; v2(104.57,82.5) 104.57,84.13 PR426.1
  IN08 w0.091: v2(97.5,32.46) 98.01,32.97 99.03,32.97 99.54,32.46 99.54,29.32 101.35,27.51 111.26,27.51 112.85,29.1 121.26,29.1 121.39,29.23 121.39,41.04 123.16,42.81 137.71,42.81 v2(140.43,40.08)
  IN10 w0.091: v3(227.81,53.04) 227.68,53.17 225.75,53.17 225.37,53.55 223.75,53.55 220.68,56.62 204.83,56.62 204.12,55.91 196.03,55.91 194.41,54.28 v2(194.41,53.42) 193.64,52.66 180.82,52.66 179.55,53.93 177.64,53.93 176.37,52.66 175.48,52.66 174.72,51.9 170.78,51.9 169.64,50.75 149.5,50.75 140.43,41.68 v2(140.43,40.08) ; v2(97.5,32.46) 97.5,35.54 105.38,43.42 105.38,59.52 103.7,61.19 103.7,79.81 104.32,80.43 104.32,82.25 v2(104.57,82.5)
  BOTTOM w0.097: Q1.3 193.89,55.19 194.02,55.05 194.02,53.93 194.41,53.55 v2(194.41,53.42) ; U2.BB43 227.49,53.04 v3(227.81,53.04)
SMB_DATA_GPU: length 22.8
  TOP w0.097: v3(238.39,117.77) 237.86,118.29 235.3,118.29 R2295.1 234.44,118.29 233.37,118.29 233.24,118.16 230.25,118.16 229.33,119.08 v1(225.65,119.08) 225.39,119.08 224.5,119.97 224.5,120.48 224.12,120.86 223.62,120.86 222.85,121.62 221.96,121.62 221.33,120.98 220.82,120.98 220.57,120.73 220.57,120.22 220.19,119.85 Q80.4
  BOTTOM w0.1: v3(238.39,117.77) G2.BH8
SMBALERT_N: length 6.4
  TOP w0.097: v3(227.55,52.4) 227.43,52.28 v1(227.43,51.01) 227.43,49.86 225.65,48.09 R169.2
  BOTTOM w0.097: U2.BB41 227.73,52.58 v3(227.55,52.4)
SML0_CLK: length 4.2
  BOTTOM w0.097: U2.AY44 226.69,53.64 226.69,53.83 226.49,54.03 225.5,54.03 225.14,53.67 223.69,53.67 R150.1
SML0_DATA: length 7.6
  TOP w0.097: R151.1 227.43,48.44 v1(228.59,49.61) 229.71,50.73 229.71,52.66 229.15,53.22 v3(229.08,53.22)
  BOTTOM w0.097: U2.BB39 229.08,52.82 229.08,53.17 229.08,53.17 v3(229.08,53.22)
SML0ALERT_N: length 9.4
  TOP w0.097: v3(229.08,53.93) 229.46,53.55 229.46,53.42 230.47,52.4 230.47,50.63 228.31,48.47 v3(228.31,48.09) R372.1
  BOTTOM w0.097: R372.1 v3(228.31,48.09) ; U2.BA40 228.62,53.47 v3(229.08,53.93)
SML1_CLK: length 29.5
  TOP w0.097: v3(227.81,53.8) v1(227.31,53.3) 227.17,53.17 224.2,53.17 R158.1
  IN08 w0.091: v2(222.6,43.9) 223.23,44.53 224.38,44.53 226.92,47.07 229.58,47.07 230.85,48.34 230.85,51.51 229.84,52.53 228.82,52.53 228.44,52.91 228.44,53.17 v3(227.81,53.8)
  BOTTOM w0.097: v3(227.81,53.8) 227.96,53.96 U2.AW42 ; Q2.6 217.91,44.28 218.08,44.11 218.08,43.36 218.3,43.13 221.83,43.13 v2(222.6,43.9)
SML1_DATA: length 15.2
  TOP w0.097: v3(224.89,54.05) 224.5,53.67 223.82,53.67 R159.1
  IN08 w0.091: v2(221.58,52.48) 223.31,52.48 v3(224.89,54.05)
  BOTTOM w0.097: U2.AW45 225.12,54.29 v3(224.89,54.05) ; v2(221.58,52.48) 221.53,52.48 219.02,49.97 219.02,46.31 218.91,46.2 Q2.3
SNUB_3V: length 1.3
  TOP w0.457: PR310.2 PC313.1
SNUB_5V: length 1.6
  TOP w0.508: PC314.1 37.69,6.62 PR311.2
SPDIF_OUT: length 2
  TOP w0.254: TP103.1 283.03,36.3 283.53,36.3 284.03,35.81 U7.2
SPK_CON_L+: length 36
  TOP w0.508: v2(294.64,63.07) 294.85,62.87 C356.2
  TOP w0.762: R68.1 279.88,40.4 279.88,40.47 v2(280.26,40.85)
  IN03 w0.762: v2(294.64,63.07) 294.94,63.07 295.62,62.39 295.62,61.43 295.16,60.96 294.91,60.96 291.43,57.48 291.43,52.62 289.27,50.46 289.27,44.02 287.37,42.12 281.53,42.12 v2(280.26,40.85)
  BOTTOM w0.508: JSPKR1.2 v2(294.64,63.07)
SPK_CON_L-: length 34.5
  TOP w0.508: v2(294.64,61.82) 294.79,61.98 C357.2
  TOP w0.762: R69.1 v2(278.35,40.85)
  IN03 w0.762: v2(278.35,40.85) 278.99,40.85 281.15,43.01 286.86,43.01 288.39,44.53 288.39,51.01 290.42,53.04 290.42,57.74 294.5,61.82 v2(294.64,61.82)
  BOTTOM w0.508: JSPKR1.1 v2(294.64,61.82)
SPK_CON_R+: length 49.2
  TOP w0.508: v2(294.64,65.57) 294.81,65.41 C359.2
  TOP w0.762: v2(268.07,42.62) 267.41,42.62 v1(266.05,41.27) 265.4,40.62 R66.1
  IN03 w0.762: v2(268.07,42.62) 268.19,42.5 272.52,42.5 274.16,44.14 274.16,52.93 278.81,57.58 278.81,60.02 280.72,61.93 288.38,61.93 291.86,65.41 294.47,65.41 v2(294.64,65.57)
  BOTTOM w0.508: JSPKR1.4 v2(294.64,65.57)
SPK_CON_R-: length 47.1
  TOP w0.508: C355.2 294.83,64.52 v2(294.64,64.32)
  TOP w0.762: R67.1 267.98,41.35 v2(268.07,41.35)
  IN03 w0.762: v2(294.64,64.32) 294.45,64.52 292.23,64.52 288.75,61.04 281.09,61.04 279.75,59.7 279.75,57.1 275.05,52.4 275.05,43.77 272.89,41.61 268.32,41.61 v2(268.07,41.35)
  BOTTOM w0.508: JSPKR1.3 v2(294.64,64.32)
SPK_L+: length 2.7
  TOP w0.097: U7.49 288.33,37.65 287.8,38.18 287.8,38.59 288.39,39.17 v1(288.39,39.32)
SPK_L-: length 3.5
  TOP w0.097: U7.50 287.93,37.69 287.42,38.21 v1(287.42,38.36) 287.42,38.56 287.92,39.06 287.92,39.49 TP92.1
SPK_R+: length 18.6
  TOP w0.279: U7.47 289.13,38.21 v3(289.3,38.38)
  TOP w0.508: v2(276.7,42.9) 276.75,42.9 277.24,42.42 R343.2
  IN10 w0.762: v3(289.3,38.38) 289.3,38.78 288.64,39.44 288.64,41.61 286.99,43.26 277.06,43.26 v2(276.7,42.9)
SPK_R-: length 17.2
  TOP w0.279: U7.48 288.73,38.04 288.33,38.43 v2(288.21,38.43)
  TOP w0.508: R339.2 275.86,42.42 276.4,41.89 v2(276.65,41.89)
  IN10 w0.762: v2(288.21,38.43) 287.62,39.02 287.62,41.1 286.48,42.24 277.59,42.24 277.24,41.89 v2(276.65,41.89)
SRTCRST_N: length 5.8
  TOP w0.097: R160.1 243.17,48.59 v3(242.79,48.97)
  BOTTOM w0.097: U2.BB10 243.3,52.55 243.3,51.32 242.97,50.99 242.97,50.27 243.17,50.07 243.17,49.63 242.79,49.25 v3(242.79,48.97) 242.77,48.95 C187.1
SSD1_DAS: length 3.5
  TOP w0.097: TP99.1 96.06,43.28 v2(95.7,43.64)
  BOTTOM w0.097: JSSD1.10 96.93,43.42 96.93,43.42 95.92,43.42 v2(95.7,43.64)
SSD2_DAS_DSS: length 2.8
  TOP w0.097: v2(100.17,67.39) 100.6,67.39 TP100.1
  BOTTOM w0.097: v2(100.17,67.39) 99.77,67.79 JSSD2.10
STRAP0: length 17.9
  TOP w0.097: v3(236.29,114.27) 236.2,114.27 235.55,113.62 234.16,113.62 233.9,113.87 231.24,113.87 230.09,115.01 225.9,115.01 v1(224.5,113.62) 224,113.11 R2162.1 223.44,112.8 223.23,112.6 221.53,112.6 R2156.2
  BOTTOM w0.097: v3(236.29,114.27) 236.58,114.57 G2.BL3
STRAP1: length 17.5
  TOP w0.097: R2157.2 221.48,114.45 223.16,114.45 223.44,114.18 R2163.1 224.12,114 v1(225.01,114.89) 225.36,115.24 230.38,115.24 231.49,114.13 234.79,114.13 235.17,114.51 235.82,114.51 v3(236.29,114.97)
  BOTTOM w0.097: G2.BL4 236.58,115.27 v3(236.29,114.97)
STRAP2: length 16.6
  TOP w0.097: R2158.2 221.53,114.76 223.23,114.76 223.44,114.96 R2164.1 223.92,115.27 224.11,115.46 226.09,115.46 v1(226.41,115.78) 226.98,115.78 227.3,115.46 230.53,115.46 231.62,114.38 234.66,114.38 235.25,114.97 v3(235.58,114.97)
  BOTTOM w0.097: v3(235.58,114.97) 235.88,115.27 G2.BM4
STRAP3: length 16.6
  TOP w0.097: R2159.2 221.71,116.16 222.22,116.67 223.23,116.67 223.44,116.46 R2165.1 v1(224.63,116.16) 227.28,116.16 227.75,115.69 230.69,115.69 231.74,114.63 234.54,114.63 235.3,115.4 235.31,115.4 v3(235.58,115.67)
  BOTTOM w0.097: G2.BM5 235.88,115.97 v3(235.58,115.67)
STRAP4: length 19
  TOP w0.097: v3(236.99,115.67) 236.55,116.11 235.49,116.11 234.27,114.89 231.87,114.89 230.85,115.91 228.06,115.91 226.8,117.17 v1(226.03,117.17) 225.52,116.67 224.5,116.67 223.74,117.43 R2166.1 222.9,116.89 222.06,116.89 221.84,116.67 221.41,116.67 R2160.2
  BOTTOM w0.097: G2.BK5 v3(236.99,115.67)
STRAP5: length 19.9
  TOP w0.097: R2161.2 221.89,118.8 223.24,118.8 223.44,118.6 R2167.1 224.07,117.68 v1(224.5,117.68) 226.66,117.68 228.21,116.13 231.01,116.13 232,115.14 234.24,115.14 235.41,116.31 237.04,116.31 v3(237.69,115.67)
  BOTTOM w0.097: G2.BJ5 v3(237.69,115.67)
SUSACK_N: length 3.8
  BOTTOM w0.097: TP72.1 239.34,49.61 238.98,49.96 238.98,51.26 239.34,51.62 239.34,52.3 238.97,52.67 U2.BB19
SUSCLK: length 22.1
  TOP w0.097: R456.2 256.43,63.58 v2(256.31,63.45) ; R148.1 241.9,56.98 v3(241.78,56.85)
  IN05 w0.091: v3(241.78,56.85) 241.78,57.99 242.03,58.25 242.03,58.75 242.41,59.13 244.06,59.13 244.95,58.25 247.11,58.25 248.13,59.26 248.13,59.64 248.38,59.9 251.05,59.9 252.7,61.55 255.11,61.55 255.62,62.06 255.62,62.77 v2(256.31,63.45)
  BOTTOM w0.097: U2.AN15 241.53,56.85 v3(241.78,56.85)
SUSON: length 608.8
  TOP w0.097: v1(28.67,48.49) 28.29,48.87 R258.2 ; v2(205.2,150.45) 205.33,150.57 v1(205.33,151.26) PR1317.1 ; R496.1 21.13,68.96 v2(21.69,68.41) ; PR425.2 208.27,111.18 v2(208.12,111.33) ; PR1408.1 118.71,64.72 v2(118.21,64.21)
  IN03 w0.091: v2(47.75,16.13) 47.75,15.11 50.8,12.06 57.15,12.06 58.39,10.83 v2(58.39,8.72)
  IN05 w0.091: v2(114.65,31.97) 111.28,31.97 110.86,31.55 99.77,31.55 97.85,29.64 94.83,29.64 93.87,28.68 82.8,28.68 82.23,28.11 74.33,28.11 71.95,25.73 64.41,25.73 62.54,27.6 57.25,27.6 56.34,28.51 55.86,28.51 49.3,35.08 49.3,37.62 46.45,40.47 40.48,40.47 39.62,39.6 39.29,39.6 38.63,38.94 34.39,38.94 32.53,40.8 29.99,40.8 28.71,42.08 28.71,45.58 29.08,45.95 29.08,48.09 v1(28.67,48.49) ; v2(193.14,45.42) 193.93,46.22 212.55,46.22 212.87,45.89 214.52,45.89 215.35,45.06 224.53,45.06 225.25,44.34 228.9,44.34 229.45,43.79 233.77,43.79 236.05,41.51 249.93,41.51 254.39,45.96 264.89,45.96 266.76,47.83 272.13,47.83 274.38,45.58 276.79,45.58 279.33,43.04 290.1,43.04 290.51,42.62 293.25,42.62 296.52,39.35 296.96,39.35 300.94,35.37 300.94,27.48 302.01,26.42 302.76,26.42 v2(304.13,25.05)
  IN08 w0.091: v2(206.09,60.15) 205.94,60 204.18,60 200.37,56.18 200.37,46.46 197.91,44 194.55,44 v2(193.14,45.42) 191.93,46.62 171.39,46.62 168.91,49.1 119.5,49.1 113.38,42.98 113.38,34.24 114.65,32.97 v2(114.65,31.97) ; v2(208.12,111.33) 207.99,111.2 200.25,111.2 193.52,117.94 193.52,123.78 199.36,129.62 199.36,144.61 v2(205.2,150.45) ; v2(21.69,68.41) 21.69,68.15 22.83,67.01 22.83,55.96 23.59,55.2 24.61,55.2 25.61,54.2 25.61,52.16 28.67,49.1 v1(28.67,48.49)
  IN10 w0.091: v2(47.75,16.13) 46.78,16.13 40.23,22.69 34.46,22.69 30.83,26.32 30.83,37.67 28.67,39.83 28.67,45.29 28.16,45.8 28.16,47.98 v1(28.67,48.49) ; v2(118.21,64.21) 121.89,60.53 121.89,54.94 122.02,54.82 122.02,52.15 117.95,48.09 117.95,37.16 114.52,33.73 114.52,32.09 v2(114.65,31.97)
  BOTTOM w0.076: 31.97,52.17 32.51,52.17 32.77,51.91 U5.E2
  BOTTOM w0.097: R873.1 58.34,8.77 v2(58.39,8.72) ; v2(206.09,60.15) 206.09,64.6 210.2,68.71 210.2,83.72 209.26,84.66 207.87,84.66 205.07,87.46 205.07,95.2 206.09,96.22 206.09,101.68 206.37,101.96 207.58,101.96 208.12,102.51 208.12,106.76 209.62,108.25 209.62,110.47 208.76,111.33 v2(208.12,111.33) ; 31.97,52.17 31.95,52.17 30.51,50.73 29.71,50.73 29.43,50.45 29.43,49.99 28.8,49.36 28.8,48.62 v1(28.67,48.49) ; v2(304.13,25.05) 303.4,25.78 301.9,25.78 301.55,25.43 301.21,25.43 301.06,25.58 JIO1.47
SUSON_N: length 3.1
  TOP w0.097: PR1406.1 117.7,66.88 117.49,67.08 117.49,67.36 PQ1404.6 116.88,67.4 116.76,67.52 v1(116.76,67.62) 116.76,67.77 116.88,67.9 PQ1404.5
SUSPWRDNACK: length 3.2
  BOTTOM w0.097: TP73.1 239.01,49.23 239.01,49.66 238.78,49.88 238.78,51.45 U2.BD19
SW1_3PH_A: length 44.6
  TOP w0.254: PR1145.2 125,201.95 125.7,201.25 v2(125.7,200.99) ; PR1185.1 133.39,194.29 v2(133.34,194.24)
  IN05 w0.203: v2(151.2,178.26) 150.92,177.98 150.64,177.98 150.44,178.18 150.44,180.14 149.98,180.6 141.14,180.6 132.18,189.56 132.18,191.98 132.43,192.23 132.43,193.37 133.29,194.24 v2(133.34,194.24)
  IN05 w0.254: v2(125.7,200.99) 126.71,199.98 126.71,198.71 127.73,197.69 128.24,197.69 129.51,196.42 131.29,196.42 133.34,194.36 v2(133.34,194.24)
  BOTTOM w0.254: PR1504.2 151.25,178.31 v2(151.2,178.26)
SW2_3PH_A: length 55.2
  IN03 w0.254: v2(130.99,199) 131.79,198.2 131.79,195.28 130.04,193.53 130.04,188.37 131.24,187.18 135.07,187.18 145.89,176.36 151.45,176.36 153.1,178.01 163.8,178.01 164.41,178.62 v2(164.41,178.64)
  BOTTOM w0.203: v2(164.41,178.64) 164.74,178.31 PR1513.2
  BOTTOM w0.254: PR1149.2 PR1184.1 131.34,198.66 v2(130.99,199)
SW2_3V:
  vias: v1(50.39,10.52)
SW3_3PH_A: length 88.5
  IN03 w0.254: v2(188.44,178.51) 188.44,178.26 188.18,178.01 186.84,178.01 184.86,176.03 184.86,171.83 184.05,171.02 151.61,171.02 148.56,174.07 143.86,174.07 133.19,184.74 131.41,184.74 131.16,184.48 130.19,184.48 129.1,185.58 129.1,197.03 129.64,197.56 129.64,198.45 v2(129.13,198.96)
  BOTTOM w0.203: v2(188.44,178.51) 188.64,178.31 PR1604.2
  BOTTOM w0.254: v2(129.13,198.96) 129.13,199.15 PR1151.2 PR1183.1
SW4_3PH_A: length 85.7
  TOP w0.254: PR1147.2 122.59,201.95 122.14,201.5 v2(122.14,200.99) ; PR1205.1 130.65,185.12 v2(130.7,185.07)
  IN03 w0.254: v2(176.37,178.51) 176.78,178.1 177.29,178.1 178.15,177.24 178.15,173.94 176.5,172.29 151.86,172.29 149.32,174.83 144.49,174.83 133.95,185.37 131.39,185.37 131.19,185.17 130.8,185.17 v2(130.7,185.07)
  IN05 w0.254: v2(122.14,200.99) 121.91,200.76 121.91,196.27 123.54,194.64 128.24,194.64 129,193.88 129,186.31 130.25,185.07 v2(130.7,185.07)
  BOTTOM w0.203: PR1612.2 176.57,178.31 v2(176.37,178.51)
SW_1PH: length 89.3
  TOP w0.254: PR1212.1 131.54,183.85 v2(131.74,183.65)
  IN03 w0.254: v2(199.36,178.51) 200.1,177.78 200.1,168.46 199.51,167.87 187.29,167.87 186.43,168.74 151.73,168.74 147.95,172.52 142.36,172.52 131.92,182.96 131.92,183.47 v2(131.74,183.65)
  BOTTOM w0.203: PR1618.2 199.56,178.31 v2(199.36,178.51)
  BOTTOM w0.254: v2(131.74,183.65) 130.79,183.65 PR1154.2
SWD_CLK: length 4.8
  TOP w0.089: R2092.1 29.81,72.47 v1(30.19,72.85) 30.32,72.72 32.35,72.72 v1(32.99,73.36)
  BOTTOM w0.089: v1(32.99,73.36) 33.25,73.62 U2007.G4
SWD_DAT: length 3.4
  TOP w0.089: v1(33.5,73.36) 33.36,73.23 33.36,73.2 33.14,72.98 33.12,72.98 32.48,72.34 v1(32.25,72.34) 31.77,72.34 R2091.1
  BOTTOM w0.089: v1(33.5,73.36) 33.75,73.61 U2007.F4
SWF_AVDD: length 12.2
  TOP w0.254: v2(278.86,50.12) 279.06,50.32 U9.7
  BOTTOM w0.356: v2(278.86,50.12) 278.99,50.24 C366.2
  BOTTOM w0.457: R329.1 282.79,46.13 R335.1 280.18,46.13 279.62,46.69 278.35,46.69 277.34,47.7 277.34,49.48 277.97,50.12 v1(278.07,50.12) v2(278.86,50.12)
SWF_CON_R+: length 4.6
  TOP w0.254: v1(294.48,50.88) 294.02,50.42 v2(293.85,50.42)
  TOP w0.508: v2(293.85,50.42) C377.2 292.34,50.42 R71.1
  BOTTOM w0.762: v2(293.85,50.42) 293.84,50.42 293.25,51.01 JSWF1.2
SWF_CON_R-: length 6
  TOP w0.254: v2(293.85,49.37) 294.09,49.37 v1(294.48,48.97)
  TOP w0.508: v2(293.85,49.37) 293.65,49.56 C378.2 292.34,49.56 R70.1
  BOTTOM w0.762: v2(293.85,49.37) 294.11,49.37 294.74,49.99 294.74,51.13 294.5,51.37 JSWF1.1
SWF_GAIN0: length 4.5
  TOP w0.254: U9.5 279.14,51.62 278.73,52.02 278.73,53.04 278.28,53.5 R345.2 R341.1
SWF_GAIN1: length 3.4
  TOP w0.254: U9.6 278.82,50.97 278.15,50.3 R348.2 R342.1
SWF_PLIMIT: length 3.9
  TOP w0.254: v2(278.86,48.21) 279.01,48.37 U9.10
  BOTTOM w0.254: v2(278.86,48.21) 278.66,48.01 R332.2 ; v2(278.86,48.21) 279.11,48.47 C375.2 ; v2(278.86,48.21) 279.5,47.58 R331.1
SWF_R+: length 9.1
  TOP w0.305: 287.37,51.34 287.06,51.34 286.69,50.97 U9.23 ; U9.25 288.2,52.27 v1(288.18,52.25) 288.18,51.51 C374.1
  TOP w0.457: 287.37,51.34 C374.1
  TOP w0.508: C374.1 288.56,51.34 289.48,50.42 R333.1 290.53,50.42 R71.2
SWF_R-: length 8.5
  TOP w0.305: C376.1 288,48.21 287.75,47.96 286.98,47.96 286.73,47.72 U9.18 ; 287.37,48.64 287.06,48.64 286.69,49.02 U9.20
  TOP w0.457: 287.37,48.64 C376.1
  TOP w0.508: C376.1 288.44,48.64 289.35,49.56 R334.1 290.53,49.56 R70.2
SWF_RINN: length 4.8
  TOP w0.305: U9.11 279.18,47.72 279.11,47.65 278.15,47.65 277.84,47.96 v1(276.57,47.96)
  TOP w0.635: C381.2 276.19,47.58 v1(276.57,47.96)
SWF_RINP: length 2.9
  TOP w0.254: C384.2 277.26,47.07 v1(278.3,47.07) U9.12
SWF_SD_N: length 4.2
  TOP w0.254: R330.1 278.35,54.44 278.57,54.22 ; U9.2 278.84,53.57 278.57,53.83 278.57,54.22 ; 278.57,54.22 U9.1
SWF_VCLAMP: length 3
  TOP w0.254: v2(278.86,49.23) 279.07,49.02 U9.9
  BOTTOM w0.254: C373.2 278.99,49.36 v2(278.86,49.23) 278.56,48.92 R332.1
SYS_PEX_RST_MON_N: length 130.1
  TOP w0.097: R999.2 248.38,109.81 v2(247.62,110.57) 246.98,111.2 245.84,111.2 245.08,111.97 244.16,111.97 243.27,112.86 241.14,112.86 240.89,113.11 240.61,113.11 v3(240.13,112.63) ; U62.2 303.12,76.15 302.86,76.41 301.99,76.41 v2(301.83,76.25) 301.48,75.9 300.07,75.9 v1(299.43,75.26) 299.43,74.25 300.2,73.49 R2171.1
  IN10 w0.091: v2(247.62,110.57) 245.43,108.39 245.43,105.34 244.95,104.85 244.95,100.99 241.9,97.94 241.9,84.66 243.39,83.17 250.93,83.17 251.56,82.54 265.69,82.54 266.16,83.01 275.69,83.01 278.23,85.55 278.99,85.55 281.65,82.88 297.13,82.88 299.55,85.3 303.37,85.3 303.63,85.04 306.04,85.04 307.18,83.9 307.18,78.06 305.4,76.28 301.87,76.28 v2(301.83,76.25)
  BOTTOM w0.1: v3(240.13,112.63) 240.38,112.88 240.38,113.11 240.44,113.17 240.44,113.37 240.79,113.72 G2.BE2
SYS_PWROK: length 250.1
  TOP w0.089: 34.51,46.69 R263.2
  TOP w0.097: v3(248.51,53.93) 248.58,53.85 R146.1 ; 34.51,46.69 v1(34.61,46.59) 36.42,44.78 36.42,42.5 v2(37.31,41.61)
  IN03 w0.091: v2(153.13,38.81) 152.37,39.58 152.37,41.74 146.58,47.52 120.18,47.52 107.22,34.56 95.98,34.56 95.24,33.83 87.56,33.83 86.96,33.23 82.52,33.23 80.49,35.26 64.48,35.26 63.47,36.27 50.26,36.27 50.13,36.4 47.45,36.4 47.06,36.79 47.06,38.46 46.83,38.69 44.42,38.69 42.13,40.97 40.61,40.97 39.59,41.99 37.69,41.99 v2(37.31,41.61)
  IN10 w0.091: v3(248.51,53.93) 249.05,53.39 249.05,50.44 247.58,48.97 245.59,48.97 244.57,47.96 242.92,47.96 242.28,47.32 242.28,46.05 238.35,42.12 216.43,42.12 212.67,45.89 206.26,45.89 203,42.62 155.67,42.62 153.64,40.59 153.64,39.32 v2(153.13,38.81)
  BOTTOM w0.097: v3(248.51,53.93) 248.22,53.93 U2.AY1
SYS_PWROK_R: length 2
  TOP w0.089: R263.1 34.22,50.11 v1(34.22,50.88)
  BOTTOM w0.089: v1(34.22,50.88) 34.22,50.99 34.63,51.41 U5.D6
SYS_RESET_N: length 5.5
  TOP w0.097: R143.1 v3(250.54,51.64)
  BOTTOM w0.097: U2.AW1 248.04,54.31 248.68,54.31 249.27,53.72 249.27,52.91 v3(250.54,51.64) R143.1
TBT_BATLOW_N: length 4.6
  TOP w0.097: R2036.1 48.74,94.06 48.48,93.81 48.48,93.3 47.97,92.79 v1(47.85,92.79)
  BOTTOM w0.076: 48.36,91.58 48.36,90.89 U2005.F2
  BOTTOM w0.102: v1(47.85,92.79) 48.36,92.27 48.36,91.58
TBT_CIO_PLUG_EVENT_N: length 204.4
  TOP w0.097: v2(56.27,96.54) 56.03,96.3 R2031.1
  IN03 w0.091: v3(224.12,67.14) 222.6,65.61 221.08,65.61 217.9,62.44 214.6,62.44 210.15,66.88 129.51,66.88 127.6,68.79 119.35,68.79 118.46,69.68 115.67,69.68 114.27,71.07 103.85,71.07 103.22,70.44 89.12,70.44 85.82,67.14 81.38,67.14 78.45,70.06 73.88,70.06 73.12,70.82 68.8,70.82 68.42,71.2 67.02,71.2 v2(66.39,70.56)
  IN08 w0.091: v2(56.27,96.54) 56.59,96.22 60.55,96.22 60.8,95.96 60.8,93.42 60.17,92.79 60.17,86.57 62.07,84.66 62.07,78.31 65.5,74.88 65.5,71.45 v2(66.39,70.56)
  BOTTOM w0.097: v3(224.12,67.14) 224.5,67.14 224.89,67.52 225.65,67.52 226.26,68.13 227.05,68.13 U2.L43
TBT_CIO_PLUG_EVENT_N_R: length 8.3
  TOP w0.097: R2031.2 56.94,95.41 v2(55.98,94.44)
  BOTTOM w0.076: 55.62,92.56 54.35,91.29 54.35,90.89 U2005.W2
  BOTTOM w0.097: v2(55.98,94.44) 55.98,94.62 R2053.1
  BOTTOM w0.102: 55.62,92.56 v1(55.62,92.84) 55.59,92.87 55.59,94.06 v2(55.98,94.44)
TBT_CIO_PWR_EN: length 204.2
  TOP w0.097: R2041.2 63.42,93.88 64.05,94.52 v2(64.23,94.52)
  IN03 w0.091: v2(67.15,70.56) 72.74,70.56 75.03,68.28 77.95,68.28 78.2,68.53 79.6,68.53 81.25,66.88 85.95,66.88 89.12,70.06 105.7,70.06 106.34,70.69 110.56,70.69 111.58,69.68 115.16,69.68 115.4,69.43 118.32,69.43 119.22,68.53 127.52,68.53 129.43,66.63 210.03,66.63 214.6,62.06 218.15,62.06 220.19,64.09 224.38,64.09 225.65,65.36 227.91,65.36 228.17,65.1 231.11,65.1 v3(231.62,65.61)
  IN08 w0.091: v2(67.15,70.56) 66.26,71.45 66.26,75.26 62.45,79.07 62.45,84.66 60.67,86.44 60.67,87.96 61.18,88.47 61.18,89.23 60.93,89.49 60.93,92.92 62.45,94.44 64.1,94.44 64.18,94.52 v2(64.23,94.52)
  BOTTOM w0.097: v3(231.62,65.61) 231.62,66.05 U2.R35
TBT_EE_CLK: length 56.1
  IN03 w0.091: v2(50.51,99.14) 52.67,96.98 55.21,96.98 56.48,95.71 58.26,95.71 59.15,94.82 59.15,90.38 58.9,90.12 57.5,90.12 v1(57.12,89.74)
  IN08 w0.091: v1(57.12,89.74) 57.12,83.01 55.34,81.23 43.78,81.23 42.39,79.84 42.39,78.82 39.21,75.64 39.08,75.64 38.58,75.14 38.58,71.2 39.14,70.64 39.14,69.88 v1(39.16,69.85)
  BOTTOM w0.076: U2005.AB4 55.72,89.51 56.54,89.51
  BOTTOM w0.097: v1(39.16,69.85) 39.16,69.88 39.59,70.31 39.59,70.77 R2287.1 ; 56.54,89.51 56.77,89.74 v1(57.12,89.74) ; U2012.6 v2(50.51,99.14)
TBT_EE_CS_N: length 56.2
  TOP w0.097: R2019.1 53.05,95.96 v2(52.04,94.95)
  IN03 w0.091: v1(57.12,90.5) 56.74,90.88 56.74,92.03 55.47,93.3 55.47,95.4 54.65,96.22 53.05,96.22 52.04,95.2 v2(52.04,94.95)
  IN08 w0.091: v1(37.84,68.51) 38.42,68.51 39.59,69.68 39.59,70.95 38.83,71.71 38.83,74.76 43.07,79 43.07,79.96 44.09,80.98 55.72,80.98 57.47,82.73 57.47,90.15 v1(57.12,90.5)
  BOTTOM w0.076: U2005.AC3 56.5,90.2
  BOTTOM w0.089: 56.5,90.2 56.76,90.46
  BOTTOM w0.097: R2290.1 39.54,68.74 39.31,68.51 v1(37.84,68.51) ; 56.76,90.46 56.81,90.5 v1(57.12,90.5) ; U2012.1 53.05,93.93 v2(52.04,94.95)
TBT_EE_DI: length 61.7
  IN03 w0.091: v1(57.88,91.27) 58.77,92.15 58.77,94.69 58.01,95.46 56.23,95.46 54.96,96.73 51.66,96.73 v2(49.24,99.14)
  IN08 w0.091: v1(57.88,91.27) 58.26,91.27 58.64,90.88 58.64,85.8 59.66,84.79 59.66,81.99 56.48,78.82 44.42,78.82 44.16,78.57 43.78,78.57 40.74,75.52 40.74,73.49 40.35,73.1 40.35,69.29 v1(40.74,68.91)
  BOTTOM w0.076: 56.76,90.78 56.41,90.43 55.86,90.43 55.63,90.2 U2005.AB3
  BOTTOM w0.097: R2288.1 40.05,71.71 40.74,71.02 v1(40.74,70.44) v1(40.74,68.91) ; U2012.5 v2(49.24,99.14) ; 56.76,90.78 56.86,90.88 57.5,90.88 v1(57.88,91.27)
TBT_EE_DO: length 53.7
  TOP w0.097: R2018.1 52.17,96.09 v2(51.53,95.46)
  IN03 w0.091: v1(57.88,90.5) 57.5,90.88 57.5,92.28 58.13,92.92 58.13,94.69 57.88,94.95 56.36,94.95 54.83,96.47 52.8,96.47 51.78,95.46 v2(51.53,95.46)
  IN08 w0.091: v1(39.47,73.36) 39.47,74.76 43.67,78.96 44.05,78.96 44.42,79.33 56.36,79.33 58.26,81.23 58.26,90.12 v1(57.88,90.5)
  BOTTOM w0.076: 56.61,89.87 56.48,89.74 U2005.AC4
  BOTTOM w0.089: 56.61,89.87 56.76,90.02
  BOTTOM w0.097: v2(51.53,95.46) 51.53,94.44 51.78,94.19 U2012.2 ; v1(39.47,73.36) 40.35,73.36 v1(40.74,72.98) 40.35,72.6 R2289.1 ; v1(57.88,90.5) 57.55,90.17 56.92,90.17 56.76,90.02
TBT_EE_WP_N: length 15.1
  TOP w0.097: v2(51.15,96.09) 51.28,96.22 R2017.1
  IN03 w0.091: v2(51.15,96.09) 51.02,95.96 51.02,95.08 51.66,94.44 52.93,94.44 53.82,95.33 53.82,95.46 54.02,95.66 54.88,95.66 55.21,95.33 55.21,93.42 v1(53.94,92.15)
  BOTTOM w0.076: U2005.V1 53.66,91.51 53.94,91.8 53.94,92.05
  BOTTOM w0.097: v2(51.15,96.09) 50.51,95.46 U2012.3 ; 53.94,92.05 v1(53.94,92.15)
TBT_FORCE_PWR: length 241.6
  TOP w0.089: R2097.1 27.86,80.67 v2(27.65,80.47)
  TOP w0.097: v2(24.99,86.19) 24.28,86.9 R2039.2
  IN03 w0.089: 27.4,80.72 v2(27.65,80.47)
  IN03 w0.091: v2(24.99,86.19) 24.99,85.17 26.64,83.52 26.64,81.49 27.4,80.72 ; v2(26.38,67.64) 30.83,63.2 43.66,63.2 45.31,64.85 50.26,64.85 52.42,62.69 55.59,62.69 59.91,67.01 74.39,67.01 75.41,68.02 78.2,68.02 78.84,67.39 80.23,67.39 81.12,66.5 86.07,66.5 89.24,69.66 105.62,69.66 106.39,70.44 110.46,70.44 111.47,69.42 114.95,69.42 115.16,69.21 117.91,69.21 119.6,67.52 127.35,67.52 128.49,66.37 209.9,66.37 214.47,61.8 218.28,61.8 220.31,63.83 224.5,63.83 225.77,65.1 227.81,65.1 228.06,64.85 231.24,64.85 v3(231.62,64.47)
  IN08 w0.089: v2(27.65,80.47) 27.91,80.22 27.91,71.07 26.97,70.13
  IN08 w0.091: v2(26.38,67.64) 26.38,69.55 26.97,70.13
  BOTTOM w0.097: U2.U35 231.62,64.94 v3(231.62,64.47)
TBT_FORCE_PWR_R: length 28
  TOP w0.097: R2039.1 R2040.1 v2(25.19,88.93)
  IN05 w0.089: 44.9,90.89 44.92,90.89 44.92,90.88 48.23,90.88 48.62,90.49 v1(48.62,89.63)
  IN05 w0.091: 44.9,90.89 44.8,90.89 44.29,91.39 38.58,91.39 36.11,88.93 v2(25.19,88.93)
  BOTTOM w0.178: U2005.H4 v1(48.62,89.63)
TBT_HDMI_DDC_CLK: length 6.5
  BOTTOM w0.076: U2005.Y2 54.8,90.89 54.8,91.24 55.76,92.19
  BOTTOM w0.097: 56.1,92.54 56.74,93.17 v1(56.74,93.68) 56.74,93.81 v2(57.37,94.44) 57.63,94.19 57.63,93.73 R2283.1
  BOTTOM w0.102: 55.76,92.19 56.1,92.54
TBT_HDMI_DDC_DATA: length 7.5
  BOTTOM w0.076: 56.03,92.71 54.58,91.26 U2005.Y1
  BOTTOM w0.097: 56.03,92.92 56.03,93.86 v2(56.61,94.44) 56.61,94.82 v1(57.37,95.58) 58.19,94.77 R2284.1
  BOTTOM w0.102: 56.03,92.71 56.03,92.92
TBT_HOLD_N: length 2.2
  TOP w0.097: R2020.1 51.96,99.32 v2(51.78,99.14)
  BOTTOM w0.097: U2012.7 v2(51.78,99.14)
TBT_I2C_SCL: length 51.3
  TOP w0.097: v2(54.71,95.13) 55.16,95.58 R2028.1
  IN03 w0.089: 37.94,80.72 37.81,80.6 37.81,73.64 36.77,72.6 35.91,72.6 35.02,71.71 35.02,70.69 v1(34.64,70.31)
  IN03 w0.091: 37.94,80.72 41.12,83.9 41.12,86.19 39.72,87.58 39.72,93.04 40.48,93.81 46.07,93.81 46.45,94.19 53.94,94.19 54.25,94.49 54.25,94.67 v2(54.71,95.13)
  BOTTOM w0.076: 35,71.83 35,72.63 U2007.D2 ; 53.42,91.29 53.42,90.89 U2005.U2
  BOTTOM w0.102: v2(54.71,95.13) 54.26,94.68 54.26,94.13 54.2,94.06 54.2,92.97 53.56,92.33 53.56,91.75 53.42,91.61 53.42,91.29 ; v1(34.64,70.31) 35.08,70.76 35.08,71.74 35,71.83
TBT_I2C_SDA: length 47
  TOP w0.102: R2026.1 52.93,92.15 v3(53.18,91.9)
  IN03 w0.089: 38.36,80.64 38.07,80.34 38.07,74.12 38.4,73.79 ; v1(33.99,70.31) 34.33,69.97 34.78,69.97 35.27,70.47 35.27,71.58 36.04,72.34 37.84,72.34 38.4,72.9
  IN03 w0.091: v3(53.18,91.9) 52.67,92.41 50.62,92.41 49.09,93.93 47.21,93.93 46.58,93.3 40.61,93.3 40.23,92.92 40.23,87.58 41.37,86.44 41.37,83.65 38.36,80.64 ; 38.4,73.79 38.45,73.74 38.45,72.95 38.4,72.9
  BOTTOM w0.076: 34.77,71.71 34.89,71.58 34.89,71.16 34.67,70.93
  BOTTOM w0.089: U2007.D1 34.75,71.72 34.77,71.71
  BOTTOM w0.102: U2005.U1 53.2,91.89 v3(53.18,91.9) ; 34.67,70.93 34.62,70.93 34,70.31 v1(33.99,70.31)
TBT_PROC_GPIO1: length 24.8
  TOP w0.097: v2(61.82,95.46) 61.82,95.38 R2024.1
  IN03 w0.089: 54.83,91.52 50.13,91.52 49.6,92.05
  IN03 w0.091: v1(47.21,92.79) 47.59,93.17 48.48,93.17 49.6,92.05 ; 54.83,91.52 55.47,91.52 55.85,91.14 55.85,90.12 56.74,89.23 58.52,89.23 60.67,91.39 60.67,92.66 61.06,93.04 61.06,94.69 v2(61.82,95.46)
  BOTTOM w0.076: U2005.E2 47.9,90.89 47.9,91.34 47.54,91.7
  BOTTOM w0.102: 47.54,91.7 47.54,92.46 v1(47.21,92.79)
TBT_RBIAS: length 1.1
  TOP w0.254: v1(48.62,88.98) 48.62,88.98 R2035.2
  BOTTOM w0.178: U2005.H6 48.62,88.98 v1(48.62,88.98)
TBT_RESET_N: length 17.4
  TOP w0.097: R2030.2 v2(26.13,87.96)
  IN10 w0.089: v1(34.08,79.53) 33.73,79.53 33.12,80.14 33.12,80.72
  IN10 w0.091: v2(26.13,87.96) 26.89,88.73 28.42,88.73 33.12,84.03 33.12,80.72
  BOTTOM w0.089: v1(34.08,79.53) 34.08,78.62 33.75,78.29 U2007.F11
TBT_RESET_N_R: length 22.2
  TOP w0.097: R2030.1 v2(28.54,87.96)
  IN05 w0.089: 44.9,90.63 44.92,90.63 47.57,90.63 v1(47.97,90.23)
  IN05 w0.091: 44.9,90.63 44.67,90.63 44.16,91.14 38.7,91.14 35.53,87.96 v2(28.54,87.96)
  BOTTOM w0.178: U2005.F4 48.02,90.23 v1(47.97,90.23)
TBT_RSENSE: length 1.2
  TOP w0.254: v1(49.92,88.33) 50.21,88.62 R2035.1
  BOTTOM w0.178: U2005.J6 v1(49.92,88.33)
TBT_SLP_S3_N: length 25.5
  TOP w0.097: v1(47.32,90.23) 47.72,90.63 47.97,90.63 48.48,91.14 48.48,91.9 v1(48.84,92.26) 49.17,92.59 R2034.1 ; R2033.2 v2(28.54,87.07)
  IN05 w0.089: v1(47.32,90.23) 44.67,90.23
  IN05 w0.091: v2(28.54,87.07) 29.05,87.58 35.46,87.58 38.63,90.76 44.15,90.76 44.67,90.23
  BOTTOM w0.178: v1(47.32,90.23) 47.22,90.34 U2005.D2
TBT_SNK0_CFG1: length 14.9
  TOP w0.097: v2(61.56,90.76) 61.94,91.14 R2082.1
  IN03 w0.089: 54.83,90.63 51.66,90.63 51.22,90.19 v1(51.22,89.63)
  IN03 w0.091: 54.83,90.63 55.09,90.38 55.09,89.87 56.61,88.34 58.9,88.34 61.31,90.76 v2(61.56,90.76)
  BOTTOM w0.178: U2005.N4 v1(51.22,89.63)
TBT_SNK0_DDC_CLK: length 8.3
  TOP w0.089: v1(54.47,89.63) 54.47,89.71 55.36,90.6 v1(55.72,90.6) 55.72,90.6 55.72,91.14 56.25,91.67 56.79,91.67
  TOP w0.097: R2118.1 59.55,91.97 58.45,91.97 58.13,91.65 57.31,91.65 57.29,91.67 56.79,91.67
  BOTTOM w0.178: v1(54.47,89.63) 54.8,89.31 U2005.Y5
TBT_SNK0_DDC_DATA: length 13.7
  TOP w0.097: v2(61.69,89.36) 61.44,89.36 61.18,89.61 R2119.1
  IN03 w0.089: v1(51.87,89.63) 51.89,89.63 53.56,87.96 54.07,87.96
  IN03 w0.091: v2(61.69,89.36) 61.69,88.85 60.17,87.33 54.71,87.33 54.07,87.96
  BOTTOM w0.178: U2005.R4 v1(51.87,89.63)
TBT_SNK1_DDC_CLK: length 1.6
  TOP w0.089: R2054.1 54.48,88.34 v1(54.47,88.33)
  BOTTOM w0.178: v1(54.47,88.33) 54.8,88.01 U2005.Y8
TBT_SRC_CFG1: length 4.8
  TOP w0.097: R2120.2 R2023.1
  TOP w0.102: v1(57.12,92.03) 57.93,92.84 R2023.1
  BOTTOM w0.076: U2005.AA1 55.04,91.21 55.72,91.9 55.85,91.9
  BOTTOM w0.178: v1(57.12,92.03) 55.98,92.03 55.85,91.9
TBT_SRC_HPD: length 3.4
  TOP w0.097: R2121.2 v1(47.85,93.55)
  BOTTOM w0.102: U2005.G1 48.6,92.42 48.36,92.66 48.36,93.04 v1(47.85,93.55)
TBT_SVR_IND:
  vias: v1(45.89,93.86)
TBT_TCK: length 4
  TOP w0.102: v1(53.17,89.63) 53.08,89.72 v1(53.08,90.2) 53.08,90.4 53.59,90.91 53.59,92.61 R2013.1
  BOTTOM w0.178: U2005.T4 v1(53.17,89.63)
TBT_TDI: length 3.9
  TOP w0.102: v1(54.47,90.23) 54.47,90.47 v1(55.87,91.88) 56.48,92.48 R2011.1
  BOTTOM w0.178: U2005.Y4 54.75,89.96 v1(54.47,90.23)
TBT_TDO: length 3.8
  TOP w0.102: v1(53.82,90.26) 53.9,90.26 55.42,91.77 55.42,92.66 R2014.1
  BOTTOM w0.178: U2005.W4 54.12,89.96 53.82,90.26 v1(53.82,90.26)
TBT_TEST_EN: length 1.9
  TOP w0.097: R2025.1 47.2,92.15 v1(47.21,92.14)
  BOTTOM w0.102: v1(47.21,92.14) 47.21,91.65 47.68,91.18 U2005.E1
TBT_TEST_PWG: length 4.4
  BOTTOM w0.076: U2005.AB5 55.73,89.05 56.02,89.05
  BOTTOM w0.089: 56.91,89.05 56.02,89.05 56.02,89.05
  BOTTOM w0.097: 56.91,89.05 56.97,89.11 58.32,89.11 v1(58.67,89.46) 58.83,89.61 R2027.1
TBT_TMS: length 4.3
  TOP w0.102: R2012.1 54.35,92.48 54.35,91.29 v1(54.27,91.21) 53.46,90.4 53.46,89.99 v1(53.82,89.63)
  BOTTOM w0.178: U2005.V4 v1(53.82,89.63)
TBT_TMU_CLK_OUT: length 2.6
  BOTTOM w0.076: 54.32,92.05 54.32,91.89 53.88,91.45 53.88,90.89 U2005.V2
  BOTTOM w0.097: 54.32,92.05 54.32,92.46 R2038.1
TBT_USB_PWR_EN: length 212.1
  TOP w0.089: v1(45.05,87.96) 44.9,87.81
  TOP w0.097: R2043.2 44.6,87.51 44.9,87.81
  IN03 w0.091: v2(51.73,68.08) 59.96,68.08 63.34,71.45 68.68,71.45 69.06,71.07 73.5,71.07 73.63,71.2 77.18,71.2 77.95,70.44 78.45,70.44 81.5,67.39 85.57,67.39 88.87,70.69 103.09,70.69 103.69,71.29 114.4,71.29 115.76,69.93 119.86,69.93 119.95,70.02 125.41,70.02 126.46,71.07 127.6,71.07 128.62,70.06 128.62,68.91 130.43,67.1 210.28,67.1 214.69,62.69 217.77,62.69 220.91,65.83 222.06,65.83 v3(224.12,67.9)
  IN10 w0.091: v2(51.73,68.08) 53.05,69.4 53.05,72.34 51.02,74.37 51.02,76.91 45.43,82.5 45.43,87.58 v1(45.05,87.96)
  BOTTOM w0.097: v3(224.12,67.9) 225.52,67.9 226.02,68.39 U2.L44
TBT_WAKE_N: length 6.1
  TOP w0.097: 58.46,91.21 R2094.1
  TOP w0.102: 58.46,91.21 58.13,90.88 57.63,90.88 57.25,91.27 v3(57.12,91.27)
  IN08 w0.091: v3(57.12,91.27) 56.1,92.28 54.86,92.28 v1(54.86,92.28)
  BOTTOM w0.076: U2005.W1 54.15,91.15 54.15,91.46 54.58,91.9 54.73,92.05 54.73,92.05
  BOTTOM w0.097: 54.73,92.05 54.86,92.18 v1(54.86,92.28)
TBT_XTAL_25_IN: length 7.3
  BOTTOM w0.076: 47.44,80.72 47.44,81.23 U2005.D22
  BOTTOM w0.097: R2010.2 46.17,79.45 47.44,80.72
  BOTTOM w0.102: R2010.2 45.23,79.05 C2048.1 45.23,78.26 45.92,77.58 45.92,76.43 45.76,76.27 Y2001.1
TBT_XTAL_25_OUT: length 5.8
  BOTTOM w0.097: Y2001.3 44.37,77.14 C2046.1 44.72,78.92 R2010.1 45.23,79.96 46.32,79.96 47.22,80.85 U2005.D23
TBTA_CC1: length 29.2
  TOP w0.254: C2130.1 30.21,76.86 29.53,76.86 v1(29.18,77.22) ; v2(18.63,80.99) D59.2 17.74,80.98 v1(14.83,80.98) 14.57,80.98 13.43,79.84 8.86,79.84 8.62,80.07 JTYPC1.A5
  IN03 w0.254: v1(29.18,77.22) 29.1,77.3 28.29,77.3 27.27,78.31 27.27,79.58 26.96,79.9 26.96,80.53 25.37,82.12 19.76,82.12 v2(18.63,80.99)
  BOTTOM w0.203: U2007.L9 30.85,76.38 30.35,76.89 29.51,76.89 v1(29.18,77.22)
TBTA_CC2: length 41.2
  TOP w0.203: v2(11.65,72.34) 11.25,72.75 D56.2 10.83,73.4 10.56,73.66 5.07,73.66 4.49,74.25 4.49,76.91 6.09,78.52 JTYPC1.B5
  TOP w0.254: C2129.1 v1(29.94,77.3)
  IN05 w0.254: v1(29.94,77.3) 30.45,76.79 30.45,75.14 29.18,73.87 29.18,72.09 27.78,70.69 19.91,70.69 16.99,73.61 12.54,73.61 11.65,72.72 v2(11.65,72.34)
  BOTTOM w0.203: 30.58,77.3 30.99,76.88 U2007.L10
  BOTTOM w0.254: 30.58,77.3 v1(29.94,77.3)
TBTA_DEBUG1: length 6
  BOTTOM w0.102: U2007.L2 30.41,72.88 27.63,70.1 27.63,70.08 26.8,69.24 R2075.2
TBTA_DEBUG2: length 6
  BOTTOM w0.076: 30.09,72.22 30.5,72.62 31.49,72.62 U2007.K2
  BOTTOM w0.102: 30.09,72.22 29.99,72.11 29.99,71.76 v1(29.9,71.67) 29.7,71.67 27.65,69.62 R2076.2
TBTA_DEBUG3: length 7.7
  BOTTOM w0.102: U2007.L3 30.24,73.38 27.6,70.74 26.23,70.74 v1(25.95,70.46) 25.55,70.46 R2071.2
TBTA_DEBUG4: length 7.9
  BOTTOM w0.076: U2007.K3 31.74,73.38 31.5,73.14 30.31,73.14
  BOTTOM w0.102: 30.31,73.14 27.4,70.23 v1(27.22,70.23) 26.33,70.23 25.88,69.78 R2072.2
TBTA_DPSRC_AUX_N: length 5.8
  TOP w0.104: R2069.2 29.41,69.8 v1(29.56,69.96)
  BOTTOM w0.076: U2007.J2 31.99,72.62 31.99,72.2 31.34,71.54 31.26,71.54 31.26,71.53
  BOTTOM w0.104: C2071.2 29.71,69.56 29.71,69.8 v1(29.56,69.96) 29.64,70.04 29.64,70.44 30.04,70.84 30.56,70.84 31.26,71.53
TBTA_DPSRC_AUX_P: length 5.7
  TOP w0.104: v1(30.12,69.96) 30.3,69.78 R2080.1
  BOTTOM w0.076: 31.44,71.35 31.44,71.36 31.44,71.37 31.41,71.4 31.45,71.44 32.25,72.24 U2007.J1
  BOTTOM w0.104: 31.44,71.35 31.3,71.21 31.3,71.06 31.43,70.93 31.43,70.79 31.28,70.64 31.13,70.64 31,70.77 30.85,70.77 30.66,70.58 30.15,70.58 29.9,70.33 29.9,70.18 v1(30.12,69.96) 29.99,69.83 29.99,69.54 C2070.2
TBTA_HPD: length 21.8
  TOP w0.089: R2049.1 50.26,90.81 50.26,89.94 v1(50.57,89.63)
  IN03 w0.091: v2(39.21,77.4) 38.7,77.91 38.7,80.09 46.2,87.58 47.87,87.58 49.4,89.11 50.04,89.11 v1(50.57,89.63)
  BOTTOM w0.097: v2(39.21,77.4) 39.03,77.22 R2063.1
  BOTTOM w0.178: U2005.M4 v1(50.57,89.63)
TBTA_I2C_INT: length 43.2
  TOP w0.097: v1(49.27,89.63) 48.86,90.04 48.86,91.71
  TOP w0.102: R2037.1 51.84,93.04 v1(51.07,93.04) 50.54,92.51 49.66,92.51 48.86,91.71
  IN03 w0.089: 38.4,74.43 38.32,74.5 38.32,80.22 38.4,80.29 ; 38.4,71.78 38.07,71.45 37.69,71.45 35.91,69.68 v1(35.66,69.68)
  IN03 w0.091: 38.4,80.29 41.62,83.52 41.62,86.69 40.48,87.84 40.48,90.12 41.37,91.01 47.89,91.01 v1(49.27,89.63) ; 38.4,71.78 38.68,72.06 38.68,74.15 38.4,74.43
  BOTTOM w0.102: U2007.C1 35.27,72.36 35.27,70.06 v1(35.66,69.68)
  BOTTOM w0.178: U2005.J4 v1(49.27,89.63)
TBTA_LDO_BMC: length 4.3
  BOTTOM w0.178: C2117.1 32.1,70.06 32.86,70.82 33.04,70.82 34.13,71.91 34.13,72.26 U2007.E1
TBTA_LSRX: length 38.4
  TOP w0.089: v1(45.05,89.61) 44.9,89.77
  TOP w0.097: R2045.2 44.04,90.63 44.9,89.77
  IN05 w0.089: 26.97,71.78 28.04,72.85 28.04,78.06 27.15,78.95 27.15,80.72 ; 44.9,88.34 45.31,88.34 45.43,88.47 45.43,89.23 v1(45.05,89.61)
  IN05 w0.091: v2(25.09,71.45) 26.64,71.45 26.97,71.78 ; 27.15,80.72 27.15,81.28 31.29,85.42 33.92,85.42 37.09,88.6 44.42,88.6 44.67,88.34 44.9,88.34
  BOTTOM w0.097: R2088.1 v2(25.09,71.45)
  BOTTOM w0.102: v1(45.05,89.61) 45.18,89.74 U2005.A4
TBTA_LSTX: length 36.5
  TOP w0.102: R2048.2 45.74,90.17 45.43,89.87 45.43,89.11 v1(45.05,88.73)
  IN05 w0.091: v2(25.37,72.34) 27.22,72.34 27.86,72.98 27.86,77.88 26.89,78.84 26.89,81.47 27.73,82.3 31.28,85.86 34.04,85.86 37.04,88.85 44.93,88.85 v1(45.05,88.73)
  BOTTOM w0.097: R2087.1 v2(25.37,72.34)
  BOTTOM w0.203: v1(45.05,88.73) 45.61,89.28 U2005.A5
