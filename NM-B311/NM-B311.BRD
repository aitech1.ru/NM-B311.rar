# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDC30: length 31.6
  IN10 w0.14: v3(296.22,113.89) 295.85,113.89 295.47,114.26 293.48,114.26 292.2,115.53 285.11,115.53 282.18,118.46 274.41,118.46 273.53,119.34 271.59,119.34 271.27,119.67 270.63,119.67 270.12,120.18 268.69,120.18 v3(268.39,119.87)
  BOTTOM w0.152: G2.F11 v3(268.39,119.87) ; U2025.F4 v3(296.22,113.89)
MDC31: length 32
  IN10 w0.14: v3(269.04,119.77) 269.34,119.47 269.34,118.89 269.59,118.63 271.29,118.63 272.02,117.9 281.95,117.9 284.92,114.94 291.95,114.94 293.24,113.64 295.46,113.64 295.82,113.28 295.82,112.69 v3(296.22,112.29)
  BOTTOM w0.152: U2025.F2 v3(296.22,112.29) ; G2.E11 269.04,119.92 v3(269.04,119.77)
MDC32: length 25.2
  IN03 w0.076: 271.18,132.94 266.16,132.94 v3(265.69,132.47)
  IN03 w0.14: 271.18,132.94 271.41,133.17 278.54,133.17 283.29,137.92 287.02,137.92 v3(287.43,137.51)
  BOTTOM w0.152: G2.J29 v3(265.69,132.47) ; v3(287.43,137.51) 287.82,137.12 U2024.A4
MDC33: length 22.6
  IN03 w0.076: v3(268.39,133.77) 268.76,133.39 270.68,133.39
  IN03 w0.14: 270.68,133.39 271.72,134.43 278.15,134.43 282.83,139.11 287.43,139.11 v3(287.43,139.11)
  BOTTOM w0.152: G2.F30 v3(268.39,133.77) ; U2024.A2 287.82,138.72 v3(287.43,139.11)
MDC34: length 24.7
  IN03 w0.076: 270.31,132.73 267.24,132.73 v3(266.98,132.47)
  IN03 w0.14: v3(288.23,137.51) 287.81,137.1 283.28,137.1 278.78,132.6 276.01,132.6 275.74,132.33 270.71,132.33 270.31,132.73
  BOTTOM w0.152: v3(288.23,137.51) 288.62,137.12 U2024.B4 ; G2.H29 v3(266.98,132.47)
MDC35: length 24.8
  IN03 w0.076: v3(267.09,133.77) 267.68,133.17 270.95,133.17
  IN03 w0.14: v3(288.23,139.11) 287.67,138.55 283.12,138.55 278.42,133.86 271.64,133.86 270.95,133.17
  BOTTOM w0.152: U2024.B2 288.62,138.72 v3(288.23,139.11) ; G2.G30 v3(267.09,133.77)
MDC36: length 27.2
  IN03 w0.14: v3(291.43,137.51) 291.03,137.92 291.03,140.37 290.38,141.02 286.86,141.02 286.21,140.36 282.45,140.36 277.94,135.86 277,135.86 276.22,135.08 v3(276.22,134.87)
  BOTTOM w0.102: 275.29,133.94 275.13,133.78 271.4,133.78 271.09,133.47 G2.B30
  BOTTOM w0.152: U2024.E4 291.03,137.12 v3(291.43,137.51) ; 275.29,133.94 v3(276.22,134.87)
MDC37: length 23.4
  IN03 w0.14: v3(290.63,139.11) 290.23,139.51 290.23,140.12 289.89,140.46 287.13,140.46 286.45,139.77 282.69,139.77 278.21,135.29 277.23,135.29 v3(276.8,134.87)
  BOTTOM w0.102: G2.A30 275.4,133.47 275.53,133.59
  BOTTOM w0.152: v3(290.63,139.11) 291.02,138.72 U2024.E2 ; 275.53,133.59 v3(276.8,134.87)
MDC38: length 35.7
  IN03 w0.076: 271.01,134.83 268.69,134.83 268.55,134.97 266.79,134.97 266.61,134.78 266.61,133.99 v3(266.39,133.77)
  IN03 w0.14: 271.01,134.83 271.49,135.31 272.8,135.31 273.02,135.53 273.02,135.89 273.37,136.24 275.79,136.24 276.53,136.98 277.34,136.98 281.96,141.6 285.8,141.6 286.43,142.23 291.42,142.23 292.65,141.01 292.65,137.93 v3(292.23,137.51)
  BOTTOM w0.152: v3(292.23,137.51) 291.83,137.12 U2024.F4 ; G2.H30 v3(266.39,133.77)
MDC39: length 27.7
  IN03 w0.14: v3(275.05,134.87) 275.48,135.3 275.65,135.3 276.76,136.42 277.6,136.42 282.18,141 286.04,141 286.65,141.61 290.86,141.61 291.83,140.65 291.83,139.51 v3(291.43,139.11)
  BOTTOM w0.102: 274.4,134.21 274.19,134 271.22,134 271,133.79 270.74,133.79 270.41,133.47 G2.C30
  BOTTOM w0.152: v3(291.43,139.11) 291.82,138.72 U2024.F2 ; 274.4,134.21 v3(275.05,134.87)
MDC40: length 21.4
  IN10 w0.14: v3(287.43,131.12) 287.43,131.41 286.72,132.11 282.83,132.11 280.44,129.71 276.14,129.71 275.59,130.26 271.91,130.26 271.57,130.59 271.57,131.24 271.23,131.58 269.87,131.58 v3(269.79,131.67)
  BOTTOM w0.152: U2024.A11 v3(287.43,131.12) ; G2.D27 v3(269.79,131.67)
MDC41: length 25.4
  IN10 w0.14: v3(265.69,130.33) 266.13,130.77 269.99,130.77 270.85,129.9 271.39,129.37 271.74,129.01 274.15,129.01 275.12,128.03 281.14,128.03 283.54,130.43 285.84,130.43 286.75,129.52 v3(287.43,129.52)
  BOTTOM w0.152: v3(265.69,130.33) 265.69,130.38 G2.J26 ; U2024.A13 v3(287.43,129.52)
MDC42: length 24.1
  IN10 w0.14: v3(267.79,131.67) 268.19,131.27 270.72,131.27 271.29,130.69 271.29,130.42 271.81,129.9 275.07,129.9 275.83,129.15 280.67,129.15 283.07,131.55 286.3,131.55 287.13,130.72 287.83,130.72 v3(288.23,131.12)
  BOTTOM w0.152: U2024.B11 v3(288.23,131.12) ; G2.F27 v3(267.79,131.67)
MDC43: length 25
  IN10 w0.14: v3(288.23,129.52) 287.83,129.92 287.14,129.92 286.07,130.99 283.3,130.99 280.91,128.59 275.45,128.59 274.58,129.46 271.79,129.46 270.23,131.02 267.73,131.02 v3(267.09,131.67)
  BOTTOM w0.152: U2024.B13 v3(288.23,129.52) ; G2.G27 v3(267.09,131.67)
MDC44: length 26.7
  IN10 w0.14: v3(273.8,132.77) 274.64,131.93 276.78,131.93 277.09,131.63 279.43,131.63 282.85,135.05 289.48,135.05 290.23,134.3 290.23,131.52 v3(290.63,131.12)
  BOTTOM w0.102: 273.17,132.13 273.1,132.06 271.43,132.06 271.09,131.72 270.74,131.72 270.39,131.37 G2.C27
  BOTTOM w0.152: 273.17,132.13 v3(273.8,132.77) ; U2024.E11 v3(290.63,131.12)
MDC45: length 28.6
  IN10 w0.14: v3(274.39,132.77) 274.39,132.76 274.8,132.35 277.34,132.35 277.5,132.19 279.19,132.19 282.62,135.61 290,135.61 291.03,134.58 U2024.E13 v3(291.43,129.52)
  BOTTOM w0.102: G2.B27 271.09,131.37 271.46,131.74 273.36,131.74 273.53,131.91
  BOTTOM w0.152: 273.53,131.91 v3(274.39,132.77) ; U2024.E13 v3(291.43,129.52)
MDC46: length 27.5
  IN10 w0.14: v3(275.56,132.77) 275.58,132.74 278.96,132.74 282.41,136.2 290.8,136.2 291.83,135.17 U2024.F11 v3(291.43,131.12)
  BOTTOM w0.102: G2.A27 273.53,131.37
  BOTTOM w0.152: 273.53,131.37 274.16,131.37 v3(275.56,132.77) ; U2024.F11 v3(291.43,131.12)
MDC47: length 32.9
  IN10 w0.14: v3(292.23,129.52) 291.83,129.12 290.42,129.12 290.23,129.31 290.23,130.56 290.07,130.72 289.64,130.72 289.43,130.93 289.43,133.88 288.83,134.49 283.08,134.49 279.66,131.07 276.86,131.07 276.39,131.53 274.07,131.53 273.44,132.16 271.95,132.16 271.2,132.91 269.11,132.91 v3(268.52,132.32)
  BOTTOM w0.102: v3(268.52,132.32) 268.45,132.39 268,132.39 267.63,132.77 G2.G29
  BOTTOM w0.152: U2024.F13 v3(292.23,129.52)
MDC48: length 44.9
  IN10 w0.14: v3(266.39,126.17) 266.39,126.01 266.66,125.73 266.66,124.99 267.13,124.52 271.68,124.52 272.67,123.53 283.45,123.53 284.16,124.23 290.31,124.23 290.5,124.43 299.44,124.43 302.18,127.17 302.18,130.71 301.61,131.28 301.19,131.28 v3(301.03,131.12)
  BOTTOM w0.152: v3(301.03,131.12) 300.63,131.52 U2024.U11 ; G2.H20 v3(266.39,126.17)
MDC49: length 36
  IN10 w0.14: v3(269.79,125.37) 269.95,125.2 272.28,125.2 272.83,124.64 282.98,124.64 284.17,125.83 285.33,125.83 285.81,125.35 289.83,125.35 290.03,125.55 298.81,125.55 300.63,127.36 300.63,129.12 v3(301.03,129.52)
  BOTTOM w0.152: v3(301.03,129.52) 300.63,129.92 U2024.U13 ; G2.D18 v3(269.79,125.37)
MDC50: length 42.1
  IN10 w0.14: v3(300.23,131.12) 300.63,130.72 301.27,130.72 301.59,130.4 301.59,127.52 299.06,124.99 290.27,124.99 290.07,124.79 283.92,124.79 283.22,124.09 272.52,124.09 271.68,124.93 268.42,124.93 268.09,125.26 268.09,125.67 267.71,126.05 v3(267.61,126.05)
  BOTTOM w0.152: G2.G20 267.61,126.25 v3(267.61,126.05) ; U2024.T11 v3(300.23,131.12)
MDC51: length 36.8
  IN10 w0.14: v3(300.23,130.32) 299.83,129.92 299.83,127.91 298.03,126.11 289.8,126.11 289.6,125.91 286.04,125.91 285.56,126.39 283.94,126.39 282.75,125.2 273.16,125.2 272.17,126.19 269.19,126.19 v3(268.91,125.92)
  BOTTOM w0.152: v3(268.91,125.92) 268.98,125.99 268.98,126.27 G2.E20 ; v3(300.23,130.32) 299.83,129.92 U2024.T13
MDC52: length 37.9
  IN10 w0.14: v3(297.83,131.12) 298.23,130.72 298.23,127.54 297.28,126.59 289.48,126.59 289.36,126.47 286.28,126.47 285.74,127 283.76,127 282.52,125.76 273.53,125.76 272.68,126.61 268.7,126.61 268.12,127.19 268.12,127.81 v3(268.49,128.17)
  BOTTOM w0.152: U2024.N11 v3(297.83,131.12) ; G2.F23 v3(268.49,128.17)
MDC53: length 32.9
  IN10 w0.14: v3(269.09,127.47) 269.52,127.03 273.12,127.03 273.83,126.32 282.29,126.32 283.91,127.94 285.72,127.94 286.63,127.03 292.91,127.03 293.11,127.23 296.6,127.23 297.43,128.06 297.43,129.12 v3(297.03,129.52)
  BOTTOM w0.152: v3(269.09,127.47) G2.E21 ; U2024.N13 v3(297.03,129.52)
MDC54: length 33.8
  IN10 w0.14: v3(269.79,127.47) 269.79,127.82 270.14,128.18 272.92,128.18 274.22,126.88 282.06,126.88 284.36,129.18 285.27,129.18 286.81,127.65 290.56,127.65 290.84,127.92 296.34,127.92 296.63,128.2 296.63,130.72 v3(297.03,131.12)
  BOTTOM w0.152: G2.D21 v3(269.79,127.47) ; U2024.M11 v3(297.03,131.12)
MDC55: length 31
  IN10 w0.14: v3(296.23,129.52) 295.76,129.05 294.03,129.05 293.3,128.32 286.93,128.32 285.5,129.74 284.13,129.74 281.82,127.44 274.7,127.44 273.54,128.6 269.46,128.6 v3(269.04,128.17)
  BOTTOM w0.152: G2.E23 269.04,128.32 v3(269.04,128.17) ; U2024.M13 v3(296.23,129.52)
MDC56: length 40.5
  IN03 w0.14: v3(300.23,137.51) 300.71,137.04 300.71,135.65 298.54,133.48 296.37,133.48 295.35,132.46 288.02,132.46 285.85,130.3 283.46,130.3 281.15,127.99 271.04,127.99 270.34,128.7 267.96,128.7 v3(267.09,129.57)
  BOTTOM w0.152: v3(300.23,137.51) 300.63,137.12 U2024.U4 ; G2.G24 v3(267.09,129.57)
MDC57: length 41.8
  IN03 w0.14: v3(300.23,139.11) 299.83,139.52 299.83,140.16 299.36,140.63 294,140.63 293.73,140.36 293.73,139.77 293.43,139.47 293.43,137.27 292.44,136.29 287.42,136.29 287.33,136.37 283.73,136.37 279.31,131.96 276.3,131.96 276.07,131.73 270.75,131.73 270.28,131.26 267.28,131.26 v3(266.39,130.37)
  BOTTOM w0.152: U2024.U2 300.62,138.72 v3(300.23,139.11) ; G2.H26 v3(266.39,130.37)
MDC58: length 37.6
  IN03 w0.14: v3(267.79,129.57) 268.2,129.15 270.8,129.15 271.39,128.57 280.94,128.57 283.23,130.85 285.62,130.85 287.79,133.02 293.51,133.02 293.77,133.28 295.41,133.28 296.36,134.24 298.42,134.24 299.83,135.64 299.83,136.31 v3(300.23,136.72)
  BOTTOM w0.152: G2.F24 v3(267.79,129.57) ; v3(300.23,136.72) 299.83,137.12 U2024.T4
MDC59: length 37.5
  IN03 w0.14: v3(299.43,139.11) 299.03,139.52 295.08,139.52 294.23,138.66 294.23,137.25 292.8,135.81 284,135.81 279.58,131.4 271.13,131.4 270.7,130.96 268.28,130.96 v3(267.69,130.37)
  BOTTOM w0.152: U2024.T2 299.82,138.72 v3(299.43,139.11) ; v3(267.69,130.37) G2.G26
MDC60: length 35.6
  IN03 w0.14: v3(297.03,137.51) 297.52,137.03 297.52,135.7 297.12,135.29 296.03,135.29 294.32,133.58 287.52,133.58 285.48,131.54 283.06,131.54 280.66,129.14 271.96,129.14 270.47,130.64 270.21,130.64 270.21,130.64 268.65,130.64 v3(268.39,130.37)
  BOTTOM w0.152: G2.F26 v3(268.39,130.37) ; v3(297.03,137.51) 297.42,137.12 U2024.N4
MDC61: length 33
  IN03 w0.14: v3(272.67,130.72) 273.68,129.71 280.39,129.71 282.84,132.16 285.2,132.16 287.17,134.14 293.77,134.14 296.63,136.99 296.63,137.91 v3(297.03,138.31)
  BOTTOM w0.102: G2.D26 269.84,131.02 271.79,131.02 271.89,131.12 272.27,131.12 v3(272.67,130.72)
  BOTTOM w0.152: U2024.N2 297.43,138.71 v3(297.03,138.31)
MDC62: length 29.4
  IN03 w0.14: v3(273.25,130.72) 273.71,130.26 280.09,130.26 284.52,134.7 293.41,134.7 v3(296.23,137.51)
  BOTTOM w0.102: G2.B26 271.11,130.67 271.45,130.32 272.85,130.32 272.92,130.38
  BOTTOM w0.152: U2024.M4 296.62,137.12 v3(296.23,137.51) ; 272.92,130.38 v3(273.25,130.72)
MDC63: length 32.1
  IN03 w0.14: v3(297.03,139.11) 296.63,138.71 295.88,138.71 295.03,137.86 295.03,137.17 293.12,135.26 284.24,135.26 279.82,130.83 275.6,130.83 275.31,131.12 274.83,131.12 v3(274.42,130.72)
  BOTTOM w0.102: 273.27,130.15 273.19,130.07 271.31,130.07 271.07,130.32 270.54,130.32 G2.C26
  BOTTOM w0.152: v3(274.42,130.72) 273.86,130.15 273.27,130.15 ; U2024.M2 296.63,138.72 v3(297.03,139.11)
MDD0: length 23.7
  IN03 w0.14: v3(250.99,117.77) 251.83,116.92 251.83,113.07 252.49,112.41 252.49,106.89 249.09,103.49 249.09,102.45 246.23,99.59 246.23,98.48 v1(246.07,98.32)
  BOTTOM w0.152: G2.AK8 v3(250.99,117.77) ; U2026.U4 v1(246.07,98.32)
MDD1: length 20.7
  IN03 w0.14: v3(244.47,98.32) 244.31,98.48 244.31,101.08 250.06,106.83 250.06,112.24 251.14,113.32 251.14,114.61 v3(250.88,114.87)
  BOTTOM w0.152: G2.AK4 251.28,115.27 v3(250.88,114.87) ; U2026.U2 v3(244.47,98.32)
MDD2: length 20.4
  IN03 w0.14: v3(251.3,112.03) 251.93,111.41 251.93,107.12 248.53,103.72 248.53,102.68 245.67,99.82 245.67,97.92 v3(246.07,97.52)
  BOTTOM w0.102: 250.77,113 250.77,113.14 251.28,113.65 G2.AK2
  BOTTOM w0.152: U2026.T4 v3(246.07,97.52) ; 250.77,113 250.77,112.49 251.23,112.03 v3(251.3,112.03)
MDD3: length 21.8
  IN03 w0.14: v3(251.3,111.46) 251.13,111.46 250.86,111.19 250.86,108.89 251.34,108.41 251.34,107.32 247.97,103.95 247.97,102.91 244.87,99.81 244.87,97.92 v3(244.47,97.52)
  BOTTOM w0.102: 250.42,113.27 250.92,113.77 250.92,114.01 251.28,114.37 G2.AK3
  BOTTOM w0.152: v3(251.3,111.46) 251.13,111.46 250.42,112.17 250.42,113.27 ; U2026.T2 v3(244.47,97.52)
MDD4: length 27.4
  IN03 w0.14: v3(250.99,115.67) 250.81,115.67 249.74,114.6 249.74,112.61 249.47,112.35 249.47,107.06 243.59,101.18 243.59,98.58 243.91,98.27 243.91,94.92 244.1,94.72 245.67,94.72 v3(246.07,94.32)
  BOTTOM w0.152: G2.AK5 v3(250.99,115.67) ; U2026.N4 v3(246.07,94.32)
MDD5: length 25.9
  IN05 w0.14: v3(250.81,116.23) 250.23,116.23 249.9,115.9 249.9,115.27 250.04,115.13 250.04,111 248.98,109.94 248.98,103.88 243.93,98.83 243.93,95.66 v3(244.47,95.12)
  BOTTOM w0.152: G2.AK6 251.24,116.67 v3(250.81,116.23) ; U2026.N2 v3(244.47,95.12)
MDD6: length 33.7
  IN03 w0.14: v3(250.99,119.07) 249.75,117.83 249.75,115.75 249.18,115.18 249.18,112.74 248.91,112.47 248.91,107.31 242.81,101.2 242.81,93.48 243.4,92.89 245.44,92.89 v3(246.07,93.52)
  BOTTOM w0.152: U2026.M4 v3(246.07,93.52) ; G2.AK9 v3(250.99,119.07)
MDD7: length 28.3
  IN05 w0.076: 243.23,95.12 243.67,95.12 v3(244.47,94.32)
  IN05 w0.14: 243.23,95.12 243,95.35 243,98.86 246.49,102.35 246.49,103.01 247.58,104.09 247.58,109.86 249.06,111.34 249.06,115.82 249.89,116.65 250.56,116.65 v3(250.99,117.07)
  BOTTOM w0.152: U2026.M2 v3(244.47,94.32) ; G2.AK7 v3(250.99,117.07)
MDD8: length 19.8
  IN10 w0.14: v3(254.09,112.13) 253.88,112.13 253.05,111.3 253.05,107.72 251.91,106.58 251.91,104.07 251.43,103.58 251.43,98.89 251.99,98.32 v3(252.47,98.32)
  BOTTOM w0.102: v3(254.09,112.13) 254.02,112.13 253.7,112.44 253.7,114.95 G2.AG4
  BOTTOM w0.152: U2026.U11 v3(252.47,98.32)
MDD9: length 23.8
  IN10 w0.076: 254.9,117.96 254.82,118.05 254.82,118.63 v3(254.39,119.07)
  IN10 w0.14: v3(254.07,98.32) 254.15,98.4 254.15,99.09 253.21,100.03 253.21,105.57 255.06,107.42 255.06,114.18 255.52,114.63 255.52,115.52 255.66,115.66 255.66,117.36 255.05,117.96 254.9,117.96
  BOTTOM w0.152: U2026.U13 v3(254.07,98.32) ; G2.AF9 v3(254.39,119.07)
MDD10: length 22.9
  IN10 w0.14: v3(252.47,97.52) 251.99,98 251.43,98 250.81,98.62 250.81,104.11 251.35,104.65 251.35,106.89 252.48,108.02 252.48,111.94 253.69,113.15 253.69,116.36 v3(253.09,116.97)
  BOTTOM w0.152: G2.AG6 v3(253.09,116.97) ; U2026.T11 v3(252.47,97.52)
MDD11: length 25.6
  IN10 w0.14: v3(254.07,97.52) 253.67,97.92 253.67,98.77 252.57,99.87 252.57,105.72 254.65,107.81 254.65,113.64 253.98,114.31 253.98,117.47 v3(252.97,118.48)
  BOTTOM w0.152: v3(252.97,118.48) 253.04,118.41 253.52,118.41 253.75,118.17 253.75,117.73 G2.AG7 ; U2026.T13 v3(254.07,97.52)
MDD12: length 23.7
  IN10 w0.14: v3(252.47,95.12) 252.07,95.52 251.16,95.52 249.61,97.06 249.61,105.07 250.11,105.56 250.11,112.07 252.28,114.25 v3(252.28,114.97)
  BOTTOM w0.152: G2.AJ4 v3(252.28,114.97) ; U2026.N11 v3(252.47,95.12)
MDD13: length 27.5
  IN10 w0.14: v3(252.28,115.67) 251.79,115.17 251.79,114.29 249.55,112.06 249.55,106.15 248.93,105.53 248.93,96.64 250.86,94.72 U2026.N13 v3(254.07,95.12)
  BOTTOM w0.152: G2.AJ5 v3(252.28,115.67) ; U2026.N13 v3(254.07,95.12)
MDD14: length 28.7
  IN10 w0.14: v3(252.47,94.32) U2026.M11 250.61,93.92 248.27,96.26 248.27,106.49 248.93,107.16 248.93,112.1 251.41,114.58 251.41,116.09 v3(252.28,116.97)
  BOTTOM w0.152: G2.AJ6 v3(252.28,116.97) ; U2026.M11 v3(252.47,94.32)
MDD15: length 27.4
  IN10 w0.14: v3(253.09,115.67) 253.42,115.33 253.42,113.71 251.9,112.19 251.9,108.28 250.79,107.17 250.79,105.11 250.24,104.56 250.24,97.5 251.42,96.32 254.26,96.32 254.47,96.11 254.47,94.72 v3(254.07,94.32)
  BOTTOM w0.152: G2.AG5 v3(253.09,115.67) ; U2026.M13 v3(254.07,94.32)
MDD16: length 42.3
  IN10 w0.14: v3(251.67,84.72) 252.65,83.74 256.63,83.74 259.38,86.5 259.38,104.73 260.33,105.68 260.33,115.78 259.46,116.66 259.17,116.66 v3(258.72,117.11)
  BOTTOM w0.152: G2.Y6 v3(258.72,117.11) ; U2026.A11 v3(251.67,84.72)
MDD17: length 34.2
  IN10 w0.14: v3(258.58,115.67) 258.16,115.24 258.16,113.77 257.7,113.31 257.7,88.43 255.19,85.92 253.67,85.92 v3(253.27,85.52)
  BOTTOM w0.152: U2026.A13 v3(253.27,85.52) ; v3(258.58,115.67) G2.Y5
MDD18: length 39
  IN10 w0.14: v3(251.67,85.52) 252.88,84.31 256.24,84.31 258.82,86.89 258.82,106.38 259.73,107.29 259.73,115.28 v3(259.36,115.66)
  BOTTOM w0.152: U2026.B11 v3(251.67,85.52) ; G2.V5 259.38,115.66 v3(259.36,115.66)
MDD19: length 34.2
  IN10 w0.14: v3(254.07,85.52) 254.47,85.12 255.8,85.12 258.26,87.58 258.26,106.75 258.97,107.46 258.97,113.77 258.58,114.16 v3(258.58,114.97)
  BOTTOM w0.152: U2026.B13 v3(254.07,85.52) ; G2.Y4 v3(258.58,114.97)
MDD20: length 33.7
  IN10 w0.14: v3(252.47,88.72) 252.87,88.32 253.9,88.32 254.7,88.32 255.67,88.32 257.14,89.79 257.14,113.29 257.91,114.06 257.91,115.54 v3(257.18,116.26)
  BOTTOM w0.152: G2.AA6 v3(257.18,116.26) ; U2026.E11 v3(252.47,88.72)
MDD21: length 30
  IN10 w0.14: v3(254.07,88.72) 254.47,89.12 255.11,89.12 256.58,90.6 256.58,113.46 257.62,114.49 257.62,115.24 v3(257.2,115.66)
  BOTTOM w0.152: v3(257.2,115.66) 257.21,115.67 257.28,115.67 G2.AA5 ; U2026.E13 v3(254.07,88.72)
MDD22: length 29
  IN10 w0.14: v3(252.47,89.52) 254.68,91.73 254.68,92.73 255.28,93.32 255.28,106.73 255.47,106.92 255.47,113.87 255.98,114.38 255.98,115.08 v3(256.6,115.7)
  BOTTOM w0.152: v3(256.6,115.7) 256.46,115.7 G2.AC5 ; U2026.F11 v3(252.47,89.52)
MDD23: length 27.5
  IN10 w0.14: v3(254.07,89.52) 254.07,90.37 255.75,92.05 255.75,94.87 255.98,95.1 255.98,113.72 256.33,114.07 256.33,114.54 v3(256.62,114.83)
  BOTTOM w0.152: G2.AC4 v3(256.62,114.83) ; U2026.F13 v3(254.07,89.52)
MDD24: length 40.6
  IN03 w0.14: v3(246.87,84.72) 246.87,84.72 247.08,84.51 248.08,84.51 249.3,85.73 249.3,86.7 250.27,87.67 250.27,91.84 250.68,92.24 250.68,97.89 257.29,104.5 257.29,112.53 255.83,113.98 255.83,116.93 255.24,117.52 v3(254.89,117.52)
  BOTTOM w0.152: v3(254.89,117.52) 255.33,117.52 G2.AD7 ; U2026.A4 v3(246.87,84.72)
MDD25: length 42.3
  IN03 w0.14: v3(256.48,116.97) 256.17,116.65 256.17,114.29 257.85,112.61 257.85,104.27 251.24,97.65 251.24,87.43 250.11,86.3 250.11,85.64 248.99,84.52 248.33,83.86 246.13,83.86 v3(245.27,84.72)
  BOTTOM w0.152: G2.AC6 256.19,116.67 v3(256.48,116.97) ; U2026.A2 v3(245.27,84.72)
MDD26: length 36.8
  IN03 w0.14: v3(254.39,116.37) 253.98,115.97 253.98,114.46 256.17,112.27 256.17,104.97 249.56,98.36 249.56,93 249.26,92.7 249.26,88.53 247.27,86.54 247.27,85.92 v3(246.87,85.52)
  BOTTOM w0.152: U2026.B4 v3(246.87,85.52) ; G2.AF6 v3(254.39,116.37)
MDD27: length 39.6
  IN03 w0.14: v3(255.04,116.22) 255.24,116.22 255.51,115.95 255.51,113.68 256.73,112.46 256.73,104.74 250.12,98.12 250.12,92.58 249.74,92.2 249.74,88.09 248.45,86.8 248.45,85.63 247.94,85.12 245.67,85.12 v3(245.27,85.52)
  BOTTOM w0.152: G2.AD6 v3(255.04,116.22) ; U2026.B2 v3(245.27,85.52)
MDD28: length 36
  IN03 w0.14: v3(246.07,88.72) U2026.E4 247.97,88.32 248.78,89.13 248.78,93.11 249,93.33 249,98.59 255.61,105.21 255.61,112.33 253.74,114.2 253.74,116.42 v3(254.39,117.07)
  BOTTOM w0.152: G2.AF7 v3(254.39,117.07) ; U2026.E4 v3(246.07,88.72)
MDD29: length 37.2
  IN03 w0.14: v3(244.47,88.72) 244.87,89.12 247.87,89.12 248.27,89.52 248.27,93.66 248.44,93.84 248.44,98.82 255.06,105.44 255.06,112.34 253.5,113.89 253.5,116.88 v3(254.39,117.77)
  BOTTOM w0.152: G2.AF8 v3(254.39,117.77) ; U2026.E2 v3(244.47,88.72)
MDD30: length 28.6
  IN03 w0.14: v3(246.87,89.52) 247.88,90.53 247.88,99.06 251.44,102.62 251.44,103.22 254.5,106.28 254.5,108.77 v3(254.07,109.19)
  BOTTOM w0.102: v3(254.07,109.19) 254.47,109.59 254.47,113.28 254.09,113.66 G2.AF2
  BOTTOM w0.152: U2026.F4 v3(246.87,89.52)
MDD31: length 31.2
  IN03 w0.14: v3(254.07,108.62) 253.84,108.86 253.3,108.86 253.06,108.62 253.06,108.03 253.42,107.66 253.42,105.99 250.89,103.46 250.89,102.85 247.32,99.29 247.32,90.95 246.29,89.92 245.67,89.92 v3(245.27,89.52)
  BOTTOM w0.102: v3(254.07,108.62) 254.73,109.28 254.73,113.42 254.44,113.72 254.44,114 254.09,114.35 G2.AF3
  BOTTOM w0.152: U2026.F2 v3(245.27,89.52)
MDD32: length 20.6
  IN10 w0.14: v3(267.53,115.78) 267.53,115.5 268.14,114.9 268.14,112.14 267.93,111.93 267.93,109.59 271.11,106.4 271.11,98.8 v3(270.63,98.32)
  BOTTOM w0.152: G2.F4 268.04,115.27 v3(267.53,115.78) ; U60.A4 v3(270.63,98.32)
MDD33: length 17
  IN10 w0.14: v3(269.09,112.42) 269.3,112.42 269.54,112.18 269.54,110.52 272.23,107.83 v3(272.23,98.32)
  BOTTOM w0.152: v3(269.09,112.42) 269.09,112.86 G2.E1 ; U60.A2 v3(272.23,98.32)
MDD34: length 19.6
  IN10 w0.14: v3(270.63,97.52) 270.23,97.92 270.23,106.47 267,109.71 267,113.58 267.68,114.27 v3(267.71,114.27)
  BOTTOM w0.152: G2.F3 268,114.57 v3(267.71,114.27) ; U60.B4 v3(270.63,97.52)
MDD35: length 21.6
  IN10 w0.14: v3(267.79,116.27) 267.96,116.1 267.96,115.47 268.6,114.83 268.6,109.79 271.67,106.71 271.67,98.78 271.83,98.63 271.83,97.92 v3(272.23,97.52)
  BOTTOM w0.152: v3(267.79,116.27) G2.F5 ; U60.B2 v3(272.23,97.52)
MDD36: length 25.5
  IN10 w0.14: v3(270.49,112.21) 270.7,112.21 271.36,111.54 272.23,111.54 272.71,111.07 272.71,109.2 274.21,107.7 274.21,95.6 273.33,94.72 271.03,94.72 v3(270.63,94.32)
  BOTTOM w0.152: G2.D2 269.84,113.52 269.84,112.86 v3(270.49,112.21) ; U60.E4 v3(270.63,94.32)
MDD37: length 21.2
  IN10 w0.14: v3(272.23,95.12) 272.23,95.12 272.63,95.52 272.63,96.11 272.84,96.32 273.27,96.32 273.45,96.5 273.45,107.44 271.62,109.28 271.62,110.76 270.76,111.62 v3(270.49,111.62)
  BOTTOM w0.152: G2.D1 269.49,112.62 v3(270.49,111.62) ; U60.E2 v3(272.23,95.12)
MDD38: length 29.5
  IN10 w0.14: v3(270.49,114.27) 270.71,114.04 271.28,114.04 271.68,113.65 271.68,113.13 272.03,112.78 272.88,112.78 273.98,111.68 273.98,109.52 276.04,107.46 276.04,95.67 273.32,92.95 271.2,92.95 v3(270.63,93.52)
  BOTTOM w0.152: G2.C3 v3(270.49,114.27) ; U60.F4 v3(270.63,93.52)
MDD39: length 25.1
  IN10 w0.14: v3(272.23,94.32) 272.23,94.32 272.63,93.92 273.38,93.92 274.95,95.49 274.95,107.76 273.37,109.34 273.37,111.28 272.64,112.01 271.5,112.01 270.91,112.6 270.91,112.6 270.9,112.61 270.9,113.15 v3(270.49,113.57)
  BOTTOM w0.152: U60.F2 v3(272.23,94.32) ; G2.C2 v3(270.49,113.57)
MDD40: length 23.7
  IN03 w0.14: v3(265.69,116.27) 266.09,115.87 266.09,113.92 266.48,113.52 267.71,113.52 268.06,113.17 268.06,99.71 266.67,98.32 v3(264.23,98.32)
  BOTTOM w0.152: G2.J5 265.98,115.97 v3(265.69,116.27) ; U60.A11 v3(264.23,98.32)
MDD41: length 20.2
  IN03 w0.14: v3(262.63,98.32) 262.86,98.32 266.94,102.4 266.94,109.46 266.42,109.98 266.42,110.99 v3(265.98,111.43)
  BOTTOM w0.102: v3(265.98,111.43) 266.4,111.85 266.4,112.9 266.34,112.97 266.34,114.92 G2.J4
  BOTTOM w0.152: U60.A13 v3(262.63,98.32)
MDD42: length 28.4
  IN03 w0.14: v3(264.98,118.92) 264.75,118.92 264.36,118.53 264.36,114.39 265.58,113.17 265.58,109.51 266.38,108.71 266.38,102.64 262.19,98.45 262.19,98.06 262.33,97.92 262.83,97.92 263.03,97.72 263.03,97.32 263.23,97.12 263.83,97.12 v3(264.23,97.52)
  BOTTOM w0.152: G2.L8 264.53,118.12 264.53,118.57 264.87,118.92 v3(264.98,118.92) ; U60.B11 v3(264.23,97.52)
MDD43: length 19.7
  IN03 w0.14: v3(263.43,97.52) 263.83,97.92 263.83,98.49 267.5,102.16 267.5,110.74 266.22,112.02 v3(265.98,112.02)
  BOTTOM w0.102: v3(265.98,112.02) 265.6,112.4 265.6,113.27 265.98,113.65 G2.J2
  BOTTOM w0.152: U60.B13 v3(263.43,97.52)
MDD44: length 21.8
  IN03 w0.14: v3(269.09,110.66) 268.91,110.66 268.62,110.37 268.62,99.47 267.12,97.97 267.12,97.18 265.46,95.52 264.63,95.52 v3(264.23,95.12)
  BOTTOM w0.152: U60.E11 v3(264.23,95.12) ; G2.F1 268.09,112.75 268.28,112.55 268.28,111.24 268.86,110.66 v3(269.09,110.66)
MDD45: length 25.1
  IN03 w0.14: v3(269.09,111.25) 269.5,110.85 269.5,99.56 267.72,97.78 267.72,96.76 265.67,94.72 263.03,94.72 v3(262.63,94.32)
  BOTTOM w0.152: v3(262.63,94.32) 263.03,94.72 U60.E13 ; G2.F2 268.45,113.5 268.45,113 268.63,112.83 268.63,111.71 v3(269.09,111.25)
MDD46: length 27.8
  IN03 w0.14: v3(264.23,94.32) 264.63,93.92 265.9,93.92 268.53,96.55 268.53,97.79 270.05,99.32 270.05,110.28 269.79,110.55 269.79,112.52 269.44,112.86 268.76,112.86 267.76,113.86 267.13,113.86 266.76,114.23 266.76,114.74 v3(266.98,114.97)
  BOTTOM w0.152: U60.F11 v3(264.23,94.32) ; G2.H4 v3(266.98,114.97)
MDD47: length 31.4
  IN03 w0.14: v3(262.63,93.52) 263.03,93.12 266.19,93.12 269.39,96.32 269.39,97.86 270.61,99.09 270.61,110.32 270.09,110.85 270.09,112.81 269.74,113.15 268.87,113.15 268.31,113.71 268.31,114.88 267.91,115.27 267.38,115.27 v3(266.98,115.67)
  BOTTOM w0.152: v3(262.63,93.52) 263.03,93.92 U60.F13 ; v3(266.98,115.67) G2.H5
MDD48: length 43.7
  IN03 w0.14: v3(259.29,117.13) 259.29,116.98 259,116.68 258.47,116.68 258.16,116.37 258.16,114.69 259.48,113.37 259.48,111.74 260.75,110.47 260.75,103.83 257.28,100.36 257.28,96.15 257.81,95.61 257.81,86.95 261.11,83.66 264.17,83.66 264.41,83.89 264.41,84.55 264.23,84.72 v3(264.23,84.72)
  BOTTOM w0.152: v3(259.29,117.13) 259.53,117.37 G2.V7 ; U60.U11 v3(264.23,84.72)
MDD49: length 39.3
  IN03 w0.14: v3(262.63,84.72) 262.23,85.12 261.4,85.12 258.93,87.59 258.93,96.08 258.39,96.61 258.39,99.89 261.87,103.37 261.87,110.94 260.04,112.77 260.04,116.49 259.82,116.71 259.82,117.94 v3(259.39,118.37)
  BOTTOM w0.152: G2.V8 v3(259.39,118.37) ; U60.U13 v3(262.63,84.72)
MDD50: length 40.7
  IN03 w0.14: v3(259.28,116.26) 259.44,116.26 259.79,115.91 259.79,112.22 261.31,110.7 261.31,103.6 257.83,100.13 257.83,96.38 258.37,95.84 258.37,87.27 261.37,84.27 263.63,84.27 263.83,84.47 263.83,85.12 v3(264.23,85.52)
  BOTTOM w0.152: U60.T11 v3(264.23,85.52) ; G2.V6 v3(259.28,116.26)
MDD51: length 39.1
  IN03 w0.14: v3(259.39,119.07) 260.16,118.29 260.16,116.94 260.29,116.81 260.29,113.33 262.43,111.19 262.43,103.13 258.95,99.66 258.95,96.85 259.49,96.31 259.49,88.03 261.6,85.92 262.23,85.92 v3(262.63,85.52)
  BOTTOM w0.152: U60.T13 v3(262.63,85.52) ; G2.V9 v3(259.39,119.07)
MDD52: length 35.1
  IN03 w0.14: v3(260.79,114.87) 260.53,114.61 260.53,113.9 262.99,111.45 262.99,102.9 259.51,99.42 259.51,97.09 260.05,96.55 260.05,88.36 260.88,87.52 263.83,87.52 v3(264.23,87.92)
  BOTTOM w0.152: G2.U4 v3(260.79,114.87) ; U60.N11 v3(264.23,87.92)
MDD53: length 33
  IN03 w0.14: v3(261.33,115.69) 261.57,115.44 261.57,113.65 263.54,111.68 263.54,102.67 260.07,99.19 260.07,97.32 260.97,96.42 260.97,92.35 260.62,92 260.62,89.24 261.54,88.32 262.23,88.32 v3(262.63,88.72)
  BOTTOM w0.152: v3(261.33,115.69) 261.5,115.69 G2.R5 ; U60.N13 v3(262.63,88.72)
MDD54: length 34.8
  IN03 w0.14: v3(264.23,88.72) 263.83,89.12 261.6,89.12 261.23,89.49 261.23,96.95 260.63,97.55 260.63,98.96 264.8,103.13 264.8,107.03 264.27,107.56 264.27,111.76 262.11,113.92 262.11,115.74 261.62,116.23 v3(261.34,116.23)
  BOTTOM w0.152: G2.R6 261.77,116.67 v3(261.34,116.23) ; U60.M11 v3(264.23,88.72)
MDD55: length 34.8
  IN03 w0.14: v3(262.63,89.52) 262.63,90.26 262.09,90.8 262.09,97.33 261.9,97.52 261.46,97.52 261.19,97.79 261.19,98.72 265.36,102.89 265.36,107.53 264.85,108.04 264.85,111.99 262.41,114.43 262.41,117.4 261.72,118.09 260.96,118.09 v3(260.69,118.37)
  BOTTOM w0.152: U60.M13 v3(262.63,89.52) ; G2.U8 v3(260.69,118.37)
MDD56: length 40.9
  IN10 w0.076: v3(262.88,117.07) 262.88,116.94 263.23,116.59 263.88,116.59 263.98,116.48
  IN10 w0.14: 263.98,116.48 263.98,116.09 263.87,115.98 263.87,108.2 264.67,107.4 264.67,101.16 267.25,98.58 267.25,90.63 267.63,90.25 267.63,88.93 268.72,87.83 269.88,87.83 270.2,87.52 272.49,87.52 272.63,87.38 272.63,86.95 272.63,86.95 272.63,86.11 272.44,85.92 271.6,85.92 271.03,85.92 v3(270.63,85.52)
  BOTTOM w0.152: G2.P6 262.49,116.67 v3(262.88,117.07) ; U60.U4 v3(270.63,85.52)
MDD57: length 43.8
  IN10 w0.14: v3(261.49,119.07) 262.38,118.18 262.38,115.27 262.1,114.99 262.1,101.25 265.62,97.72 265.62,93.48 265.33,93.18 265.33,90.6 266.37,89.55 266.37,86.43 268.49,84.31 271.8,84.31 272.23,84.75 v3(272.23,85.52)
  BOTTOM w0.152: G2.R9 v3(261.48,119.07) ; U60.U2 v3(272.23,85.52)
MDD58: length 34.8
  IN10 w0.14: v3(269.83,85.52) 269.4,85.09 268.75,85.09 266.74,87.1 266.74,89.89 266.44,90.2 266.44,97.72 262.78,101.37 262.78,113.21 262.63,113.36 262.63,114.61 v3(262.88,114.87)
  BOTTOM w0.152: U60.T4 v3(269.83,85.52) ; G2.P4 v3(262.88,114.87)
MDD59: length 36.3
  IN10 w0.14: v3(272.23,86.32) 271.83,86.72 268.6,86.72 267.2,88.12 267.2,90.02 266.87,90.35 266.87,98.1 263.42,101.55 263.42,108.02 263.52,108.12 263.52,114.81 262.84,115.49 v3(262.84,115.62)
  BOTTOM w0.152: v3(262.84,115.62) 262.84,115.61 G2.P5 ; U60.T2 v3(272.23,86.32)
MDD60: length 34.8
  IN10 w0.14: v3(264.88,117.67) 264.43,117.21 264.43,116.15 264.15,115.88 264.15,114.28 264.61,113.82 264.61,108.3 265.31,107.6 265.31,101.61 267.65,99.27 267.65,90.94 268.11,90.48 268.11,88.79 268.66,88.24 270.15,88.24 v3(270.63,88.72)
  BOTTOM w0.152: v3(264.88,117.67) 264.59,117.37 G2.L7 ; U60.N4 v3(270.63,88.72)
MDD61: length 33
  IN10 w0.14: v3(264.88,116.37) 264.88,116.25 264.43,115.8 264.43,114.43 264.95,113.92 264.95,108.84 265.88,107.9 265.88,101.87 268.24,99.51 268.24,91.16 268.5,90.9 268.5,89.46 268.84,89.12 271.03,89.12 v3(271.43,88.72)
  BOTTOM w0.152: v3(271.43,88.72) 271.83,88.32 U60.N2 ; G2.L6 v3(264.88,116.37)
MDD62: length 28.8
  IN10 w0.14: v3(270.63,89.52) 268.8,91.35 268.8,99.74 266.44,102.1 266.44,108.19 265.51,109.13 265.51,113.78 264.88,114.4 v3(264.88,114.97)
  BOTTOM w0.152: U60.M4 v3(270.63,89.52) ; G2.L4 v3(264.88,114.97)
MDD63: length 31.7
  IN10 w0.14: v3(272.23,88.72) U60.M2 271.83,89.87 270.98,90.72 270.33,90.72 269.21,91.84 269.21,98.37 269.36,98.52 269.36,99.97 267,102.33 267,108.5 266.47,109.04 266.47,114.43 265.73,115.17 265.38,115.17 v3(264.88,115.67)
  BOTTOM w0.152: G2.L5 v3(264.88,115.67) ; U60.M2 v3(272.23,88.72)
MDI_N0: length 51.8
  TOP w0.081: v2(42.89,66.5) 43.14,66.26 43.14,64.42 43.42,64.14 43.63,64.14 43.68,64.09 U6.12
  IN10 w0.081: v2(42.89,66.5) 43.27,66.87 43.27,70.55 45.43,72.72 45.43,74.73 46.08,75.37 46.08,78.84 44.68,80.24 44.68,84.27 44.29,84.66 42.29,84.66 41.38,85.58 41.38,86.72 38.32,89.77 38.32,96.89 35.94,99.27 35.25,99.27 35.02,99.5 35.02,99.77 34.74,100.06 v2(34.64,100.06)
  BOTTOM w0.081: TL1.3 32.26,100.48 32.34,100.56 32.34,100.9 32.41,100.97 32.82,100.97 33.53,101.69 v2(34.26,101.69) 34.58,101.69 34.89,101.37 34.89,101.08 34.32,100.5 D7.6 34.21,100.06 v2(34.64,100.06)
MDI_N1: length 53.6
  TOP w0.081: U6.15 43.68,62.89 43.63,62.94 41.77,62.94 41.51,63.19 41.51,63.57 v2(41.37,63.71)
  IN10 w0.081: v2(41.37,63.71) 41.59,63.93 41.71,63.93 41.81,63.83 41.81,63.26 41.62,63.07 40.61,63.07 40.3,63.38 40.3,64.42 41.75,65.87 41.75,69.42 40.99,70.18 40.99,73.61 42.51,75.14 42.51,80.31 39.21,83.61 39.21,87.71 37.55,89.37 37.55,94.16 35.15,96.57 35.15,97.9 v2(35.4,98.15)
  BOTTOM w0.081: TL1.6 32.26,97.48 32.4,97.62 32.83,97.62 33.8,96.65 34.87,96.65 35.23,97.01 35.23,97.35 35.4,97.52 35.78,97.52 36.27,98.01 D7.3 35.85,98.6 v2(35.4,98.15)
MDI_N2: length 47.4
  TOP w0.081: v3(42.6,61.47) 42.86,61.74 43.63,61.74 43.68,61.69 U6.18
  IN10 w0.081: v3(42.6,61.47) 42.27,61.81 40.22,61.81 39.22,62.81 39.22,66.98 39.6,67.36 39.6,72.22 39.85,72.48 39.85,77.45 38.2,79.1 38.2,82.91 35.28,85.83 35.28,89.08 36.16,89.96 36.16,92.54 35.39,93.31 35.14,93.31 34.83,93.62 34.83,93.87 v2(34.64,94.06)
  BOTTOM w0.081: v2(34.64,94.06) 34.21,94.06 D6.6 34.32,94.5 34.89,95.08 34.89,95.5 34.69,95.71 33.55,95.71 32.82,94.97 32.41,94.97 32.34,94.9 32.34,94.56 32.26,94.48 TL1.9
MDI_N3: length 50.8
  TOP w0.081: v2(44.67,59.26) 44.42,59.26 44.3,59.38 44.3,59.87 44.9,60.47 45.08,60.47 45.16,60.39 U6.21
  IN10 w0.081: v2(35.4,92.15) 35.14,91.9 35.14,91.39 34.39,90.63 34.39,85.68 37.43,82.64 37.43,78.54 38.82,77.14 38.82,72.62 38.32,72.12 38.32,69.03 38.82,68.53 38.82,67.51 38.58,67.26 38.58,61.93 39.73,60.78 43.41,60.78 44.35,59.84 44.35,59.58 v2(44.67,59.26)
  BOTTOM w0.081: TL1.12 31.81,91.48 31.91,91.59 32.61,91.59 32.81,91.39 32.81,91.19 33.55,90.45 34.84,90.45 35.25,90.86 35.25,91.37 35.4,91.52 35.78,91.52 36.27,92.01 D6.3 35.85,92.6 v2(35.4,92.15)
MDI_P0: length 51.7
  TOP w0.081: U6.11 43.68,64.49 43.63,64.45 43.55,64.45 43.45,64.55 43.45,66.57 43.51,66.63 43.75,66.63 v2(43.88,66.5)
  IN10 w0.081: v2(35.4,100.06) 35.27,99.93 35.27,99.88 35.27,99.88 35.27,99.6 35.36,99.51 36.04,99.51 38.57,96.99 38.57,89.88 41.62,86.82 41.62,85.68 42.39,84.91 44.39,84.91 44.93,84.38 44.93,80.34 46.32,78.95 46.32,75.27 45.68,74.63 45.68,72.62 43.51,70.45 43.51,66.87 v2(43.88,66.5)
  BOTTOM w0.081: v2(35.4,100.06) 35.83,100.06 D7.1 35.72,100.5 35.2,101.02 35.2,101.5 34.71,102 33.4,102 32.69,101.28 32.46,101.28 32.26,101.48 TL1.2
MDI_P1: length 53.6
  TOP w0.081: U6.14 43.68,63.29 43.63,63.25 41.89,63.25 41.82,63.32 41.82,63.71 41.93,63.83 42.14,63.83 v2(42.26,63.71)
  IN10 w0.081: v2(42.26,63.71) 42.06,63.5 42.06,63.16 41.73,62.83 40.51,62.83 40.06,63.27 40.06,64.52 41.51,65.97 41.51,69.32 40.74,70.08 40.74,73.71 42.27,75.24 42.27,80.21 38.97,83.51 38.97,87.61 37.31,89.27 37.31,94.06 34.9,96.47 34.9,97.89 v2(34.64,98.15)
  BOTTOM w0.081: TL1.5 32.26,98.48 32.34,98.4 32.34,98 32.41,97.93 32.96,97.93 33.93,96.96 34.74,96.96 34.92,97.14 34.92,97.37 34.77,97.52 34.43,97.52 33.77,98.18 D7.4 34.19,98.6 v2(34.64,98.15)
MDI_P2: length 47.4
  TOP w0.081: v3(42.6,62.31) 42.86,62.05 43.63,62.05 43.68,62.09 U6.17
  IN10 w0.081: v3(42.6,62.31) 42.35,62.06 40.32,62.06 39.47,62.91 39.47,66.88 39.85,67.26 39.85,72.12 40.1,72.38 40.1,77.55 38.45,79.2 38.45,83.01 35.53,85.93 35.53,88.98 36.41,89.86 36.41,92.64 35.5,93.55 35.24,93.55 35.07,93.72 35.07,93.98 35.15,94.06 v2(35.4,94.06)
  BOTTOM w0.081: v2(35.4,94.06) 35.83,94.06 D6.1 35.72,94.5 35.2,95.02 35.2,95.63 34.81,96.02 33.43,96.02 32.69,95.28 32.46,95.28 32.26,95.48 TL1.8
MDI_P3: length 50.8
  TOP w0.081: v2(43.78,59.26) 43.99,59.47 43.99,60 44.74,60.74 44.74,60.83 44.67,60.89 U6.20
  IN10 w0.081: v2(34.64,92.15) 34.9,91.9 34.9,91.49 34.14,90.73 34.14,85.58 37.18,82.54 37.18,78.44 38.58,77.04 38.58,72.72 38.08,72.22 38.08,68.93 38.58,68.43 38.58,67.61 38.33,67.36 38.33,61.83 39.63,60.53 43.31,60.53 44.11,59.73 44.11,59.58 v2(43.78,59.26)
  BOTTOM w0.081: v2(34.64,92.15) 34.19,92.6 D6.4 33.77,92.18 34.43,91.52 34.77,91.52 34.94,91.34 34.94,90.99 34.71,90.76 v2(34.13,90.76) 33.68,90.76 33.12,91.32 33.12,91.52 32.74,91.9 32.32,91.9 32.27,91.95 32.27,92.38 32.17,92.48 TL1.11
MDO_N0: length 12.7
  IN08 w0.081: v2(20.8,100.48) 20.34,100.93 19.8,100.93 19.41,101.32 19.41,102.69 15.34,106.76 14.45,106.76 14.28,106.59 JRJ1.2
  BOTTOM w0.081: TL1.22 21.74,100.48 21.41,100.82 20.92,100.82 20.8,100.69 v2(20.8,100.48)
MDO_N1: length 13.7
  IN08 w0.081: v2(20.8,97.48) 20.42,97.86 19.57,97.86 18.9,98.53 18.9,100.18 17.63,101.45 17.63,102.47 16.38,103.72 15.72,103.72 15.46,103.46 15.46,102.7 JRJ1.6
  BOTTOM w0.081: TL1.19 21.74,97.48 21.41,97.82 20.92,97.82 20.8,97.69 v2(20.8,97.48)
MDO_N2: length 14.3
  IN10 w0.081: v2(20.8,94.48) 20.55,94.73 19.9,94.73 17.25,97.39 17.25,100.28 15.16,102.37 14.2,102.37 14.12,102.45 14.07,102.51 14.07,102.51 JRJ1.5
  BOTTOM w0.081: v2(20.8,94.48) 20.8,94.69 20.92,94.82 21.41,94.82 21.74,94.48 TL1.16
MDO_N3: length 15.2
  IN08 w0.081: JRJ1.8 14.25,100.37 14.3,100.43 15.19,100.43 15.46,100.16 15.46,96.22 19.72,91.96 20.32,91.96 v2(20.8,91.48)
  BOTTOM w0.081: v2(20.8,91.48) 20.8,91.69 20.92,91.82 21.41,91.82 21.74,91.48 TL1.13
MDO_P0: length 12.8
  IN08 w0.081: JRJ1.1 13.96,106.62 14.34,107.01 15.44,107.01 19.65,102.79 19.65,101.43 19.9,101.18 20.5,101.18 v3(20.8,101.48)
  BOTTOM w0.081: v3(20.8,101.48) 20.8,101.33 21,101.13 21.33,101.13 21.68,101.48 TL1.23
MDO_P1: length 13.8
  IN08 w0.081: v2(20.8,98.48) 20.42,98.1 19.67,98.1 19.15,98.63 19.15,100.28 17.88,101.55 17.88,102.57 16.48,103.97 15.53,103.97 15.34,104.15 15.34,104.33 15.09,104.58 JRJ1.3
  BOTTOM w0.081: v2(20.8,98.48) 20.8,98.33 21,98.13 21.33,98.13 21.68,98.48 TL1.20
MDO_P2: length 14.2
  IN10 w0.081: JRJ1.4 14.25,102.67 14.3,102.62 14.3,102.61 15.26,102.61 17.49,100.38 17.49,97.49 20.01,94.98 20.29,94.98 v2(20.8,95.48)
  BOTTOM w0.081: TL1.17 21.68,95.48 21.33,95.13 21,95.13 20.8,95.33 v2(20.8,95.48)
MDO_P3: length 15.3
  IN08 w0.081: v2(20.8,92.48) 20.52,92.21 19.82,92.21 15.71,96.32 15.71,100.26 15.29,100.67 14.2,100.67 14.12,100.59 14.07,100.53 JRJ1.7
  BOTTOM w0.081: TL1.14 21.68,92.48 21.33,92.13 21,92.13 20.8,92.33 v2(20.8,92.48)
ME_FLASH: length 240.4
  TOP w0.097: v3(246.6,49.86) 246.6,49.99 246.93,50.32 R2286.1
  IN03 w0.091: v2(151.86,40.08) 151.86,41.53 146.74,46.65 119.62,46.65 107.21,34.24 96.11,34.24 95.47,33.61 87.73,33.61 87.09,32.97 84.8,32.97 84.55,32.72 80.23,32.72 79.34,33.61 72.18,33.61 71.29,34.5 64.48,34.5 63.72,35.26 50.77,35.26 49.88,36.15 47.34,36.15 46.81,36.68 46.81,38.31 46.68,38.43 43.91,38.43 41.62,40.72 39.85,40.72 v2(39.21,41.35)
  IN10 w0.091: v2(151.86,40.08) 151.86,40.65 154.47,43.26 202.79,43.26 206.07,46.54 213.73,46.54 215.93,44.34 224.53,44.34 225.11,43.77 236.06,43.77 237.08,44.78 239.74,44.78 241.01,46.05 241.01,47.2 242.28,48.47 243.43,48.47 243.68,48.72 243.68,49.36 244.7,50.37 246.09,50.37 v3(246.6,49.86)
  BOTTOM w0.089: U5.A9 36.28,48.47
  BOTTOM w0.097: v2(39.21,41.35) 38.58,41.35 v1(38.45,41.48) 36.67,43.26 36.67,45.67 36.28,46.07 36.28,48.47
MIC1_VREF_L: length 2.2
  TOP w0.203: U7.38 292.35,34.61 292.74,35 293.54,35 R846.1
MIC1_VREF_R: length 3.5
  TOP w0.203: U7.39 292.28,35.01 292.66,35.39 293.06,35.39 293.64,35.97 R845.1 293.85,36.2 v1(293.85,36.91)
MIC1L_RING2: length 26.3
  TOP w0.254: v2(292.92,33.81) U7.36
  TOP w0.508: v2(299.72,17.53) 299.66,17.59 298.75,17.59 297.69,18.65 297.69,30.62 298.08,31.01 298.08,33.7 296.53,35.26 v2(295.38,35.26) 294.71,35.26 R846.2
  IN05 w0.508: v2(295.38,35.26) 294.74,35.26 293.29,33.81 v2(292.92,33.81)
MIC1R_SLEEVE: length 26.4
  TOP w0.203: v2(292.92,34.5) 292.7,34.5 292.41,34.21 U7.37
  TOP w0.508: v2(299.72,18.29) 299.66,18.22 299.02,18.22 298.32,18.92 298.32,30.35 298.72,30.75 298.72,33.97 296.79,35.89 v2(295.38,35.89) 294.66,35.89 R845.2
  IN05 w0.508: v2(295.38,35.89) 294.48,35.89 293.08,34.5 v2(292.92,34.5)
MIC2_VREF: length 5.2
  TOP w0.254: v2(292.88,35.89) 292.66,35.89 292.18,35.41 U7.40
  BOTTOM w0.508: v2(292.88,35.89) 293.69,35.09 v1(293.69,34.98) D10.2 D9.2
MIC2L: length 2.4
  TOP w0.203: C510.1 293.3,33.33 292.56,33.33 292.48,33.41 U7.35
MIC2L_C: length 25.4
  TOP w0.381: R849.1 296.74,33.06 296.95,33.06 v2(297.12,32.89)
  IN03 w0.508: v2(297.91,13.74) 297.99,13.82 297.99,16.64 297.69,16.94 297.69,26.91 296.48,28.12 296.48,32.27 297.11,32.89 v2(297.12,32.89)
  BOTTOM w0.254: JIO1.74 299.69,14.78 299.56,14.66 298.96,14.66
  BOTTOM w0.381: 298.96,14.66 298.78,14.66 297.91,13.79 v2(297.91,13.74) ; v2(297.12,32.89) 296.43,33.58 R848.2
MIC2R: length 2.7
  TOP w0.203: C511.1 293.78,32.3 293.09,32.99 292.28,32.99 292.26,33.01 U7.34
MIC2R_C: length 23.2
  TOP w0.381: R850.1 296.63,32.49 v2(297.12,32)
  IN03 w0.508: v2(297.12,32) 297.12,28.38 298.32,27.18 298.32,17.32 298.63,17.02 298.63,13.79 v2(298.67,13.74)
  BOTTOM w0.254: 298.9,14.06 299,14.06 299.21,14.27 299.74,14.27 299.85,14.38 JIO1.75
  BOTTOM w0.381: 298.9,14.06 298.67,13.83 v2(298.67,13.74) ; R847.2 296.66,32.47 v2(297.12,32)
MIC_JD: length 2
  TOP w0.097: v2(301.5,19.56) 301.73,19.33 R312.2
  BOTTOM w0.097: v2(301.5,19.56) 301.48,19.58 JIO1.62
MPHY_EXT_PWR_GATE_N: length 1.5
  TOP w0.097: TP76.1 236.32,56.98 v3(235.93,56.59)
  BOTTOM w0.097: U2.AN24 236.4,57.06 v3(235.93,56.59)
MX0: length 29.9
  IN10 w0.091: v2(57.63,49.61) 60.42,49.61 v2(62.07,51.26)
  BOTTOM w0.076: 38.58,53.66 38.04,53.66 37.78,53.91 U5.J12
  BOTTOM w0.097: JEC1.15 62.97,51.91 62.33,51.26 v2(62.07,51.26) ; 38.58,53.66 40.19,53.66 40.71,54.18 45.43,54.18 48.36,51.26 48.36,51.01 49.24,50.12 49.24,49.86 50.13,48.97 57.25,48.97 57.63,49.36 v2(57.63,49.61)
MX1: length 23.1
  BOTTOM w0.097: U5.J13 40.1,53.91 40.63,54.44 45.56,54.44 48.48,51.51 v1(49.24,51.51) 50.01,51.51 52.04,49.48 54.59,49.48 55.86,50.75 56.43,50.75 57.47,51.8 JEC1.26
MX2: length 27
  IN03 w0.089: v1(37.31,54.94) 37.81,54.94 38.7,54.05 39.97,54.05
  IN03 w0.091: v2(57.88,54.56) 57.64,54.32 56.61,54.32 56.58,54.28 54.6,54.28 54.58,54.31 40.86,54.31 40.61,54.05 39.97,54.05
  BOTTOM w0.076: v1(37.31,54.94) 37.03,54.67 37.03,54.31 36.88,54.16 36.67,54.16 36.52,54.16 U5.J9
  BOTTOM w0.097: v2(57.88,54.56) 58.26,54.18 59.66,54.18 60.97,52.87 JEC1.19
MX3: length 30.9
  BOTTOM w0.076: U5.H12 37.78,53.41 38.04,53.16 38.58,53.16
  BOTTOM w0.097: 38.58,53.16 40.61,53.16 41.11,53.66 45.2,53.66 46.32,52.53 v1(46.32,51.9) 46.32,50.5 47.72,49.1 49.24,49.1 49.88,48.47 54.28,48.47 54.91,47.83 56.77,47.83 57.4,48.47 59.79,48.47 61.47,50.15 JEC1.18
MX4: length 24.8
  IN03 w0.089: 39.97,53.55 37.81,53.55 v1(37.43,53.17)
  IN03 w0.091: v2(57.25,53.67) 56.74,53.17 54.07,53.17 53.47,53.77 46.83,53.77 46.61,53.55 39.97,53.55
  BOTTOM w0.076: v1(37.43,53.17) 37.43,53.17 36.88,53.17 36.67,53.17 36.43,53.41 U5.H9
  BOTTOM w0.097: JEC1.22 59.47,53.1 59.15,53.42 57.5,53.42 v2(57.25,53.67)
MX5: length 25
  IN03 w0.089: 39.97,53.78 v1(37.38,53.78)
  IN03 w0.091: 39.97,53.78 46.5,53.78 46.7,53.99 53.63,53.99 54.2,53.42 56.23,53.42 56.91,54.1 57.71,54.1 v2(57.88,53.93)
  BOTTOM w0.089: U5.H10 37.15,53.78 v1(37.38,53.78)
  BOTTOM w0.097: v2(57.88,53.93) 59.28,53.93 59.97,53.23 JEC1.21
MX6: length 26.4
  BOTTOM w0.097: JEC1.24 58.47,49.69 57.5,48.72 50.01,48.72 49.12,49.61 48.61,49.61 TP147.1 v1(47.59,50.63) 47.47,50.75 47.47,51.78 45.31,53.93 40.99,53.93 40.47,53.41 U5.H13
MX7: length 36.3
  IN05 w0.089: 33.62,54.56 33.62,53.04 34.6,52.07 35.57,52.07 35.81,52.3 v1(35.81,52.91)
  IN05 w0.091: v2(49.63,50.5) 49.24,50.5 45.71,54.03 41.25,54.03 40.97,54.31 39.82,54.31 38.04,56.09 34.26,56.09 33.62,55.45 33.62,54.56
  BOTTOM w0.089: U5.G9 v1(35.81,52.91)
  BOTTOM w0.097: v2(49.63,50.5) 49.88,50.5 TP152.1 51.15,49.23 56.99,49.23 57.12,49.36 57.12,50.12 57.97,50.97 JEC1.25
MXLID_N: length 302
  TOP w0.097: R369.1 182.92,194.01 C416.2 182.04,194.69 181.83,194.9 180.82,194.9 180.56,195.15 180.56,196.29 181.2,196.93 182.09,196.93 182.34,197.18 v2(182.34,198.2)
  IN03 w0.091: v2(34.64,40.97) 35.27,41.61 35.27,41.74 36.54,43.01 36.54,43.39 37.23,44.07 46.66,44.07 46.83,43.89 51.8,43.89 53.71,45.8 61.31,45.8 64.15,48.64 66.4,48.64 67.37,47.67 67.37,45.33 68.04,44.66 77.06,44.66 v2(78.45,46.05)
  IN05 w0.089: 32.99,46.69 v1(32.48,47.2)
  IN05 w0.091: 32.99,46.69 32.99,46.69 32.99,42.62 v2(34.64,40.97)
  IN10 w0.091: v2(182.34,198.2) 182.22,198.08 178.03,198.08 177.87,197.92 175.54,197.92 173.48,199.98 166.72,199.98 166.2,199.46 160.34,199.46 158.83,197.95 155.42,197.95 147.54,190.07 147.54,184.48 145.13,182.07 128.24,182.07 126.08,179.91 120.11,179.91 114.01,173.82 114.01,133.18 110.14,129.3 110.14,119.14 100.3,109.3 97.5,109.3 88.11,99.9 88.11,94.06 83.28,89.23 83.28,82.25 81.8,80.77 81.8,75.94 80.74,74.88 80.74,73.1 73.83,66.2 73.83,64.54 71.6,62.31 71.6,59.52 72.87,58.25 72.87,54.18 73.63,53.42 73.63,50.88 v2(78.45,46.05)
  BOTTOM w0.097: v1(32.48,47.2) 32.48,47.55 33.12,48.19 33.12,49.32 33.27,49.48 U5.A3
MY0: length 32.8
  IN10 w0.091: v2(60.29,51.51) 60.04,51.77 56.74,51.77 54.96,53.55 54.96,56.01 v2(55.34,56.39)
  BOTTOM w0.076: 36.03,56.21 36.03,55.67 35.77,55.42 U5.M8
  BOTTOM w0.097: v2(55.34,56.39) 54.76,56.98 52.42,56.98 52.17,56.72 49.37,56.72 47.97,58.12 36.8,58.12 36.29,57.61 36.29,56.88 36.03,56.62 36.03,56.21 ; v2(60.29,51.51) 60.47,51.69 JEC1.20
MY1: length 34.8
  IN03 w0.089: 41.5,55.58 40.1,55.58 39.59,56.09 34.51,56.09 33.62,55.2 33.62,54.56 34.39,53.8 34.89,53.8 v1(35.27,53.42)
  IN03 w0.091: v2(57.88,55.71) 57.37,56.21 56.23,56.21 55.98,55.96 52.67,55.96 52.29,55.58 41.5,55.58
  BOTTOM w0.089: U5.J7 v1(35.27,53.42)
  BOTTOM w0.097: v2(57.88,55.71) 58.13,55.71 v1(58.64,55.2) 59.02,54.82 59.91,54.82 60.93,53.8 61.69,53.8 62.47,53.02 JEC1.16
MY2: length 34.3
  IN10 w0.091: v2(63.09,51.26) 63.09,51.64 62.58,52.15 61.82,52.15 60.67,51.01 57.12,51.01 54.58,53.55 54.58,55.71 v2(53.82,56.47)
  BOTTOM w0.097: JEC1.14 63.47,51.65 v2(63.09,51.26) ; U5.N9 36.28,56.1 38.05,57.87 47.71,57.87 49.12,56.47 v2(53.82,56.47)
MY3: length 35.3
  IN10 w0.091: v2(66.26,51.3) 64.77,52.78 57.25,52.78 56.23,53.8 56.23,54.18 v2(55.47,54.94)
  BOTTOM w0.076: 36.53,56.09 36.53,55.67 36.28,55.42 U5.M9
  BOTTOM w0.097: v2(55.47,54.94) 54.45,55.96 53.56,55.96 53.31,56.21 48.74,56.21 47.33,57.62 38.06,57.62 36.53,56.09 ; v2(66.26,51.3) 65.97,51.59 JEC1.9
MY4: length 31.4
  IN03 w0.089: 41.5,54.94 41.37,55.07 38.88,55.07 38.37,55.58 36.16,55.58 35.77,55.19 v1(35.77,54.94)
  IN03 w0.091: 41.5,54.94 41.62,54.82 54.32,54.82 54.96,55.45 56.1,55.45 56.36,55.2 59.28,55.2 v2(59.4,55.32)
  BOTTOM w0.089: U5.K8 v1(35.77,54.94)
  BOTTOM w0.097: v2(59.4,55.32) 59.79,55.32 61.06,54.05 62.2,54.05 v1(62.33,53.93) 62.96,53.29 63.72,53.29 63.97,53.04 JEC1.13
MY5: length 33.8
  IN03 w0.089: 41.5,55.32 39.97,55.32 39.47,55.83 34.51,55.83 33.88,55.2 33.88,54.69 34.51,54.05 35.15,54.05 v1(35.77,53.43)
  IN03 w0.091: 41.5,55.32 52.67,55.32 53.08,55.73 54.81,55.73 54.83,55.71 v2(56.99,55.71)
  BOTTOM w0.089: U5.J8 v1(35.77,53.43)
  BOTTOM w0.097: JEC1.17 61.97,53.01 61.44,53.55 60.67,53.55 59.79,54.44 58.62,54.44 57.98,55.07 57.85,55.07 57.22,55.71 v2(56.99,55.71)
MY6: length 36.8
  IN10 w0.091: v2(65.47,51.26) 65.47,51.29 64.99,51.77 64.54,51.77 64.28,51.51 64.28,50.93 63.98,50.63 62.83,50.63 62.58,50.88 62.58,51.64 62.33,51.9 61.94,51.9 60.8,50.75 56.99,50.75 54.07,53.67 v2(54.07,55.3)
  BOTTOM w0.097: U5.N10 36.78,56.07 38.08,57.37 47.2,57.37 48.61,55.96 52.93,55.96 53.59,55.3 v2(54.07,55.3) ; JEC1.10 v2(65.47,51.26)
MY7: length 32.1
  IN10 w0.091: v2(55.54,53.85) 55.67,53.85 56.99,52.53 62.83,52.53 63.85,51.51 v2(63.85,51.26)
  BOTTOM w0.076: 37.03,56.06 37.03,55.67 36.78,55.42 U5.M10
  BOTTOM w0.097: v2(63.85,51.26) 64.47,51.88 JEC1.12 ; v2(55.54,53.85) 54.71,54.69 53.82,54.69 52.8,55.71 48.23,55.71 47.09,56.85 v1(45.69,56.85) 44.05,56.85 43.78,57.12 38.08,57.12 37.03,56.06
MY8: length 35.6
  IN10 w0.091: v2(54.58,51.64) 55.09,51.13 55.09,49.74 55.72,49.1 63.09,49.1 64.74,50.75 v2(64.74,51.26)
  BOTTOM w0.097: U5.N11 37.28,56.03 38.12,56.87 43.15,56.87 43.62,56.4 47.15,56.4 48.1,55.45 52.67,55.45 53.94,54.18 53.94,52.28 v2(54.58,51.64) ; JEC1.11 64.97,51.49 v2(64.74,51.26)
MY9: length 26.4
  IN03 w0.091: v2(57.09,54.75) 56.91,54.56 56.18,54.56 56.13,54.51 55.01,54.51 54.96,54.56 40.61,54.56 40.35,54.31 38.96,54.31 37.94,55.32 36.67,55.32 v1(36.28,54.93)
  BOTTOM w0.089: U5.K9 v1(36.28,54.93)
  BOTTOM w0.097: JEC1.23 58.97,52.96 58.77,53.17 57.12,53.17 56.74,53.55 56.74,54.39 v2(57.09,54.75)
MY10: length 41.9
  BOTTOM w0.076: 38.43,55.66 38.04,55.66 37.78,55.91 U5.N12
  BOTTOM w0.089: v1(41.12,56.09) 41.5,56.09
  BOTTOM w0.097: 41.5,56.09 41.85,55.73 46.81,55.73 47.72,54.82 51.91,54.82 52.8,53.93 52.8,51.23 52.85,51.18 55.01,51.18 55.98,52.15 55.98,56.34 56.48,56.85 59.53,56.85 61.44,54.94 62.71,54.94 63.6,54.05 67.15,54.05 67.79,53.42 68.17,53.42 68.47,53.11 JEC1.4 ; v1(41.12,56.09) 40.76,55.73 40.08,55.73 39.59,56.21 38.98,56.21 38.43,55.66
MY11: length 41.9
  IN10 w0.091: v2(53.31,51.64) 53.31,49.56 56.43,46.43 65.87,46.43 68.04,48.61 v2(68.04,51.26)
  BOTTOM w0.097: v2(68.04,51.26) 67.97,51.33 JEC1.5 ; U5.N13 38.32,55.91 39,56.59 42.89,56.59 43.4,56.09 46.96,56.09 47.97,55.07 52.55,55.07 53.31,54.31 v2(53.31,51.64)
MY12: length 37
  IN10 w0.091: v2(67.02,51.26) 64.48,48.72 55.59,48.72 54.58,49.74 v2(54.58,50.75)
  BOTTOM w0.097: v2(67.02,51.26) 66.47,51.81 JEC1.8 ; U5.M13 38.53,55.41 39.08,55.97 39.46,55.97 39.92,55.5 46.02,55.5 46.96,54.56 51.66,54.56 52.42,53.8 52.42,50.94 52.87,50.5 53.72,50.5 53.97,50.75 v2(54.58,50.75)
MY13: length 40
  BOTTOM w0.076: 38.58,54.66 38.04,54.66 37.78,54.91 U5.L12
  BOTTOM w0.097: JEC1.7 66.97,53.22 66.64,53.55 63.34,53.55 62.45,54.44 61.06,54.44 59.28,56.21 56.74,56.21 56.48,55.96 56.48,51.72 54.63,49.86 52.04,49.86 51.15,50.75 51.15,53.04 50.77,53.42 v1(48.36,53.42) 47.34,53.42 45.73,55.03 39.92,55.03 39.54,54.66 38.58,54.66
MY14: length 40.5
  BOTTOM w0.097: U5.L13 39.42,54.91 39.78,55.27 45.87,55.27 47.09,54.05 v1(50.39,54.05) 51.66,54.05 52.17,53.55 52.17,50.75 52.8,50.12 54.55,50.12 56.23,51.79 56.23,56.21 56.48,56.47 59.53,56.47 61.31,54.69 62.58,54.69 63.47,53.8 67.02,53.8 67.41,53.42 67.41,52.58 JEC1.6
MY15: length 40.4
  IN10 w0.091: v2(50.64,51.9) 50.64,51.01 55.72,45.93 65.74,45.93 68.97,49.16 v2(68.97,51.26)
  BOTTOM w0.076: 38.58,54.16 38.04,54.16 37.78,54.41 U5.K12
  BOTTOM w0.097: v2(50.64,51.9) 50.13,52.4 47.97,52.4 45.67,54.7 40.6,54.7 40.05,54.16 38.58,54.16 ; JEC1.3 v2(68.97,51.26)
NBSWON_N: length 391.7
  TOP w0.097: v2(32.48,46.18) 32.23,45.93 R250.2 ; R854.1 104.62,2.04 104.41,2.24 v2(103.22,2.24)
  IN03 w0.091: v2(103.22,2.24) 97.63,2.24 97.12,2.75 88.87,2.75 88.11,3.51 85.69,3.51 85.44,3.25 81.25,3.25 80.82,3.68 79.25,3.68 78.44,2.87 70.71,2.87 69.56,4.02 67.66,4.02 67.28,3.64 61.06,3.64 59.28,5.41 54.96,5.41 52.55,3 31.08,3 28.92,5.16 28.89,5.16 28.16,5.89 28.16,18.24 27.4,19 27.4,25.1 28.16,25.86 28.16,44.28 29.56,45.67 31.97,45.67 v2(32.48,46.18)
  IN05 w0.091: v2(103.22,2.24) 108.05,2.24 113.25,7.45 113.25,26.59 114.98,28.32 118.92,28.32 120.77,30.17 120.77,42.27 122.02,43.51 193.39,43.51 195.04,45.16 195.04,45.67 195.29,45.93 212.53,45.93 212.78,45.67 214.43,45.67 215.26,44.84 224.44,44.84 225.16,44.12 228.81,44.12 229.36,43.57 233.68,43.57 235.96,41.29 250.22,41.29 254.67,45.74 266.36,45.74 266.92,46.31 268.45,46.31 269.08,45.67 269.08,44.24 270.53,42.79 273.22,42.79 275,44.57 277.27,44.57 279.04,42.79 287.37,42.79 288.2,41.96 293.6,41.96 296.42,39.14 296.87,39.14 300.69,35.31 300.69,25.95 301.12,25.53 302.42,25.53 v2(302.89,25.05)
  BOTTOM w0.076: U5.B4 33.77,50.4 33.52,50.15 33.52,49.23
  BOTTOM w0.097: 33.52,49.23 33.37,49.08 33.37,48.18 32.86,47.67 32.86,46.56 v2(32.48,46.18) ; v2(302.89,25.05) 302.38,24.54 301.72,24.54 301.56,24.38 JIO1.50
NOVO_BTN_N: length 320.7
  IN05 w0.091: v2(255.22,43.13) 255.88,43.79 257.83,43.79 258.52,44.48 263.42,44.48 264.01,45.07 267.53,45.07 270.32,42.28 273.43,42.28 275.21,44.06 277.05,44.06 278.83,42.28 287.21,42.28 287.99,41.51 293.44,41.51 296.24,38.7 296.68,38.7 300.18,35.2 300.18,24.3 300.46,24.03 v2(302.1,24.03) ; v2(33.62,42.88) 33.71,42.96 44.59,42.96 45.05,42.5 49.05,42.5 51.74,39.8 51.74,35.81 57.1,30.45 57.61,30.45 58.47,29.59 63.55,29.59 65.38,27.77 71.23,27.77 74.05,30.58 83.53,30.58 83.77,30.81 93.09,30.81 93.73,31.45 98.01,31.45 99.72,33.16 111.21,33.16 111.55,33.49 114.67,33.49 v2(115.06,33.1)
  IN08 w0.091: v2(255.22,43.13) 255.09,43.26 235.93,43.26 235.43,43.77 223.74,43.77 222.69,42.72 216.41,42.72 213.2,45.93 202.66,45.93 199.67,42.93 193.46,42.93 190.6,45.8 170.78,45.8 168.98,47.6 119.28,47.6 113.89,42.21 113.89,37.42 114.65,36.66 114.65,33.51 v2(115.06,33.1)
  BOTTOM w0.097: JIO1.51 302.05,23.98 v2(302.1,24.03) ; R265.2 R249.2 34.08,45.17 34.08,43.61 33.62,43.16 v2(33.62,42.88)
