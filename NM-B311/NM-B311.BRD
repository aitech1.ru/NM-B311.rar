# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_TX_DP3: length 279.5
  TOP w0.104: C500.1 21.33,30.11 21.61,30.11 v2(21.98,30.47)
  IN03 w0.114: v3(242.95,73.54) 242.95,73.71 243.06,73.83 243.22,73.83 243.33,73.71 243.33,73.01 242.38,72.06 242.38,67.77 241.94,67.33 241.51,67.33 241.4,67.43 240.73,67.43 240,66.7 240,65.86 239.65,65.51 237.23,65.51 236.7,64.98 236.7,62.56 236.25,62.11 232.18,62.11 231.53,62.77 227.76,62.77 226.6,61.61 223.94,61.61 222.11,59.78 219.95,59.78 219.31,59.15 217.63,59.15 217.25,59.53 214.33,59.53 210.77,63.08 139.27,63.08 138.27,64.09 128.37,64.09 126.46,65.99 117.19,65.99 116.03,67.15 110.95,67.15 109.5,68.6 106.72,68.6 106.28,68.16 90.54,68.16 84.69,62.32 70.82,62.32 70.31,62.83 60.82,62.83 57.38,59.39 55.97,59.39 54.56,60.8 38.21,60.8 37.18,59.77 33.88,59.77 32.37,58.26 29.83,58.26 29.58,58 28.31,58 27.29,56.99 26.53,56.99 24.75,55.21 22.59,55.21 19.9,52.52 19.9,42.45 18.89,41.44 18.89,33.48 19.59,32.78 22.26,32.78 22.83,32.21 22.83,29.92 22.76,29.85 22.56,29.85 22.43,29.98 22.43,30.52 22.33,30.62 22.12,30.62 v2(21.98,30.47)
  BOTTOM w0.076: U2.D13 242.26,71.73 242.58,72.05 242.58,73.68 242.65,73.74 242.74,73.74 v3(242.95,73.54)
USB3_TX_DP3_C: length 1.6
  TOP w0.104: C500.2 20,30.35 CM11.3 18.9,30.43 R529.1
USB3_TX_DP3_R: length 8.9
  TOP w0.104: R529.2 17.59,30.35 CM11.4 16.81,30.35 16.57,30.11 16.28,30.11 15.96,29.79 15.64,29.79 15.51,29.91 D53.10 D53.1 14.14,29.91 14.02,29.79 13.8,29.79 13.68,29.91 13.68,31.68 v2(13.53,31.83) 13.53,31.83 13.04,32.33 12.16,32.33 12.05,32.44 JUSB2.9
USB3_TX_DP6: length 115
  IN10 w0.114: v2(307.55,28.9) 307.42,28.76 307.29,28.76 307.16,28.9 307.16,29.64 306.8,30 301.79,30 301.19,30.6 301.19,35.9 297.91,39.17 297.91,42.87 296.24,44.54 295.61,44.54 293.22,46.93 293.22,47.82 291.57,49.47 291.57,56.58 290.4,57.75 289.39,57.75 285.71,61.43 281.13,61.43 279.64,62.93 279.64,67.25 278.85,68.04 266.3,68.04 263.87,65.61 256.25,65.61 255.75,65.1 255.75,64.21 254.4,62.87 252.3,62.87 252.23,62.94 248.89,62.94 247.75,64.09 247.75,66.37 246.35,67.77 245.35,67.77 243.61,69.51 243.61,69.7 243.36,69.95 243.17,69.95 243.01,70.1 243.01,70.14 243.01,70.31 242.79,70.53 242.75,70.53 242.59,70.53 242.43,70.68 242.43,71.55 242.25,71.73 242.25,71.8 242.25,71.93 242.01,72.17 241.81,72.17 241.66,72.32 241.66,73.28 v3(241.86,73.49)
  BOTTOM w0.076: U2.C15 241.19,72.07 241.4,72.28 241.4,72.59 241.52,72.71 241.52,73.37 241.63,73.49 v3(241.86,73.49)
  BOTTOM w0.104: v2(307.55,28.9) 307.38,28.73 307.38,28.18 306.85,27.65 305.61,27.65 305.29,27.97 302.21,27.97 301.82,27.58 JIO1.42
USB3_TX_DP6_C: length 1.5
  TOP w0.104: CM14.3 22.68,60.21 arc(22.88,60.07) 23.11,60.03 23.41,60.03 arc(23.68,60.14) C648.2
USB_CHG_CLT1: length 17.5
  TOP w0.097: U21.6 22.06,42.24 v2(22.32,42.5)
  IN08 w0.089: 29.81,48.41 v1(29.81,48.47)
  IN08 w0.091: v2(22.32,42.5) 22.45,42.37 26.89,42.37 29.18,44.66 29.18,46.82 29.42,47.06 29.42,48.02 29.81,48.41
  BOTTOM w0.076: U5.C2 32.77,50.91 32.51,51.16 32,51.16
  BOTTOM w0.097: v1(29.81,48.47) 30.34,48.99 30.34,49.51 32,51.16
USB_CHG_CLT2: length 32.3
  TOP w0.097: U21.7 v2(21.56,42.5)
  IN08 w0.091: v2(21.56,42.5) 22.07,41.99 23.84,41.99 23.97,42.12 28.29,42.12 30.55,39.86 32.2,39.86 32.99,39.07 32.99,38.18 33.62,37.54 35.53,37.54 v2(36.16,38.18)
  BOTTOM w0.076: U5.B8 36.02,50.16 36.02,49.1
  BOTTOM w0.097: v2(36.16,38.18) 36.16,38.94 v1(37.31,40.08) 37.81,40.59 37.81,41.74 36.44,43.11 36.44,45.49 36.02,45.91 36.02,49.1
USB_CHG_CLT3: length 20
  TOP w0.097: U21.8 21.06,42.36 v2(20.92,42.5) v1(20.92,43.1)
  IN08 w0.089: v1(29.81,50.24) 30.19,49.86 30.19,49.1 29.94,48.85 29.81,48.85
  IN08 w0.091: 29.81,48.85 29.59,48.85 29.43,48.7 29.43,48.34 29.18,48.09 29.18,47.45 28.92,47.2 28.42,47.2 28.16,46.94 28.16,44.78 26.71,43.34 21.76,43.34 v2(20.92,42.5)
  BOTTOM w0.097: U5.E1 31.95,51.91 30.52,50.47 30.04,50.47 v1(29.81,50.24)
USB_CHG_EN: length 17.8
  TOP w0.097: v2(22.19,44.78) 22.45,45.04 v1(22.96,45.04) 23.08,44.91 23.08,44.48 R498.1
  IN08 w0.091: v2(22.19,44.78) 23.39,43.59 26.61,43.59 27.91,44.89 27.91,47.7 28.32,48.11 28.82,48.11 29.18,48.47 29.18,48.97 29.56,49.36 v1(29.81,49.36)
  BOTTOM w0.097: U5.D1 31.98,51.41 30.26,49.7 30.15,49.7 v1(29.81,49.36)
USB_CHG_ILIM_HI: length 2.6
  TOP w0.097: R505.1 21.56,36.27 v1(22.53,37.25) 22.56,37.28 U21.16
USB_CHG_ILIM_LO: length 2.8
  TOP w0.097: U21.15 22.06,37.54 20.75,36.22 R504.1
USB_CHG_ILIM_SEL: length 2.9
  TOP w0.097: U21.4 23.71,40.71 23.84,40.85 23.84,42.12 23.72,42.24 R503.1
USB_CHG_STATUS_N: length 23.7
  TOP w0.097: v2(19.15,42.62) 19.15,41.35 19.79,40.71 U21.9
  IN08 w0.091: v2(19.15,42.62) 20.16,42.62 21.05,41.74 24.23,41.74 24.35,41.86 28.04,41.86 30.27,39.63 31.03,39.63 31.21,39.45 31.21,38.69 v2(31.72,38.18)
  BOTTOM w0.097: R540.2 36.21,41.28 34.64,39.7 34.26,39.7 32.73,38.18 v2(31.72,38.18)
USB_OC0_N: length 118.9
  TOP w0.097: RP1.1 223.86,62.07 224,61.93 224,61.29 v3(224.89,60.4)
  IN03 w0.091: v2(256.64,57.1) 257.14,57.61 257.14,59.01 256.76,59.39 256.76,60.02 257.91,61.17 258.79,61.17 260.04,59.92 263.98,59.92 265.02,58.88 265.02,55.32 265.78,54.56 265.78,51.13 266.92,49.99 266.92,46.56 267.43,46.05 v2(267.43,45.55)
  IN05 w0.091: v2(302.09,25.05) 300.96,25.05 300.44,25.57 300.44,35.26 296.78,38.92 296.33,38.92 293.52,41.74 288.07,41.74 287.3,42.5 278.92,42.5 277.14,44.28 275.12,44.28 273.34,42.5 270.41,42.5 267.43,45.48 v2(267.43,45.55)
  IN08 w0.091: v2(256.64,57.1) 255.58,58.15 254.79,58.15 254.46,58.49 248.5,58.49 247.11,57.1 242.41,57.1 241.9,57.61 237.71,57.61 237.2,58.12 231.87,58.12 230.35,59.64 227.81,59.64 227.3,60.15 225.65,60.15 225.39,60.4 v3(224.89,60.4)
  BOTTOM w0.097: U2.AD43 227.32,61.57 226.99,61.24 225.72,61.24 v3(224.89,60.4) ; JIO1.49 301.82,24.78 v2(302.09,25.05)
USB_OC1_N: length 278.6
  TOP w0.097: U18.3 18.97,67.69 19.15,67.52 19.53,67.52 v2(20.42,68.41) ; v3(228.19,62.06) 227.76,61.62 225.11,61.62 223.67,63.07 RP1.3
  IN03 w0.091: v2(34,38.18) 34,37.8 34.39,37.42 35.4,37.42 35.68,37.7 35.68,38.59 36.04,38.94 38.96,38.94 39.97,37.93 39.97,33.73 42.01,31.7 56.71,31.7 57.34,31.07 62.2,31.07 63.6,29.67 70.33,29.67 72.74,27.26 76.3,27.26 77.18,26.37 82.39,26.37 83.28,27.26 97.76,27.26 100.34,29.84 109.51,29.84 113.66,33.99 115.16,33.99 115.67,34.5 118.15,34.5 121.89,38.23 121.89,41.35 122.96,42.43 128.95,42.43 132.99,38.38 134.92,38.38 v2(135.35,38.81)
  IN08 w0.089: 29.81,51.26 30.96,51.26 34.26,47.96 34.26,46.82 34.13,46.69
  IN08 w0.091: v2(34,38.18) 34.13,38.31 34.13,46.69 ; v2(20.42,68.41) 20.92,68.91 22.19,68.91 22.7,68.41 22.7,67.64 23.1,67.25 23.1,56.07 23.7,55.47 24.72,55.47 25.88,54.31 25.88,52.28 26.89,51.26 29.81,51.26
  IN10 w0.091: v2(135.35,38.81) 136.11,39.58 136.11,42.28 147.38,53.55 160.24,53.55 160.88,54.18 166.49,54.18 167.47,55.16 173.21,55.16 174.34,56.29 180.51,56.29 183.48,59.26 183.48,61.04 183.74,61.29 199.49,61.29 201.02,59.76 203.06,59.76 204.19,58.63 215.49,58.63 220.47,63.61 223.71,63.61 224.38,62.94 226.28,62.94 227.17,62.06 v3(228.19,62.06)
  BOTTOM w0.097: U2.AD42 227.83,61.7 v3(228.19,62.06)
USB_OC2_N: length 253
  TOP w0.097: v3(229.46,61.04) 229.33,61.04 228.77,61.6 228.19,61.6 227.96,61.37 225.04,61.37 223.84,62.57 RP1.2 ; U21.13 21.06,37.35 v2(20.92,37.21)
  IN03 w0.091: v2(30.7,39.2) 31.19,39.68 32.25,39.68 33.11,38.82 33.63,38.82 34.51,39.7 40.1,39.7 40.85,38.96 40.85,38.51 40.99,38.37 40.99,34.88 43.15,32.72 57.25,32.72 57.88,32.08 66.9,32.08 68.2,30.78 70.87,30.78 73.12,28.53 76.93,28.53 77.82,27.64 81.76,27.64 82.65,28.53 97.12,28.53 99.53,30.94 108.96,30.94 113.96,35.94 116.73,35.94 120.8,40.01 120.8,42.14 122.41,43.75 131.68,43.75 v2(135.35,40.08)
  IN08 w0.091: v2(20.92,37.21) 20.92,38.69 21.23,38.99 30.5,38.99 v2(30.7,39.2)
  IN10 w0.091: v3(229.46,61.04) 229.46,61.29 229.33,61.42 229.33,62.69 229.08,62.94 227.43,62.94 227.04,63.33 224.5,63.33 224,63.83 220.38,63.83 215.43,58.88 204.31,58.88 203.21,59.98 201.18,59.98 199.49,61.67 183.61,61.67 183.23,61.29 183.23,59.39 180.36,56.52 168.46,56.52 166.38,54.44 160.62,54.44 159.99,53.8 147.27,53.8 135.35,41.88 v2(135.35,40.08)
  BOTTOM w0.097: v3(229.46,61.04) 229.46,61.09 U2.AD39
USB_OC3_N: length 123.6
  TOP w0.097: v3(225.27,62.01) 223.71,63.57 RP1.4
  IN05 w0.091: v2(305.02,25.05) 303.4,26.67 302.13,26.67 301.2,27.6 301.2,35.42 296.94,39.68 296.94,49.31 296.51,49.74 295.5,49.74 290.42,54.82 290.42,56.72 288.26,58.88 280.06,58.88 279.97,58.97 275.6,63.34 268.84,63.34 268.32,62.82 260.5,62.82 259.05,61.36 259.05,58.83 258.08,57.86 v2(256.64,57.86)
  IN08 w0.091: v2(256.64,57.86) 256.13,58.37 255.02,58.37 254.68,58.71 248.43,58.71 247.07,57.35 242.46,57.35 241.56,58.25 240.13,58.25 239.74,58.63 238.35,58.63 237.97,58.25 237.59,58.25 236.82,59.01 231.62,59.01 230.73,59.9 228.31,59.9 226.92,61.29 225.98,61.29 v3(225.27,62.01)
  BOTTOM w0.097: U2.AC44 226.72,62.34 226.63,62.34 226.54,62.44 225.69,62.44 v3(225.27,62.01) ; JIO1.48 301.62,25.18 301.99,25.55 303.25,25.55 303.53,25.27 303.53,25.04 304.03,24.54 304.51,24.54 v2(305.02,25.05)
USB_OC_N: length 3.4
  TOP w0.097: v3(227.93,64.47) 227.76,64.65 R875.2
  BOTTOM w0.097: U2.W43 227.59,64.47 v3(227.93,64.47) 228.32,64.08 U2.Y41 ; U2.W43 U2.W44 ; U2.W43 227.48,64.01 U2.Y43
USB_OTG_VBUSSENSE: length 4.1
  TOP w0.097: R62.2 246.68,60.68 246.37,60.38 244.62,60.38 v3(244.06,60.94)
  BOTTOM w0.097: v3(244.06,60.94) 243.86,61.14 U2.AD10
USB_STATUS_N_R: length 8.9
  BOTTOM w0.097: U5.A8 35.77,45.63 35.99,45.42 R379.2 35.6,45.11 35.53,45.04 35.53,42.75 v1(35.64,42.64) 36.09,42.19 R540.1
V_PATH: length 57.8
  TOP w0.508: PR204.1 84.55,15.52 84.84,15.81 84.84,19.44 v2(83.53,20.74)
  IN03 w0.508: v2(38.7,27.38) 39.39,28.07 43.2,28.07 46.32,31.19 56.61,31.19 58.64,29.16 70.2,29.16 72.61,26.75 75.79,26.75 79.98,22.56 82.47,22.56 82.88,22.15 82.88,21.4 v2(83.53,20.74)
  vias: v1(37.69,33.48)
VBL_INT_N: length 287.4
  IN05 w0.091: v2(43.28,51.9) 43.28,51.62 43.87,51.03 43.87,50.54 45.81,48.59 47.78,48.59 48.67,47.7 51.41,47.7 52.8,46.31 52.8,44.53 54.95,42.38 54.95,37.94 58.52,34.37 v2(59.28,34.37)
  IN10 w0.091: v2(59.28,34.37) 60.47,35.56 67.31,35.56 68.33,36.58 68.33,41.78 66.93,43.18 66.93,46.35 69.82,49.25 69.82,65.23 73.37,68.79 75.41,68.79 78.71,72.09 78.71,77.68 80.74,79.71 80.74,87.81 87.09,94.16 87.09,100.41 97,110.32 99.92,110.32 109.35,119.75 109.35,130.04 113,133.68 113,173.9 119.77,180.67 125.7,180.67 127.98,182.96 144.88,182.96 146.78,184.86 146.78,190.33 155.29,198.83 158.69,198.83 160.72,200.87 175.1,200.87 177.13,198.83 181.3,198.83 181.68,199.22 183.36,199.22 183.43,199.14 v2(183.43,198.25)
  BOTTOM w0.097: v2(183.43,198.25) 183.99,198.25 184.2,198.04 184.2,197.49 ; 184.2,197.49 183.74,197.49 183.68,197.55 PU1306.6 ; 184.2,197.49 PR1315.1 ; R777.1 v2(43.28,51.9)
VCIN0_PT1: length 203.2
  TOP w0.203: v2(124.23,108.06) 124.23,108.21 124.68,108.66 140.94,108.66 147.92,115.65 147.92,124.79 155.29,132.16 155.29,133.23 R558.1
  IN05 w0.203: v2(45.56,52.02) 45.81,52.02 49.24,48.59 52.04,48.59 53.89,46.74 53.89,45.34 55.98,43.26 55.98,39.2 59.28,35.89 88.49,35.89 90.14,37.54 92.93,37.54 94.08,38.69 94.89,38.69 v2(95.47,38.1)
  IN08 w0.203: v2(95.47,38.1) 97.25,39.88 97.25,41.35 98.9,43.01 98.9,60.91 99.92,61.93 101.44,61.93 105.51,65.99 105.51,66.88 109.08,70.45 109.08,85.82 112.36,89.11 112.36,98.38 122.4,108.41 123.87,108.41 v2(124.23,108.06)
  BOTTOM w0.076: 38.58,52.66 38.04,52.66 37.78,52.91 U5.G12
  BOTTOM w0.097: 38.58,52.66 38.97,52.66 39.58,52.04 40.1,52.04 40.46,52.4 41.29,52.4 R557.2 41.68,53.09 42.01,53.42 44.79,53.42 45.56,52.65 v2(45.56,52.02)
VCOUT1_PROCHOT: length 12.5
  BOTTOM w0.089: 40.63,46.69 39.71,47.6 39.41,47.6 v1(39.26,47.76) 39.21,47.81 39.21,49.47 U5.B13
  BOTTOM w0.097: 40.63,46.69 41.09,46.23 42.21,46.23 42.51,45.93 42.51,44.53 42.61,44.43 U26.2 43.63,44.43 43.78,44.28 43.78,43.26 43.28,42.75 R555.1
VR_SVID_ALERT_1: length 3
  TOP w0.097: PU1101.4 122.59,192.8 122.02,193.37 120.82,193.37 PR1239.1
VR_SVID_CLK_1: length 3.1
  TOP w0.097: PR1238.2 120.95,193.12 121.89,193.12 122.61,192.4 PU1101.5
VR_SVID_DAT_1: length 3.2
  TOP w0.097: PU1101.3 122.57,193.2 122.14,193.63 121.63,193.63 120.75,194.52 PR1237.1
VRAM_VDDQ_ADJ: length 120.4
  TOP w0.097: v2(246.64,107.28) 246.32,107.6 R980.2 R981.2
  IN03 w0.091: v2(304.01,105.74) 304.01,106.38 300.58,109.81 288.39,109.81 286.86,108.28 281.78,108.28 275.56,102.06 275.56,92.03 276.96,90.63 279.11,90.63 v2(279.5,90.25)
  IN10 w0.091: v2(279.5,90.25) 278.73,90.25 275.08,86.59 275.08,84.76 273.58,83.26 266.03,83.26 265.53,82.76 251.68,82.76 251.05,83.39 243.55,83.39 242.16,84.79 242.16,97.87 245.17,100.88 245.17,103.93 246.35,105.11 246.35,106.99 v2(246.64,107.28)
  BOTTOM w0.097: v2(304.01,105.74) 304.06,105.79 PR414.1 304.51,105.34 304.51,104.09 304.13,103.71 PR3408.1
VRAM_VDDQ_ADJ_R: length 12.7
  TOP w0.097: R981.1 245.84,109.43 242.92,112.35 241.52,112.35 241.4,112.22 239.87,112.22 239.24,112.86 239.24,113.87 238.99,114.12 v3(238.99,115.57) 238.99,115.62 238.45,116.16 v1(237.97,116.16)
  BOTTOM w0.097: G2.BH4 v3(238.99,115.57)
VRAM_VREF_CTL: length 253.4
  IN10 w0.091: v2(302.23,124.16) 302.74,123.65 302.74,110.82 301.47,109.55 294.1,109.55 290.67,106.12 280.77,106.12 279.11,104.47 279.11,91.65 274.54,87.07 274.54,85.66 272.65,83.77 265.4,83.77 264.89,83.26 258.03,83.26 v2(257.52,83.77) 256.95,83.2 251.88,83.2 251.21,83.86 243.77,83.86 242.59,85.04 242.59,97.67 245.71,100.79 245.71,103.58 247.57,105.44 247.57,109.72 248.25,110.4 248.25,111.97 248,112.22 v2(247.62,112.22) ; v2(247.75,178.39) 248.25,177.88 249.78,177.88 250.92,179.02 253.08,179.02 253.21,179.15 259.18,179.15 259.86,179.84 264.33,179.84 265.4,178.77 269.84,178.77 270.25,179.18 273.81,179.18 275.25,180.62 280.94,180.62 282.67,178.9 284.25,178.9 284.45,178.69 284.45,176.61 284.96,176.1 v2(284.96,175.26)
  BOTTOM w0.097: v2(247.75,178.39) 247.49,178.39 247.16,178.06 R858.1 247.16,176.94 247.49,176.61 Q81.2 ; Q84.2 258.16,84.28 257.65,83.77 v2(257.52,83.77) ; v2(302.23,124.16) 302.48,124.41 Q83.2 304.51,124.41 305.53,125.43 305.53,156.54 300.96,161.12 285.85,161.12 283.81,163.15 283.81,173.69 283.56,173.94 282.92,173.94 282.8,174.07 Q82.2 282.8,174.67 283.38,175.26 v2(284.96,175.26)
  BOTTOM w0.1: G2.BD3 241.49,114.39 241.83,114.04 241.83,113.67 242.09,113.42 242.09,113.18 242.79,112.47 245.08,112.47 245.33,112.22 v2(247.62,112.22)
VRHOT_203: length 7.4
  TOP w0.097: PR1233.2 v1(118.71,186.64) 120.8,186.64 122.16,188 122.16,189.07 122.68,189.6 PU1101.12
VSBP_2: length 13.8
  TOP w0.381: v2(276.57,49.23) 275.94,49.86 PR230.1 ; v2(275.81,41.23) 274.92,42.12 v1(274.62,42.12) 274.15,42.12 273.81,41.78 PQ206.1
  IN03 w0.381: v2(275.81,41.23) 275.81,42.82 276.57,43.59 v2(276.57,49.23)
VSBP_2_PUMP: length 1.5
  TOP w0.381: PR3593.1 267.26,19.44 PQ207.1
VSBP_3: length 6
  TOP w0.356: PC230.1 275.35,52.09 275.59,51.84 PR230.2 ; PC230.1 PC204.2 272.59,52.09 PR234.2 PQ904.4 ; PC230.1 v1(274.8,53.14)
VSBP_3_PUMP: length 10
  TOP w0.381: PC3591.1 270,12.19 269.37,12.83 269.37,15.48 PQ905.4 269.18,17.53 PC3599.2 269.04,17.92 PR3598.2 PR3593.2
VSN_1PH: length 3.8
  TOP w0.203: PU1101.14 123.93,188.11 122.83,187.01 PR1177.2
  TOP w0.254: PR1177.2 PC1141.2
VSN_3PH_A: length 7.7
  TOP w0.203: PC1139.2 PR1166.2 119.11,197.44 119.27,197.6 120.21,197.6 v1(121.55,196.26) 122.57,195.23 123.8,195.23 123.93,195.09 PU1101.52
VSP_1PH: length 7
  TOP w0.203: PC1143.2 123.16,184.28 123.36,184.48 123.36,187.08 123.81,187.52 123.91,187.52 124.33,187.94 PU1101.15
  TOP w0.254: v1(123.67,183.34) PR1175.2 122.75,184.2 PC1143.2
VSP_3PH_A: length 10.4
  TOP w0.203: PU1101.51 124.33,195.38 124.06,195.66 122.75,195.66 120.32,198.1 v1(119.86,198.1) 117.52,198.1 PC1137.2 PR1121.2
WLAN_CK_REQ_N: length 6.9
  TOP w0.097: Q8.1 267.52,76.33 R457.2 266.54,75.26 v2(266.41,75.14)
  BOTTOM w0.097: v2(266.41,75.14) 266.54,75.26 266.54,75.9 267.75,77.11 JWLAN1.53
WLAN_RST_N: length 13
  TOP w0.097: R458.1 v2(259.18,64.85)
  BOTTOM w0.097: v2(259.18,64.85) 262.69,64.85 268,70.16 JWLAN1.52
WLAN_SUSCLK: length 13.9
  TOP w0.097: R456.1 v2(259.18,63.58)
  BOTTOM w0.097: JWLAN1.50 268.5,70.24 261.84,63.58 v2(259.18,63.58)
WLAN_WAKE_N: length 8.1
  TOP w0.097: v2(265.14,74.88) 265.14,75.26 265.65,75.77 R459.2
  BOTTOM w0.097: v2(265.14,74.88) 265.14,75.26 267.25,77.37 JWLAN1.55 267.25,80.32 v1(267.38,80.45)
XCLK_BIASREF: length 3.9
  BOTTOM w0.254: 248.56,71.61 248.09,71.14 U2.E1
  BOTTOM w0.508: 248.56,71.61 248.56,72.01 v1(249.65,73.1) 250.21,73.66 R189.1
XDP_BPM0_N: length 1.4
  TOP w0.097: v1(148.94,149.18) 149.23,149.47 v3(149.64,149.47)
  BOTTOM w0.097: v3(149.64,149.47) 149.97,149.8 U1.BR27
XDP_BPM1_N: length 2.8
  BOTTOM w0.097: TP62.1 147.42,149.3 148.05,149.94 149.24,149.94 U1.BT27
XDP_BPM2_N: length 1.5
  TOP w0.097: v2(152.29,152.59) 152.91,151.97 v1(153,151.97)
  BOTTOM w0.097: U1.BM31 151.92,152.96 v2(152.29,152.59)
XDP_BPM3_N: length 2.9
  BOTTOM w0.097: U1.BT30 149.07,152.48 147.29,152.48 146.91,152.1 TP3.1
XDP_HOOK3: length 3.2
  TOP w0.097: R593.1 212.26,52.73 212.06,52.53 212.06,51.13 212.19,51.01 TP60.1 R588.2
XDP_PRDY_N: length 373.2
  TOP w0.097: R201.2 252.57,52.99 253.7,52.99 254.1,52.59 v2(254.1,52.56) ; v3(150.29,149.47) 150.14,149.47 148.94,148.27 TP23.1
  IN03 w0.091: v2(156.94,38.81) 156.18,39.58 156.18,40.97 148.17,48.98 119.57,48.98 107.87,37.29 98.3,37.29 98.18,37.42 93.31,37.42 v2(92.42,36.53)
  IN05 w0.091: v2(109.32,112.86) 117.82,121.36 117.82,150.32 126.46,158.96 137.76,158.96 140.81,155.91 140.81,151.34 143.35,148.8 149.62,148.8 v3(150.29,149.47)
  IN08 w0.091: v2(109.32,112.86) 103.5,107.04 98.9,107.04 84.9,93.04 84.17,93.04 83.32,92.2 83.32,82.29 81.76,80.72 81.76,76.63 81.8,76.58 81.8,75.98 80.74,74.91 80.74,70.09 82.6,68.23 85.49,68.23 86.71,67.01 86.71,65.59 91.69,60.61 91.69,37.27 v2(92.42,36.53)
  IN10 w0.091: v2(156.94,38.81) 157.58,39.45 157.58,40.05 158.12,40.59 158.46,40.59 159.8,39.26 185.45,39.26 186.66,40.47 204.82,40.47 207.74,43.39 211.42,43.39 214.84,39.97 248.37,39.97 252.57,44.17 252.57,46.33 252.95,46.71 252.95,47.73 253.59,48.36 253.59,52.02 254.1,52.53 v2(254.1,52.56)
  BOTTOM w0.097: v3(150.29,149.47) 150.62,149.8 U1.BP27
XDP_PREQ_N: length 412.6
  TOP w0.097: R200.2 v2(252.83,52.53)
  IN03 w0.091: v2(146.65,156.54) 147.16,156.54 150.71,153 152.41,153 152.7,152.71 152.7,152.24 v3(152.33,151.87)
  IN05 w0.091: v2(114.9,128.86) 114.27,129.49 114.27,163.02 118.84,167.59 135.6,167.59 v2(146.65,156.54) ; v2(252.83,52.53) 252.42,52.12 252.42,47.93 250.54,46.05 250.54,44.02 248.68,42.16 236.33,42.16 234.04,44.45 229.72,44.45 229.17,45 225.53,45 224.8,45.72 215.62,45.72 214.61,46.73 212.96,46.73 212.66,47.03 202.45,47.03 201.42,48.06 192.41,48.06 189.47,45.12 153.85,45.12 153.24,44.51 121.48,44.51 119.9,42.94 119.9,31.36 118.96,30.43 114,30.43 110.82,27.25 95.85,27.25 94.55,25.95 84.54,25.95 v2(83.7,26.8)
  IN08 w0.091: v2(83.7,26.8) 82.01,28.48 82.01,33.99 79.22,36.78 79.22,42.37 77.31,44.28 77.31,50.24 77.71,50.64 77.71,59.53 78.45,60.28 78.45,65.2 78.12,65.53 77.58,65.53 75.79,67.32 75.79,75.9 76.17,76.28 76.17,78.33 76.93,79.09 76.93,81.8 77.4,82.27 77.4,89.4 76.26,90.54 76.26,91.05 76.64,91.43 76.64,93.01 77.39,93.76 79.03,93.76 79.71,94.44 79.71,98.88 81.25,100.41 86.96,100.41 97.21,110.66 101.17,110.66 102.62,112.11 102.62,114.29 108.97,120.64 108.97,125.72 112.11,128.86 v2(114.9,128.86)
  BOTTOM w0.097: U1.BL30 v3(152.33,151.87) ; R25.1 146.27,156.16 v2(146.65,156.54) 146.27,156.92 TP21.1
XDP_PRS: length 2.5
  TOP w0.097: R594.1 v2(232.76,45.8)
  BOTTOM w0.097: R336.1 v1(233.01,45.04) 233.01,45.55 v2(232.76,45.8)
XDP_TCK: length 305.3
  TOP w0.097: v2(254.1,54.18) 254.1,55.2 253.46,55.83 252.06,55.83 v1(251.68,56.21) 250.67,56.21 249.78,57.1 R220.2 ; v2(150.29,150.26) 150.51,150.48 R27.1
  IN03 w0.091: v2(208.63,161.5) 207.69,162.44 207.69,175.38 207.22,175.85 201.77,175.85 201.39,175.47 201.39,167.21 200.63,166.45 185.64,166.45 182.59,163.4 182.59,160.1 181.83,159.34 168.24,159.34 166.08,161.5 147.42,161.5 145,159.08 145,154 146.53,152.48 148.43,152.48 150.29,150.62 v2(150.29,150.26)
  IN08 w0.091: v2(254.1,54.18) 255.49,52.78 257.02,52.78 258.16,53.93 258.16,58.88 257.91,59.13 256.76,59.13 256.13,59.77 256.13,61.29 258.03,63.2 258.03,69.17 257.83,69.37 256.94,69.37 256.64,69.68 256.64,70.06 256.13,70.56 254.1,70.56 252.44,68.91 252.44,67.39 251.81,66.75 249.02,66.75 247.11,64.84 241.17,64.84 240.76,65.25 234.05,65.25 233.64,64.84 228.32,64.84 228.06,65.1 226.66,65.1 225.01,66.75 223.11,66.75 220.19,69.68 220.19,73.74 218.41,75.52 207.61,75.52 206.44,76.7 206.44,93.02 208.88,95.47 208.88,99.52 209.74,100.37 209.74,102.98 213.13,106.38 215.16,106.38 215.87,107.09 215.87,111.71 214.98,112.6 214.34,112.6 210.16,116.78 204.83,116.78 204.33,117.28 204.33,126.21 205.2,127.08 205.2,144.22 210.15,149.18 210.15,160.48 209.14,161.5 v2(208.63,161.5)
  BOTTOM w0.097: TP48.1 146.27,148.67 147.8,150.19 149.51,150.19 U1.BR28 150.29,150.33 v2(150.29,150.26)
XDP_TDI: length 379.8
  TOP w0.097: R306.2 v1(253.08,54.31) 253.08,54.05 TP51.1 253.71,53.42 v2(254.1,53.42)
  IN03 w0.091: v2(90.37,36.51) 91.77,36.51 92.93,37.67 98.39,37.67 98.52,37.54 107.82,37.54 119.48,49.2 148.26,49.2 156.4,41.06 156.4,40.63 v2(156.94,40.08)
  IN05 w0.091: v2(106.78,113.74) 106.78,114.25 116.55,124.03 116.55,151.59 130.02,165.05 133.7,165.05 142.46,156.29 142.46,152.86 143.22,152.1 147.92,152.1 148.84,153.01 151.2,153.01 v2(151.59,153.41)
  IN08 w0.091: v2(90.37,36.51) 90.58,36.72 90.58,59.96 85.44,65.1 85.44,66.37 84.68,67.14 82.01,67.14 79.48,69.67 79.48,78.19 80.41,79.12 80.41,87.88 81.76,89.24 81.76,94.01 82.06,94.31 84.42,94.31 98.26,108.15 102.57,108.15 106.14,111.71 106.14,113.11 v2(106.78,113.74)
  IN10 w0.091: v2(156.94,40.08) 157.79,40.94 158.94,40.94 160.39,39.48 185.19,39.48 186.43,40.72 204.71,40.72 207.64,43.64 211.53,43.64 214.98,40.19 248.23,40.19 252.32,44.28 252.32,46.43 252.7,46.82 252.7,47.83 253.33,48.47 253.33,52.66 v2(254.1,53.42)
  BOTTOM w0.097: v2(151.59,153.41) 152.56,153.41 U1.BL32
XDP_TDO: length 388
  TOP w0.097: R507.2 v2(252.83,55.2)
  IN05 w0.091: v2(252.83,55.2) 251.96,54.33 251.96,48.11 251.43,47.58 251.05,47.58 248.89,45.42 248.89,44.02 247.62,42.75 236.57,42.75 234.28,45.04 229.97,45.04 229.58,45.42 229.58,45.93 229.1,46.41 224.21,46.41 224.06,46.56 223.87,46.56 223.11,47.32 218.03,47.32 217.01,46.31 215.87,46.31 214.85,47.32 213.2,47.32 212.9,47.63 202.68,47.63 201.52,48.79 192.19,48.79 189.11,45.71 153.51,45.71 152.91,45.1 121.23,45.1 119.31,43.18 119.31,31.61 118.72,31.02 113.75,31.02 110.57,27.84 95.42,27.84 94.5,26.92 93.49,26.92 v2(93.06,26.5) ; v2(108.05,114.25) 117.06,123.27 117.06,150.7 130.91,164.54 133.32,164.54 141.7,156.16 141.7,151.97 143.1,150.57 v2(146.65,150.57)
  IN08 w0.091: v2(93.06,26.5) 92.94,26.5 91.07,28.37 91.07,60.34 85.95,65.46 85.95,66.63 84.93,67.64 82.26,67.64 79.98,69.93 79.98,78.07 80.95,79.05 80.95,81.19 82.56,82.8 82.56,93.6 82.77,93.81 84.8,93.81 98.64,107.64 102.96,107.64 107.41,112.09 107.41,113.11 108.05,113.74 v2(108.05,114.25)
  BOTTOM w0.097: R24.1 146.53,149.69 146.65,149.81 TP49.1 v2(146.65,150.57) 146.81,150.42 149.08,150.42 U1.BT28
XDP_TMS: length 389.1
  IN05 w0.091: v2(94.33,26.5) 94.58,26.5 95.64,27.55 110.7,27.55 113.87,30.72 118.84,30.72 119.6,31.48 119.6,43.06 121.35,44.81 153.03,44.81 153.63,45.41 189.32,45.41 192.34,48.44 201.46,48.44 202.57,47.32 212.78,47.32 213.08,47.03 214.73,47.03 215.75,46.01 217.13,46.01 218.15,47.03 221.88,47.03 222.85,46.05 224.89,46.05 225.65,45.29 229.29,45.29 229.84,44.74 234.16,44.74 236.45,42.46 248.47,42.46 250.16,44.15 250.16,46.09 250.25,46.18 250.3,46.18 252.19,48.07 252.19,52.78 v2(252.83,53.42) ; v2(108.05,112.86) 117.44,122.25 117.44,150.57 131.03,164.16 133.19,164.16 141.32,156.04 141.32,151.59 142.72,150.19 144.73,150.19 145.37,149.56 147.54,149.56 147.86,149.88 150.56,149.88 v2(150.94,150.26)
  IN08 w0.091: v2(94.33,26.5) 94.33,26.88 91.36,29.84 91.36,60.5 86.33,65.54 86.33,66.88 85.27,67.94 82.48,67.94 80.36,70.06 80.36,75.14 80.91,75.69 80.91,78.36 81.38,78.82 81.38,81.11 83.03,82.76 83.03,92.41 84.04,93.42 84.86,93.42 98.77,107.33 103.16,107.33 108.05,112.22 v2(108.05,112.86)
  BOTTOM w0.076: U1.BP28 150.62,150.58 v2(150.94,150.26)
  BOTTOM w0.097: U1.BP28 150.32,150.96 148.69,150.96 148.56,151.08 TP52.1 ; R216.2 252.83,53.22 v2(252.83,53.42)
XDP_TRST_N: length 390
  TOP w0.097: v3(150.3,152.62) 150.3,153.03 150.08,153.24 TP50.1 R29.1
  IN05 w0.091: v2(95.85,26.11) 96.55,26.82 111.03,26.82 114.21,29.99 119.25,29.99 120.12,30.86 120.12,42.85 121.57,44.3 153.97,44.3 154.21,44.53 189.6,44.53 192.47,47.39 201.47,47.39 202.05,46.81 212.57,46.81 212.98,46.4 214.63,46.4 215.53,45.5 224.71,45.5 225.43,44.78 229.08,44.78 229.63,44.23 233.95,44.23 236.23,41.94 248.97,41.94 250.92,43.89 250.92,46.13 252.64,47.84 252.64,49.29 v2(254.1,50.75) ; v3(150.3,152.62) 148.95,152.62 147.8,151.46 145.38,151.46 144.75,150.83 143.48,150.83 142.08,152.23 142.08,156.29 133.57,164.8 130.52,164.8 116.81,151.08 116.81,123.78 107.28,114.25 107.28,113.36 v2(106.78,112.86)
  IN08 w0.091: v2(95.85,26.11) 95.35,25.61 93.09,25.61 90.8,27.89 90.8,60.13 85.69,65.23 85.69,66.5 84.8,67.39 82.14,67.39 79.7,69.83 79.7,78.1 80.74,79.14 80.74,87.83 82.14,89.23 82.14,93.81 82.39,94.06 84.68,94.06 98.51,107.89 102.83,107.89 106.78,111.84 v2(106.78,112.86)
  BOTTOM w0.097: v3(150.3,152.62) 150.62,152.3 U1.BP30 ; R202.2 252.19,50.75 252.7,50.24 253.59,50.24 v2(254.1,50.75)
XTAL_IN: length 19.4
  BOTTOM w0.097: Y6.1 219.03,113.99 219.96,114.92 221.32,114.92 221.74,114.51 222.42,114.51 C1399.1 222.78,114.51 223.43,114.51 v1(223.62,114.33) 223.8,114.51 224.69,114.51 225.34,115.16 234.3,115.16 235.43,116.28 236.2,116.28 G2.BL6
XTAL_LAN_IN: length 4.3
  TOP w0.097: U6.8 45.96,67.04 R281.2 45.87,68.13 C276.1 45.89,69.45 Y4.1
XTAL_LAN_OUT: length 6
  TOP w0.097: U6.7 46.36,66.94 46.56,67.14 R281.1 46.78,67.52 46.73,67.57 C277.1 46.73,68.18 47.42,68.86 47.42,69.98 47.08,70.32 Y4.3
XTAL_OUT: length 19.1
  BOTTOM w0.097: Y6.3 219.9,116.11 219.81,116.02 219.81,115.29 219.91,115.19 221.43,115.19 221.84,114.79 222.19,114.79 C1400.1 223.01,114.79 224.4,114.79 v1(224.89,115.27) 225.05,115.43 234.19,115.43 235.43,116.67 G2.BM6
N34955: length 2.9
  BOTTOM w0.097: R264.1 27.2,53.8 26.69,53.8 C247.1 25.93,54.56 v1(25.34,54.56)
N151202: length 1.8
  TOP w0.254: v1(121.33,201.07) PR1243.1 PC1158.1
N151523: length 0.9
  BOTTOM w0.254: PR1162.2 121.3,197.82 PC1133.1
N153421: length 3.6
  TOP w0.203: v1(116,195.61) PR1165.2 116.02,196.5 PC1137.1 116.86,196.52 PC1139.1 PR1166.1
N162072: length 42.7
  IN05 w0.127: v2(149.57,178.77) 149.51,178.71 148.85,178.71 148.54,179.02 139.8,179.02 130.52,188.29 130.52,193.88 130.91,194.26 130.91,195.41 130.52,195.79 128.11,195.79 124.43,199.47 123.21,199.47 v2(122.96,199.72)
  BOTTOM w0.254: v2(149.57,178.77) 149.73,178.77 PH1103.2 ; PR1146.1 PR1148.2 123.29,200.05 v2(122.96,199.72)
N168892: length 3
  TOP w0.203: PU1101.27 129.62,189.2 v1(130.74,188.08) 131.29,187.53 PR1190.1
N169056: length 5.8
  TOP w0.203: PU1101.13 122.79,189.2 122.52,188.93 122.52,187.79
  TOP w0.381: 122.52,187.79 122.52,187.3 v1(122.21,186.99) 121.99,186.77 121.51,186.77 120.64,185.91 PC1153.2 120.62,185.04 PR1197.2
N170540: length 0.9
  TOP w0.254: PC1151.1 PR1195.1
N170610: length 0.9
  BOTTOM w0.254: PC1150.1 123.69,186.06 PR1194.2
N171722: length 105.9
  TOP w0.254: PR1198.1 126.69,185.14 PR1199.2 125.83,183.57 v2(125.85,183.54)
  IN03 w0.203: v2(209.29,177.63) 209.04,177.88 208.63,177.88 207.11,176.36 201.64,176.36 201.01,175.72 201.01,167.77 200.2,166.96 186.53,166.96 185.87,167.61 172.71,167.61 170.55,165.46 150.82,165.46 147.9,168.38 147.9,170.67 147.67,170.89 142.46,170.89 131.03,182.32 127.35,182.32 126.13,183.54 v2(125.85,183.54)
  BOTTOM w0.254: v2(209.29,177.63) 209.21,177.55 PH1106.2
N172077: length 6
  TOP w0.203: v1(128.8,183.32) PR1176.1 128.26,184.76 128.26,185.86 128.04,186.08 PC1142.2 127.48,186.34 127.48,187.23 127.13,187.57 PU1101.22
N187198: length 2.7
  TOP w0.203: PU1101.8 121.62,191.2 121.51,191.09
  TOP w0.381: PR1188.2 121.33,190.91 121.51,191.09
N187431: length 32.8
  IN03 w0.203: v2(148.18,178.01) 146.02,178.01 135.99,188.04 131.29,188.04 130.45,188.88 130.45,191.01 131.44,192 v2(131.44,192.97)
  BOTTOM w0.254: PH1105.1 149.14,175.52 148.18,176.48 v2(148.18,178.01) ; v2(131.44,192.97) 131.36,193.04 PR1180.1 130.07,193.04 129.89,192.87 PR1179.2
N188686: length 98.6
  IN05 w0.254: v2(118.76,187.38) 119.22,186.92 122.04,186.92 123.26,185.7 127.78,185.7 137,176.48 151.99,176.48 153.13,177.63 166.34,177.63 167.23,176.74 207.61,176.74 207.74,176.86 v2(209.29,176.86)
  BOTTOM w0.254: PR1182.1 PR1181.2 118.79,187.4 v2(118.76,187.38) ; v2(209.29,176.86) 208.99,176.56 PH1107.1
N16691093: length 25.7
  BOTTOM w0.076: U2005.AB7 55.72,88.59 56.22,88.59 56.32,88.49 56.33,88.49
  BOTTOM w0.097: 56.33,88.49 60.37,88.49 60.63,88.23 61.03,87.83 62.34,87.83 v2(63.64,86.53) 65.25,84.92 65.25,82.78 67.02,81.01 67.02,77.55 66.68,77.22 66.68,74.77 67.06,74.39 68.84,74.39 68.97,74.26 69.66,74.26 C2043.1
N16691099: length 25.7
  BOTTOM w0.076: U2005.AC7 55.84,88.36 55.77,88.28 55.77,88.19 55.84,88.13 56.11,88.13 56.21,88.22 56.54,88.22
  BOTTOM w0.097: C2044.1 69.61,73.98 68.86,73.98 68.72,74.12 66.94,74.12 66.41,74.65 66.41,77.33 66.74,77.66 66.74,80.9 64.97,82.67 64.97,84.81 62.22,87.56 60.91,87.56 v2(60.58,87.89) 60.25,88.22 56.54,88.22
N16691181: length 24.9
  BOTTOM w0.076: 56.18,87.62 56.13,87.67 55.72,87.67 U2005.AB9
  BOTTOM w0.097: C2045.1 69.68,72.75 68.99,72.75 68.56,73.18 66.97,73.18 65.76,74.39 65.76,81.03 64.36,82.43 64.36,83.19 v2(61.95,85.59) 59.94,87.6 56.2,87.6 56.18,87.62
N16691187: length 24.9
  BOTTOM w0.076: 56.22,87.28 56.15,87.21 55.86,87.21 55.79,87.27 55.79,87.38 55.86,87.44 U2005.AC9
  BOTTOM w0.097: 56.22,87.28 56.27,87.33 59.83,87.33 60.13,87.03 64.08,83.07 64.08,82.31 v2(64.59,81.81) 65.48,80.91 65.48,74.28 66.85,72.91 68.45,72.91 68.88,72.47 69.6,72.47 C2047.1
N16691295: length 25.1
  BOTTOM w0.076: U2005.AB11 55.72,86.75 56.13,86.75 56.18,86.7
  BOTTOM w0.097: C2049.1 69.64,71.18 69.1,71.18 68,72.28 66.59,72.28 64.87,74 v2(64.87,77.31) 64.87,80.62 63.47,82.02 63.47,82.56 59.34,86.68 56.2,86.68 56.18,86.7
N16691301: length 25.1
  BOTTOM w0.076: 56.12,86.29 55.83,86.29 55.75,86.37 55.75,86.47 55.8,86.52 U2005.AC11
  BOTTOM w0.097: 56.12,86.29 56.24,86.41 59.23,86.41 63.19,82.44 63.19,81.91 64.59,80.51 64.59,73.89 v2(65.53,72.95) 66.48,72.01 67.89,72.01 68.98,70.91 69.64,70.91 C2050.1
N16691335: length 25.2
  BOTTOM w0.076: 56.18,85.78 56.13,85.83 55.72,85.83 U2005.AB13
  BOTTOM w0.097: C2051.1 69.64,69.71 69.14,69.71 67.53,71.32 66.23,71.32 63.97,73.58 63.97,80.19 62.45,81.71 62.45,82.12 61.45,83.13 v2(61.23,83.34) 61.23,83.35 58.82,85.76 56.2,85.76 56.18,85.78
N16691365: length 25.3
  BOTTOM w0.076: 56.12,85.37 55.83,85.37 55.75,85.45 55.75,85.55 55.8,85.6 U2005.AC13
  BOTTOM w0.097: 56.12,85.37 56.24,85.49 58.7,85.49 59.15,85.04 61.04,83.15 61.25,82.93 62.18,82.01 62.18,81.6 63.7,80.08 63.7,73.46 66.12,71.05 67.42,71.05 v2(67.67,70.79) 69.03,69.44 69.64,69.44 C2052.1
N16691909: length 9
  BOTTOM w0.076: U2005.Y23 54.58,81.16 54.51,81.23 54.41,81.23 54.34,81.16 54.34,80.83 54.5,80.67 54.5,80.53 55,80.04 55.6,80.04 55.65,79.99 55.67,79.99
  BOTTOM w0.104: 55.67,79.99 57.09,79.99 v2(57.5,79.58) 58.77,78.31 58.77,75.86 58.67,75.76 C2027.1
N16691941: length 4.9
  BOTTOM w0.076: 54.29,79.01 54.28,79.01 54.23,79.06 53.73,79.06 52.66,80.13 52.66,80.67 52.5,80.83 52.5,81.16 52.57,81.23 52.67,81.23 52.74,81.16 U2005.T23
  BOTTOM w0.104: C2031.1 54.85,78.54 54.85,78.68 54.52,79.01 54.29,79.01
N16691945: length 4.9
  BOTTOM w0.076: 54.29,79.27 54.28,79.27 54.22,79.21 53.8,79.21 52.81,80.2 52.81,80.67 52.96,80.82 52.96,81.23 U2005.T22
  BOTTOM w0.104: 54.29,79.27 54.62,79.27 55.1,78.79 55.1,78.33 C2033.1
N16691949: length 9.1
  BOTTOM w0.076: 55.67,80.24 55.65,80.24 55.6,80.19 55.06,80.19 54.65,80.6 54.65,80.67 54.8,80.82 54.8,81.23 U2005.Y22
  BOTTOM w0.104: C2029.1 59.03,75.93 59.03,78.42 v2(58.77,78.67) 57.2,80.24 55.67,80.24
N16693389: length 6.1
  BOTTOM w0.076: 56.23,79.05 56.22,79.05 56.21,79.06 56.21,79.09 56.15,79.15 56.13,79.15 55.9,79.38 55.09,79.38 54.83,79.63 54.34,79.63 53.58,80.39 53.58,80.67 53.42,80.83 53.42,81.16 53.49,81.23 53.59,81.23 53.66,81.16 U2005.V23
  BOTTOM w0.104: 56.23,79.05 56.65,79.05 57.17,78.53 57.17,78.46 C2028.2
N16693435: length 6.1
  BOTTOM w0.076: 56.23,79.3 56.19,79.3 55.96,79.53 55.15,79.53 54.9,79.78 54.4,79.78 53.73,80.45 53.73,80.67 53.88,80.82 53.88,81.23 U2005.V22
  BOTTOM w0.104: 56.23,79.3 56.76,79.3 57.43,78.63 57.43,78.37 C2030.2
N16693587: length 9.4
  BOTTOM w0.076: U2005.P23 51.82,81.16 51.75,81.23 51.65,81.23 51.58,81.16 51.58,80.83 51.74,80.67 51.74,80.41 51.69,80.36 51.69,80.34
  BOTTOM w0.104: C2032.2 55.72,74.16 55.82,74.26 55.82,74.65 v2(54.33,76.15) 54.02,76.46 53.76,76.46 53.11,77.12 53.11,78.38 51.69,79.8 51.69,80.34
N16693593: length 9.5
  BOTTOM w0.076: 51.95,80.34 51.95,80.36 51.89,80.41 51.89,80.67 52.04,80.82 52.04,81.23 U2005.P22
  BOTTOM w0.104: 51.95,80.34 51.95,79.9 53.36,78.49 53.36,77.22 53.87,76.72 54.12,76.72 v2(55.45,75.39) 56.08,74.76 56.08,74.44 C2034.2
N16693655: length 10.2
  BOTTOM w0.076: U2005.K23 49.98,81.16 49.91,81.23 49.81,81.23 49.74,81.16 49.74,80.83 49.9,80.67 49.9,80.41 49.85,80.36 49.85,80.34
  BOTTOM w0.104: 49.85,80.34 49.85,78.98 50.9,77.93 v2(50.9,77.04) 50.9,74.99 49.9,74 49.08,74 48.95,74.12 48.95,74.38 48.86,74.46 48.74,74.46 48.65,74.38 C2036.2
N16693677: length 10.2
  BOTTOM w0.076: 50.11,80.34 50.11,80.36 50.05,80.41 50.05,80.67 50.2,80.82 50.2,81.23 U2005.K22
  BOTTOM w0.104: C2038.2 v2(49.63,73.74) 50.01,73.74 51.15,74.89 51.15,78.04 50.11,79.08 50.11,80.34
N16693763: length 3.6
  BOTTOM w0.076: U2005.F23 48.14,81.16 48.07,81.23 47.97,81.23 47.9,81.16 47.9,80.83 48.06,80.67 48.06,80.41 48.01,80.36 48.01,80.34
  BOTTOM w0.104: C2040.2 47.59,78.48 47.59,79.2 48.01,79.62 48.01,80.34
N16693769: length 3.6
  BOTTOM w0.076: U2005.F22 48.36,81.23 48.36,80.82 48.21,80.67 48.21,80.41 48.27,80.36 48.27,80.34
  BOTTOM w0.104: C2042.2 47.85,78.6 47.85,79.09 48.27,79.51 48.27,80.34
N16693791: length 5.9
  BOTTOM w0.076: 50.77,80.34 50.77,80.36 50.82,80.41 50.82,80.67 50.66,80.83 50.66,81.16 50.73,81.23 50.83,81.23 50.9,81.16 U2005.M23
  BOTTOM w0.104: 50.77,80.34 50.77,79.85 52.3,78.33 52.3,76.59 52.3,76.58 C2035.1
N16693827: length 4.6
  BOTTOM w0.076: 48.93,80.34 48.93,80.36 48.98,80.41 48.98,80.67 48.82,80.83 48.82,81.16 48.89,81.23 48.99,81.23 49.06,81.16 U2005.H23
  BOTTOM w0.104: 48.93,80.34 48.93,78.75 49.5,78.18 49.5,77.46 C2039.1
N16693831: length 4.6
  BOTTOM w0.076: 49.19,80.34 49.19,80.36 49.13,80.41 49.13,80.67 49.28,80.82 49.28,81.23 U2005.H22
  BOTTOM w0.104: 49.19,80.34 49.19,78.86 49.76,78.29 49.76,77.64 C2041.1
N16693835: length 5.9
  BOTTOM w0.076: U2005.M22 51.12,81.23 51.12,80.82 50.97,80.67 50.97,80.41 51.03,80.36 51.03,80.34
  BOTTOM w0.104: C2037.1 52.55,76.69 v2(52.55,77.55) 52.55,78.43 51.03,79.96 51.03,80.34
N16694173: length 28.2
  BOTTOM w0.076: 56.18,84.86 56.13,84.91 55.72,84.91 U2005.AB15
  BOTTOM w0.097: 56.18,84.86 56.2,84.84 57.85,84.84 63.08,79.61 63.08,77.68 63.08,77.68 63.08,76.73 63.08,76.73 63.08,76.72 63.08,76.18 v2(63.08,71.66) 63.08,71.27 59.56,67.75 59.56,64.65 59.22,64.31 59.22,63.56 59.36,63.43 59.67,63.43 C2056.1
N16694179: length 28.3
  BOTTOM w0.076: U2005.AC15 55.8,84.68 55.75,84.63 55.75,84.53 55.83,84.45 56.12,84.45
  BOTTOM w0.097: 56.12,84.45 56.24,84.57 57.73,84.57 62.8,79.5 62.8,76.81 62.8,76.43 v2(62.8,73.69) 62.8,71.39 59.28,67.87 59.28,64.76 58.95,64.42 58.95,63.45 59.24,63.15 59.69,63.15 C2057.1
N16694217: length 28.9
  BOTTOM w0.076: U2005.AB17 55.72,83.99 56.13,83.99 56.18,83.94
  BOTTOM w0.097: C2058.1 59.66,62.17 58.9,62.17 57.99,63.08 57.99,64.38 58.26,64.65 v2(58.26,67.37) 58.26,67.76 62.19,71.69 62.19,77.25 62.19,77.79 62.2,77.8 62.19,77.8 62.19,78.75 62.19,79.21 57.48,83.92 56.2,83.92 56.18,83.94
N16694223: length 28.9
  BOTTOM w0.076: U2005.AC17 55.8,83.76 55.75,83.71 55.75,83.61 55.83,83.53 56.12,83.53
  BOTTOM w0.097: C2059.1 59.7,61.9 58.78,61.9 57.71,62.97 57.71,64.5 57.98,64.76 v2(57.98,65.15) 57.98,67.87 61.92,71.8 61.92,77.36 61.92,77.5 61.92,77.88 61.92,79.1 57.36,83.65 56.24,83.65 56.12,83.53
N16694285: length 29.1
  BOTTOM w0.076: 56.18,83.02 56.13,83.07 55.72,83.07 U2005.AB19
  BOTTOM w0.097: C2060.1 59.68,61 58.64,61 57.06,62.58 v2(57.06,62.96) 57.06,67.85 61.29,72.08 61.29,75.31 61.29,75.31 61.29,75.85 61.29,75.86 61.29,75.86 61.29,75.94 61.29,76.81 61.29,78.85 57.14,83 56.2,83 56.18,83.02
N16694291: length 29.2
  BOTTOM w0.076: U2005.AC19 55.8,82.84 55.75,82.79 55.75,82.69 55.83,82.61 56.12,82.61
  BOTTOM w0.097: C2061.1 59.68,60.72 v2(58.78,60.72) 58.52,60.72 56.79,62.46 56.79,67.96 61.01,72.19 61.01,75.42 61.01,75.42 61.01,75.47 61.01,75.47 61.01,75.56 61.01,75.56 61.01,75.94 61.02,76.81 61.02,78.74 57.02,82.73 56.24,82.73 56.12,82.61
N16694353: length 32
  BOTTOM w0.076: U2005.AB21 55.72,82.15 56.13,82.15 56.18,82.1
  BOTTOM w0.097: C2062.1 59.67,59.69 55.71,59.69 54.79,60.6 v2(54.79,61.26) 54.79,61.91 55.86,62.97 55.86,68.2 60.22,72.56 60.22,75.41 60.22,75.41 60.22,75.96 60.22,75.96 60.22,75.96 60.22,78.63 56.76,82.08 56.2,82.08 56.18,82.1
N16694359: length 32
  BOTTOM w0.076: 56.12,81.69 55.83,81.69 55.75,81.77 55.75,81.87 55.8,81.92 U2005.AC21
  BOTTOM w0.097: 56.12,81.69 56.24,81.81 56.65,81.81 59.94,78.51 59.94,75.66 59.94,75.66 59.94,72.68 55.58,68.32 55.58,63.09 54.52,62.02 54.52,60.49 55.59,59.42 v2(57.63,59.42) 59.67,59.42 C2063.1
N16694397: length 6.5
  TOP w0.097: C2133.2 59.5,86.06 59.6,85.96 59.6,85.73 59.5,85.63 58.7,85.63 58.27,86.06 57.4,86.06 57.01,86.44 54.91,86.44 54.85,86.38 v1(54.47,86.38)
  BOTTOM w0.102: U2005.Y12 v1(54.47,86.38)
N16694403: length 6.6
  TOP w0.097: C2134.2 59.14,85.36 58.58,85.36 58.16,85.78 v2(57.95,85.78) 57.28,85.78 56.9,86.17 55.02,86.17 54.86,86.01 54.25,86.01 53.87,86.38 v1(53.82,86.38)
  BOTTOM w0.102: U2005.W12 v1(53.82,86.38)
N16694687: length 43.2
  IN03 w0.114: v2(30.25,67.76) 29.97,68.04 29.97,68.28 30.1,68.41 31.19,68.41 31.45,68.14 31.45,66.64 32.12,65.98 40.72,65.98 42.64,67.9 43.26,67.9 43.78,68.42 43.78,69.93 45.56,71.71 45.56,74.5 47.09,76.03 48.48,76.03 53.61,81.16 55.39,81.16 55.85,81.61 55.85,83.42 55.44,83.82 54.61,83.82 54.28,84.16 54.28,84.24 v1(54.47,84.43)
  BOTTOM w0.104: v2(30.25,67.76) 29.97,68.04 29.97,68.67 C2070.1
  BOTTOM w0.114: U2005.Y15 54.8,84.76 v1(54.47,84.43)
N16694693: length 43.2
  IN03 w0.114: v2(29.43,67.76) 29.71,68.04 29.71,68.39 29.99,68.67 31.3,68.67 31.72,68.25 31.72,66.75 32.23,66.25 40.61,66.25 42.53,68.16 43.15,68.16 43.52,68.53 43.52,70.04 45.3,71.82 45.3,74.61 46.98,76.29 48.37,76.29 53.5,81.42 55.28,81.42 55.58,81.72 55.58,83.31 55.33,83.56 54.5,83.56 54.01,84.04 54.01,84.24 v1(53.82,84.43)
  BOTTOM w0.104: C2071.1 29.71,68.67 29.71,68.04 v2(29.43,67.76)
  BOTTOM w0.114: v1(53.82,84.43) 54.15,84.76 U2005.W15
N16695077: length 2.4
  BOTTOM w0.076: 45.34,83.57 45.36,83.57 45.36,83.58 45.45,83.58 arc(45.48,83.57) 45.5,83.57 45.63,83.53 arc(45.65,83.53) 45.66,83.53 45.91,83.53 arc(46.05,83.56) 46.18,83.64 U2005.B17
  BOTTOM w0.097: 45.34,83.57 44.43,83.57 arc(44.37,83.57) 44.31,83.58 44.29,83.58 arc(44.16,83.54) C2067.1
N16695083: length 2.4
  BOTTOM w0.076: U2005.A17 45.95,83.76 arc(46.03,83.79) 46.06,83.87 46.06,83.87 arc(46.03,83.96) 45.94,83.99 45.72,83.99 arc(45.7,83.99) 45.68,83.98 45.43,83.88
  BOTTOM w0.097: C2066.1 arc(44.25,83.88) 44.43,83.84 45.24,83.84 arc(45.34,83.85) 45.43,83.88
N16695201: length 2.5
  BOTTOM w0.076: U2005.B19 46.18,82.95 arc(46.05,83.04) 45.91,83.07 45.73,83.07 arc(45.7,83.06) 45.67,83.04 45.66,83.03 arc(45.63,83.01) 45.58,83 45.5,83 45.5,83
  BOTTOM w0.097: C2069.1 arc(44.16,82.66) 44.3,82.6 44.46,82.6 arc(44.58,82.63) 44.69,82.7 44.83,82.85 arc(45.01,82.96) 45.21,83 45.46,83 arc(45.48,83) 45.5,83
N16695207: length 2.5
  BOTTOM w0.076: U2005.A19 45.96,82.84 arc(46.08,82.72) 45.96,82.61 45.75,82.61 arc(45.68,82.62) 45.61,82.67
  BOTTOM w0.097: 45.61,82.67 arc(45.54,82.71) 45.46,82.73 45.21,82.73 arc(45.11,82.71) 45.03,82.65 44.88,82.51 arc(44.78,82.43) 44.67,82.37 arc(44.57,82.34) 44.46,82.33 44.3,82.33 arc(44.19,82.31) C2068.1
N16731494: length 4.9
  BOTTOM w0.076: 29.84,73.82 31.18,73.82 U2007.L4
  BOTTOM w0.089: 29.84,73.82 v1(29.04,73.02) 28.37,72.34 R2087.2
N16731524: length 5.8
  BOTTOM w0.076: U2007.K4 31.49,73.62 30.18,73.62
  BOTTOM w0.089: R2088.2 27.12,71.61 v1(27.91,71.61) 28.16,71.61 30.18,73.62
N16732102: length 5.5
  TOP w0.089: R2077.2 R2078.2 32.89,78.06 v1(34.13,78.06) 34.13,77.72 33.93,77.52 v1(33.93,76.38)
  BOTTOM w0.089: U2007.F10 33.75,76.56 v1(33.93,76.38)
N16819243: length 2.7
  TOP w0.104: R278.2 51.52,60.6 51.13,60.6 50.36,61.36 50.19,61.36 50.12,61.29 U6.32
N16819245: length 2.7
  TOP w0.104: R279.2 51.52,60.85 51.24,60.85 50.47,61.62 50.19,61.62 50.12,61.69 U6.33
N16821473: length 3.4
  TOP w0.097: U6.5 47.16,65.81 47.42,66.07 47.42,66.32 v1(48.09,67) 48.48,67.39 R282.1
N16827117: length 4.4
  BOTTOM w0.457: TL1.7 v2(30.32,96.48) ; TL1.10 v2(30.32,93.48) ; TL1.4 v2(30.36,99.48) ; TL1.1 v2(30.36,102.48)
  vias: v1(30.19,101.04)
N16827394: length 1.7
  TOP w0.097: v1(19.53,104.6) 19.46,104.66 C291.1
N16843215: length 3.2
  BOTTOM w0.076: U2007.C10 35.5,77.13 36.8,77.13
  BOTTOM w0.089: R2063.2 37.66,76.53 37.06,77.13 36.8,77.13
N16897992: length 5.8
  BOTTOM w0.076: U2007.B2 35.99,72.64 35.99,72.13
  BOTTOM w0.089: 37.64,68.91 37.69,68.96 37.69,69.93 37.48,70.13 R2060.2 ; 35.99,72.13 35.99,71.24
  BOTTOM w0.097: v1(37.31,68.28) 37.31,68.58 37.64,68.91
  BOTTOM w0.102: R2060.2 37.1,70.13 35.99,71.24
N16898760: length 2.2
  TOP w0.089: v1(34.94,76.43) 34.94,76.79 v1(35.15,76.99) R2062.2
  BOTTOM w0.089: U2007.D10 34.75,76.63 v1(34.94,76.43)
N16899256: length 2.9
  BOTTOM w0.089: U2007.G11 v1(33.25,79.2) 33.25,80.13 R2084.2
N16968466: length 1.2
  TOP w0.356: v1(34.13,73.36) 34.21,73.28 R2068.1
  BOTTOM w0.178: U2007.E4 34.25,73.48 v1(34.13,73.36)
N16968469: length 1.7
  TOP w0.356: R2070.1 34.84,73.03 34.84,73.29 v1(34.75,73.38)
  BOTTOM w0.178: v1(34.75,73.38) 34.75,73.38 U2007.D5
N16968572: length 1.1
  TOP w0.356: C2131.2 32.23,75.43 v1(32.18,75.38)
  BOTTOM w0.178: U2007.H7 v1(32.18,75.38)
N16976376: length 3.6
  TOP w0.097: U7.18 286.73,29.46 v1(286.23,28.96) 285.46,28.2 C328.2 C329.2
N16976592: length 4.9
  TOP w0.203: v2(287.75,28.88) 287.93,29.06 U7.21
  BOTTOM w0.305: v2(287.75,28.88) 287.75,28.58 288.44,27.89 C326.2 C327.2 v1(288.94,26.09)
N16976910: length 2.9
  TOP w0.203: v2(288.41,28.86) 288.33,28.94 U7.22
  BOTTOM w0.097: C324.2 C325.1 288.44,28.88 v2(288.41,28.86)
N16977173: length 4.8
  TOP w0.203: v1(293.24,27.31) C318.2 291.81,27.82 291.81,28.48 291.46,28.83 291.13,28.83 290.33,29.63 U7.27
N16977182: length 2.7
  TOP w0.203: C318.1 292.32,28.48 291.59,29.21 291.34,29.21 290.73,29.82 U7.28
N16977185: length 2.4
  TOP w0.203: U7.26 289.93,29.52 291.18,28.27 C321.1
N16977188: length 3.7
  TOP w0.203: U7.25 289.53,29.44 289.98,28.99 v1(289.98,28.84) 290.54,28.27 290.54,27.64 290.87,27.31 C321.2
N16977287: length 3.5
  TOP w0.203: C315.1 292.31,30.76 292.31,31.57 292.06,31.81 U7.31
N16977319: length 3.7
  TOP w0.203: U7.29 291.61,31.01 291.75,31.01 291.94,30.81 291.94,29.67 292.35,29.26 v1(292.7,29.26)
  TOP w0.254: C317.1 293.26,28.71 v1(292.7,29.26)
N16977470: length 3.9
  TOP w0.203: U7.41 292.07,35.81 v2(293.25,36.99)
  BOTTOM w0.254: C313.1 293.08,38.43 293.34,38.18 293.34,37.07 v2(293.25,36.99)
N16978248: length 3.4
  TOP w0.203: 291.48,37.6 290.98,37.6 290.73,37.35 U7.43
  TOP w0.356: C306.2 C307.1 292.19,38.13 291.66,37.6 291.48,37.6
N16979537: length 2.1
  TOP w0.203: U7.44 290.33,37.56 290.77,38 291,38
  TOP w0.356: 291,38 291.33,38.33 C309.1
N16980185: length 3.6
  TOP w0.097: v1(285.54,24.69) R313.1 R314.1 C331.1 C330.2
N17007017: length 4.7
  TOP w0.097: R296.2 282.57,38.1 v1(283.28,38.1) 283.61,38.1 283.94,37.77 285.67,37.77 285.93,37.51 U7.55
N17007044: length 3.8
  TOP w0.097: U7.56 285.53,37.35 285.34,37.54 282.24,37.54 R298.2
N17007081: length 2.8
  TOP w0.097: U7.1 284.26,36.21 283.69,36.78 v1(283.56,36.78) R301.2
N17007119: length 2.7
  TOP w0.097: R302.2 283.43,35.89 283.92,35.41 U7.3
N17009629: length 2.5
  TOP w0.102: v2(275.03,27.46) 275.02,27.45 U8.28
  BOTTOM w0.097: C358.2 274.36,26.8 v2(275.03,27.46)
N17009645: length 4.9
  TOP w0.097: U8.32 277.25,29.45 278.02,30.23 278.78,30.23 v1(278.86,30.15) 278.94,30.23 279.75,30.23 C360.2
N17009647: length 5.3
  TOP w0.097: U8.34 277.48,30.45 277.59,30.56 280.33,30.56 C360.1 v1(281.43,30.38)
N17009661: length 2.1
  TOP w0.203: C361.2 278.16,30.95 U8.35
N17009677: length 2.2
  TOP w0.097: C362.1 277.77,31.45 U8.36
N17009679: length 3.3
  TOP w0.097: C362.2 278.7,32.45 277.7,32.45 277.21,31.95 U8.37
N17009693: length 4.5
  TOP w0.097: U8.38 277.32,32.45 277.54,32.67 279.14,32.67 v1(279.34,32.87) 280.05,32.16 C363.1
N17009767: length 2.3
  TOP w0.102: U8.11 267.67,32.45 266.92,31.7 C364.1
N17009783: length 3.5
  TOP w0.097: C365.1 266.08,30.94 266.67,30.94 267.68,31.95 U8.12
N17009785: length 2.4
  TOP w0.097: U8.13 267.56,31.45 266.54,30.43 C365.2
N17010419: length 4
  TOP w0.097: v1(266.64,25.07) 266.49,25.23 R322.2 266.92,25.99 267.3,26.37 267.3,27.13 267.63,27.45 U8.21
N17011679: length 3.4
  TOP w0.254: 267.3,35.28 267.47,35.45 U8.5
  TOP w0.508: v1(265.32,35.56) C351.2 266.54,35.28 267.3,35.28
N17011706:
  vias: v1(269.49,38.61)
N17011853:
  vias: v1(277.08,38.54)
N17011867: length 2.3
  TOP w0.254: 277.59,35.06 277.19,35.45 U8.44
  TOP w0.508: C354.2 277.97,34.67 277.59,35.06
N17104532: length 5.4
  TOP w0.097: R2058.2 39.08,72.04 39.08,73.49 38.19,74.38 v3(37.43,74.38)
  BOTTOM w0.102: v3(37.43,74.38) U2007.A5
N17104536: length 5.1
  TOP w0.097: v1(37.43,73.74) 38.2,73.74 38.7,73.23 v1(38.7,72.98) R2059.2
  BOTTOM w0.076: 36.8,74.12 36.15,74.12 36.15,74.12 36.01,74.12 U2007.B5
  BOTTOM w0.102: 36.8,74.12 36.92,74.12 37.31,73.74 v1(37.43,73.74)
N17166492: length 1.6
  TOP w0.089: v1(35.3,75.52) 35.6,75.21 R2086.2
  BOTTOM w0.089: U2007.D7 34.89,75.52 v1(35.3,75.52)
N17166775: length 1.5
  TOP w0.089: R2085.2 33.06,76.74 v1(33.42,76.38)
  BOTTOM w0.089: U2007.G10 33.25,76.55 v1(33.42,76.38)
N17246415: length 3
  TOP w0.076: v1(51.91,88.98) 51.54,89.35 51.54,89.98
  TOP w0.102: R2032.1 50.9,90.63 v1(51.38,90.15) 51.54,89.98
  BOTTOM w0.102: U2005.N6 51.59,88.66 v1(51.91,88.98)
N17249246: length 2.1
  TOP w0.097: TP93.1 v1(283.28,35.51) 283.4,35.51 283.9,35.01 U7.4
N17282944: length 4.9
  TOP w0.089: R2089.1 29,76.31 v1(28.87,76.43) 28.54,76.76 v1(28.54,76.91)
  BOTTOM w0.076: U2007.K8 31.49,76.14 30.71,76.14 30.19,76.66 29.1,76.66 v1(28.87,76.43)
N17283025: length 3.6
  TOP w0.089: R2090.2 v1(30.04,75.67) 30.04,76.18 v1(29.94,76.28)
  BOTTOM w0.076: v1(29.94,76.28) 30.32,76.28 30.72,75.88 U2007.L8
N17351028: length 9.1
  TOP w0.097: R2093.1 31.87,81.41 31.77,81.51 31.19,81.51 v3(30.93,81.26) ; U2011.4 v2(26.67,77.96)
  IN08 w0.089: 26.97,80.55 27.15,80.72
  IN08 w0.091: 26.97,80.55 26.77,80.34 26.77,78.06 v2(26.67,77.96) ; v3(30.93,81.26) 30.65,80.98 27.4,80.98 27.15,80.72
N17351043: length 4.9
  TOP w0.089: 26.97,80.39 27.4,79.96 28.34,79.96 R2097.2 C2139.1 29.86,79.76 29.94,79.84 R2096.2 ; 26.97,79.89 27.02,79.84 U2011.2
  TOP w0.097: 26.97,79.89 26.89,79.96 v1(26.89,80.47) 26.97,80.39
N17738807: length 1.2
  TOP w0.356: R346.1 278.35,45.24 R344.1
N17740217: length 6.3
  TOP w0.254: C374.2 287.5,50.42 287.29,50.63 v2(287.12,50.63) 286.99,50.63 286.68,50.32 U9.22 ; v2(287.12,53.04) 286.99,52.92 U9.26
  BOTTOM w0.254: v2(287.12,50.63) v2(287.12,53.04)
N17740396: length 6
  TOP w0.254: v2(287.12,47.32) 286.86,47.07 U9.17 ; U9.21 286.68,49.67 286.99,49.36 v2(287.12,49.36) 287.37,49.36 287.57,49.56 C376.2
  BOTTOM w0.254: v2(287.12,47.32) v2(287.12,49.36)
N17741392: length 1.8
  TOP w0.457: C379.1 R333.2
  TOP w0.508: C379.1 v1(290.72,52.2)
N17741619: length 0.9
  TOP w0.457: R334.2 289.78,48.06 289.71,47.98 C380.1
N17787956: length 5.2
  BOTTOM w0.254: U25.7 206.59,108.25 v1(206.12,107.78) 204.16,107.78 203.55,108.39 R554.2
N17791490: length 2
  TOP w0.508: R344.2 277.21,44.33 C382.1 277.16,43.64 R343.1
N17791569: length 3
  TOP w0.508: v1(274.87,43.34) R339.1 276.24,43.77 C382.2 275.36,44.28 R340.2
N18154072: length 2.5
  TOP w0.254: PR1407.1 118.89,69.55 v1(117.95,69.55) 117.95,69.15 PQ1404.3
N18154233: length 1.1
  BOTTOM w0.356: PR1411.1 207.97,194.67 208.26,194.38 PQ1405.3
N18154289: length 1
  BOTTOM w0.097: PR1410.2 207.51,193.78 207.61,193.88 PQ1405.2
N18154418: length 3.3
  TOP w0.097: PR1408.2 119.12,66.2 119.83,66.91 v1(119.83,67.34) 119.83,67.52 119.45,67.9 PQ1404.2
N18154431: length 1.3
  TOP w0.097: PR1405.2 107.46,66.88 PQ1401.2
N18155028: length 4.2
  TOP w0.254: PR1404.1 112.8,70.39 v1(112.24,70.95) 112.11,71.07 110.8,71.07 110.47,70.74 PQ1403.3
N18155196: length 2.7
  TOP w0.254: PQ1403.6 111.72,68.54 111.86,68.41 v1(112.62,68.41) 112.62,68.02 112.43,67.83 PR1413.1
N18288660: length 7.2
  TOP w0.254: 87.82,8.29 87.51,8.6 PU201.18
  TOP w0.508: 87.82,8.29 88.28,7.83 89.48,7.83 v1(89.61,7.7) 89.63,7.7 90.77,6.56 PC220.1 91.22,6.49 92.34,5.38 PR218.1
N18288662: length 2.3
  TOP w0.356: PC203.1 PR231.2 101.64,19.46 PQ203.4
N18288666: length 44.6
  TOP w0.254: PR207.1 110.57,21.15 v2(111.09,21.67) ; v2(87.76,3) 87.76,3.44 PR211.2
  TOP w0.356: PC203.2 105.38,20.65
  IN05 w0.254: v2(87.76,3) 87.66,3.11 87.66,4.34 90.55,7.24 94.11,7.24 95.2,8.33 95.2,10.29 94.31,11.18 94.31,13.91 95.79,15.4 95.79,18.79 98.42,21.42 106.01,21.42 106.39,21.8 110.97,21.8 v2(111.09,21.67)
N18288670: length 6.4
  TOP w0.254: 88.9,8.41 88.54,8.41 v1(88.09,8.86) 87.94,9 PU201.19
  TOP w0.381: PR214.1 90.27,7.89 89.75,8.41 88.9,8.41
  TOP w0.508: PR214.1 91.22,7.57 92.49,7.57 PC214.1
N18288674: length 5.4
  TOP w0.254: PC221.2 PR221.2 81.76,5.24 81.76,5.81 82.35,6.4 82.52,6.4 82.8,6.68 83.66,6.68 84.19,7.21 PU201.10
N18343239: length 1.1
  BOTTOM w0.254: PU902.28 268.3,201.74 PTP903.1
N18346836: length 4.1
  BOTTOM w0.254: PU901.27 255.71,202.17 PC906.1 256.54,202.17 256.54,201.53 256.51,201.5 PU901.29
