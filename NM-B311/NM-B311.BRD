# Allegro board NM-B311.BRD (continued)
## Nets (continued)
ACDET: PC223.1 PR203.2 PR206.1 PU201.1
ACOK: PU201.2 R245.2 R248.1
ACOK_R: C71.1 R248.2 U5.A4
ADAPTER_ID: JDCIN1.5 PC108.1 PD101.1 PQ101.1 PR107.1 U5.F9
ADIN_1: PC106.1 PC107.1 PC201.2 PD201.2 PL103.2 PL104.2 PQ201.5 PQ205.5 PR106.1 PR116.1 PR203.1
ALL_SYS_PWRGD: C246.2 R260.1 U5.B9
ALL_SYS_PWRGD_PMIC: PR1242.2 R56.1 R538.2 R843.1
ALL_SYS_PWRGD_PMIC_R: R300.2 R538.1 U61.4
ALW_B+: PC301.1 PC304.1 PC305.1 PC306.1 PC307.1 PC308.1 PJ303.1 PQ301.3 PQ301.4 PQ301.10 PQ302.3 PQ302.4 PQ302.10 PR315.1
AMON: PC218.2 PR213.1 U5.F13
AMP_GAIN/FSW: R325.2 R328.1 U8.9
AMP_MONO: R335.2 U9.14
AMP_PD_N_R: D19.2 R323.1 R330.2 R338.1 U8.27
AMP_SPK_L+: C354.1 R68.2 U8.45
AMP_SPK_L-: C353.1 R69.2 U8.47
AMP_SPK_R+: C351.1 R66.2 U8.4
AMP_SPK_R-: C352.1 R67.2 U8.2
APDIN: JDCIN1.1 JDCIN1.2 JDCIN1.3 JDCIN1.4 PF102.1
AR_HOLD_RST_N: R2103.1 U5.B12
ASGATE: PR202.2 PU201.30
AUD_AZACPU_SCLK: R2291.1 U1.G27
AUD_AZACPU_SDO: R2292.1 U1.G25
B+: C1327.1 PC193.1 PC194.1 PC195.1 PC225.1 PC226.1 PC227.1 PC1310.2 PJ4.2 PJ303.2 PJ401.1 PJ405.2 PJ501.2 PJ1207.2 PJ1501.1 PJ1502.1 PJ1503.1 PJ1505.2 PQ203.5 PQ204.3 PQ204.4 PQ204.10 PR201.2 PR232.2 PR701.2 PU1306.1 PU1306.2
B+_1.0VG: PC709.1 PC710.1 PC711.1 PJ704.1 PU702.8
B+_1.05VP: PC501.1 PC502.1 PC503.1 PJ501.1 PU501.8
B+_1.8VP: PC3531.1 PC3534.1 PC3535.1 PJ1505.1 PU1309.8
B+_2.5VP: PC419.1 PC420.1 PC436.1 PJ405.1 PU403.8
B+_GPU_ALL: PC701.1 PC702.1 PC722.1 PC723.1 PC3401.1 PC3426.1 PC3501.1 PC3502.1 PC3503.1 PC3504.1 PQ701.3 PQ701.4 PQ701.10 PQ702.3 PQ702.4 PQ702.10 PR701.1 PR901.2 PR3552.2
B+_GPU_ALLN: PR26.1 PR701.4
B+_GPU_ALLP: PR29.1 PR701.3
B+_GPU_COREN: PR36.1 PR901.4
B+_GPU_COREP: PR24.1 PR901.3
B+_NVVDDSN: PR3552.4 PR3569.1
B+_NVVDDSP: PR3552.3 PR3568.1
BAT_R: JBAT1.1 JBAT1.2 JBAT1.3 JBAT1.4 PC103.1 PF101.2
BATT_SMB_CLK: JBAT1.5 PR101.2
BATT_SMB_DAT: JBAT1.6 PR102.2
BGATE: PR231.1 PU201.25
BIOS_ONEKEY_N: JKB1.48 R268.2 U5.D8
BMON: PC219.2 PR215.1 U5.F10
BOARD_ID0: R186.1 R188.2 U2.AG42
BOARD_ID1: R185.1 R187.2 U2.AG43
BOARD_ID2: R855.2 R856.1 U2.AE45
BST_3V: PR309.2 PU301.9
BST_5V: PR308.1 PU301.17
CAM_PWR_EN: PR1305.2 R103.1 U2.R36
CFG0: R10.2 TP24.1(TP-1) U1.BN25
CFG1: TP26.1(TP-1) U1.BN27
CFG2: R12.2 TP28.1(TP-1) U1.BN26
CFG3: R269.1 TP29.1(TP-1) U1.BN28
CFG4: R23.2 TP30.1(TP-1) U1.BR20
CFG5: R28.2 TP31.1(TP-1) U1.BM20
CFG6: R26.2 TP33.1(TP-1) U1.BT20
CFG7: R32.2 TP32.1(TP-1) U1.BP20
CFG8: TP34.1(TP-1) U1.BR23
CFG9: TP36.1(TP-1) U1.BR22
CFG10: TP39.1(TP-1) U1.BT23
CFG11: TP38.1(TP-1) U1.BT22
CFG12: TP40.1(TP-1) U1.BM19
CFG13: TP41.1(TP-1) U1.BR19
CFG14: TP43.1(TP-1) U1.BP19
CFG15: TP42.1(TP-1) U1.BT19
CFG16: TP44.1(TP-1) U1.BP23
CFG17: TP45.1(TP-1) U1.BN23
CFG18: TP47.1(TP-1) U1.BN22
CFG19: TP46.1(TP-1) U1.BP22
CFG_RCOMP: R22.2 U1.BT25
CHASSIS1_GND: C278.2 C279.2 C280.2 C281.2 C291.2 DL1.2 JRJ1.9 JRJ1.10
CHG_DH: PR209.2 PU201.23
CHG_DH_R: PQ204.1 PR209.1
CHG_DL: PQ204.8 PU201.21
CHG_PAHSE: PL201.1 PQ204.5 PQ204.6 PQ204.7
CHG_PROCHOT_N: PR229.2 PU201.5
CHG_PROCHOT_N_R: D2016.1 PR229.1 R247.2 R435.1 U5.C13
CHG_SMB_CLK: PR228.2 PU201.4
CHG_SMB_DAT: PR227.2 PU201.3
CHG_TGR: PC212.2 PQ204.2 PU201.22
CK_CPU_24M_N: U1.D31 U2.F1
CK_CPU_24M_P: U1.E31 U2.G1
CK_CPU_BCLK_N: U1.A32 U2.H2
CK_CPU_BCLK_P: U1.B31 U2.G2
CK_CPU_PCIBCLK_N: U1.C36 U2.J1
CK_CPU_PCIBCLK_P: U1.D35 U2.J2
CK_CR_N: JIO1.27 U2.E5
CK_CR_P: JIO1.26 U2.G4
CK_LAN_N: R278.1 U2.D8
CK_LAN_P: R279.1 U2.D7
CK_LPC1: TP184.1(TP-1) U2.AV19
CK_LPC/ESPI_CLK: R183.1 R264.2 U5.K2
CK_LPC/ESPI_CLK_R: R183.2 U2.BC17
CK_PCIE_SSD1_N: JSSD1.53 U2.N3
CK_PCIE_SSD1_P: JSSD1.55 U2.N2
CK_PCIE_SSD2_N: JSSD2.53 U2.D5
CK_PCIE_SSD2_P: JSSD2.55 U2.E6
CK_PEG1_N: G2.BM27 U2.N7
CK_PEG1_P: G2.BM26 U2.N8
CK_REQ_CR_N: JIO1.18 RP2.5 U2.BD25
CK_REQ_LAN_N: Q35.6 R277.1 RP2.6 U2.BE25
CK_REQ_PEG1_N: Q13.6 R601.2 RP2.8 U2.BC24
CK_REQ_SSD1_N: Q9.6 R304.2 R479.2 R512.2 U2.BC32
CK_REQ_SSD2_N: Q9.3 R485.2 R508.2 RP2.7 U2.BB24
CK_REQ_TBT_N: R309.2 R2067.1 U2.BD32
CK_REQ_TBT_N_R: R2066.1 R2067.2 U2005.AC5
CK_REQ_WLAN_N: Q8.6 R457.1 R787.2 U2.AT24
CK_TBT_N: U2.W10 U2005.T19
CK_TBT_P: U2.W11 U2005.V19
CK_WLAN_N: JWLAN1.49 U2.D3
CK_WLAN_P: JWLAN1.47 U2.F2
CK_XDP_N: TP55.1(TP-1) U2.L1
CK_XDP_P: TP54.1(TP-1) U2.L2
CLK_REQ_PEG_N_R: G2.BL26 Q13.1 R600.2 R601.1
CLKA0: G2.AG45 R774.2 U48.J12
CLKA0_N: G2.AG46 R2219.2 U48.J11
CLKA1: G2.AK46 R2218.2 U2022.J12
CLKA1_N: G2.AK45 R2215.2 U2022.J11
CLKB0: G2.H42 R2223.2 U2023.J12
CLKB0_N: G2.G42 R2221.2 U2023.J11
CLKB1: G2.F47 R2220.2 U55.J12
CLKB1_N: G2.E47 R871.2 U55.J11
CLKC0: G2.G15 R2226.2 U2025.J12
CLKC0_N: G2.F15 R2227.2 U2025.J11
CLKC1: G2.H21 R903.2 U2024.J12
CLKC1_N: G2.J21 R901.2 U2024.J11
CLKD0: G2.Y8 R785.2 U2026.J12
CLKD0_N: G2.Y7 R906.2 U2026.J11
CLKD1: G2.R8 R916.2 U60.J12
CLKD1_N: G2.R7 R914.2 U60.J11
CMDA0: G2.Y51 U48.G3
CMDA1: G2.Y52 R2195.1 U48.J3
CMDA2: G2.Y49 R2200.1 U48.J2
CMDA3: G2.AA52 U48.L3
CMDA4: G2.AA51 U48.K5
CMDA5: G2.AA50 U48.K4
CMDA6: G2.AC50 U48.J5
CMDA7: G2.AC51 U48.J4
CMDA8: G2.AC52 U48.H5
CMDA9: G2.AC49 U48.H4
CMDA10: G2.AD52 U48.G12
CMDA11: G2.AD51 U48.H10
CMDA12: G2.AD50 U48.H11
CMDA13: G2.AF50 U48.K11
CMDA14: G2.AF51 U48.K10
CMDA15: G2.AF52 U48.L12
CMDA16: G2.AN50 U2022.L3
CMDA17: G2.AN51 R2197.1 U2022.J3
CMDA18: G2.AN52 R2193.1 U2022.J2
CMDA19: G2.AM49 U2022.G3
CMDA20: G2.AM52 U2022.H5
CMDA21: G2.AM51 U2022.H4
CMDA22: G2.AM50 U2022.J5
CMDA23: G2.AK50 U2022.J4
CMDA24: G2.AK51 U2022.K5
CMDA25: G2.AK52 U2022.K4
CMDA26: G2.AJ49 U2022.L12
CMDA27: G2.AJ52 U2022.K10
CMDA28: G2.AJ51 U2022.K11
CMDA29: G2.AJ50 U2022.H11
CMDA30: G2.AG50 U2022.H10
CMDA31: G2.AG51 U2022.G12
CMDB0: G2.B35 U2023.G3
CMDB1: G2.A35 R2198.1 U2023.J3
CMDB2: G2.D35 R2194.1 U2023.J2
CMDB3: G2.A36 U2023.L3
CMDB4: G2.B36 U2023.K5
CMDB5: G2.C36 U2023.K4
CMDB6: G2.C38 U2023.J5
CMDB7: G2.B38 U2023.J4
CMDB8: G2.A38 U2023.H5
CMDB9: G2.D38 U2023.H4
CMDB10: G2.A39 U2023.G12
CMDB11: G2.B39 U2023.H10
CMDB12: G2.C39 U2023.H11
CMDB13: G2.C41 U2023.K11
CMDB14: G2.B41 U2023.K10
CMDB15: G2.A41 U2023.L12
CMDB16: G2.B49 U55.L3
CMDB17: G2.A49 R2199.1 U55.J3
CMDB18: G2.A48 R2196.1 U55.J2
CMDB19: G2.D47 U55.G3
CMDB20: G2.A47 U55.H5
CMDB21: G2.B47 U55.H4
CMDB22: G2.C47 U55.J5
CMDB23: G2.C45 U55.J4
CMDB24: G2.B45 U55.K5
CMDB25: G2.A45 U55.K4
CMDB26: G2.D44 U55.L12
CMDB27: G2.A44 U55.K10
CMDB28: G2.B44 U55.K11
CMDB29: G2.C44 U55.H11
CMDB30: G2.C42 U55.H10
CMDB31: G2.B42 U55.G12
CMDC0: G2.C11 U2025.G3
CMDC1: G2.B11 R2202.1 U2025.J3
CMDC2: G2.A11 R2206.1 U2025.J2
CMDC3: G2.D11 U2025.L3
CMDC4: G2.A12 U2025.K5
CMDC5: G2.B12 U2025.K4
CMDC6: G2.C12 U2025.J5
CMDC7: G2.C14 U2025.J4
CMDC8: G2.B14 U2025.H5
CMDC9: G2.A14 U2025.H4
CMDC10: G2.D14 U2025.G12
CMDC11: G2.A15 U2025.H10
CMDC12: G2.B15 U2025.H11
CMDC13: G2.C15 U2025.K11
CMDC14: G2.C17 U2025.K10
CMDC15: G2.B17 U2025.L12
CMDC16: G2.B24 U2024.L3
CMDC17: G2.A24 R2203.1 U2024.J3
CMDC18: G2.D23 R2207.1 U2024.J2
CMDC19: G2.A23 U2024.G3
CMDC20: G2.B23 U2024.H5
CMDC21: G2.C23 U2024.H4
CMDC22: G2.C21 U2024.J5
CMDC23: G2.B21 U2024.J4
CMDC24: G2.A21 U2024.K5
CMDC25: G2.D20 U2024.K4
CMDC26: G2.A20 U2024.L12
CMDC27: G2.B20 U2024.K10
CMDC28: G2.C20 U2024.K11
CMDC29: G2.C18 U2024.H11
CMDC30: G2.B18 U2024.H10
CMDC31: G2.A18 U2024.G12
CMDD0: G2.AD2 U2026.G3
CMDD1: G2.AD1 R2204.1 U2026.J3
CMDD2: G2.AD4 R2201.1 U2026.J2
CMDD3: G2.AC1 U2026.L3
CMDD4: G2.AC2 U2026.K5
CMDD5: G2.AC3 U2026.K4
CMDD6: G2.AA3 U2026.J5
CMDD7: G2.AA2 U2026.J4
CMDD8: G2.AA1 U2026.H5
CMDD9: G2.AA4 U2026.H4
CMDD10: G2.Y1 U2026.G12
CMDD11: G2.Y2 U2026.H10
CMDD12: G2.Y3 U2026.H11
CMDD13: G2.V3 U2026.K11
CMDD14: G2.V2 U2026.K10
CMDD15: G2.V1 U2026.L12
CMDD16: G2.L3 U60.L3
CMDD17: G2.L2 R2205.1 U60.J3
CMDD18: G2.L1 R857.1 U60.J2
CMDD19: G2.M4 U60.G3
CMDD20: G2.M1 U60.H5
CMDD21: G2.M2 U60.H4
CMDD22: G2.M3 U60.J5
CMDD23: G2.P3 U60.J4
CMDD24: G2.P2 U60.K5
CMDD25: G2.P1 U60.K4
CMDD26: G2.R4 U60.L12
CMDD27: G2.R1 U60.K10
CMDD28: G2.R2 U60.K11
CMDD29: G2.R3 U60.H11
CMDD30: G2.U3 U60.H10
CMDD31: G2.U2 U60.G12
CODEC_PD_N: D8.1 D19.1 U5.E6
CODEC_PD_N_R: D8.2 R292.1 R338.2 U7.52
COMP31: PC3439.1 PR3419.2
COMP31_NVS: PC3571.1 PR3444.2
COMP32: PC3438.1 PR3417.2
COMP32_NVS: PC3514.1 PR3441.2
COMP_1PH_A: PC1149.2 PC1150.2 PU1101.18
COMP_3PH_A: PC1120.2 PC1133.2 PU1101.48
CPU_2_PCH_TRIGGER: R31.2 U2.AK1
CPU_2_PCH_TRIGGER_R: R31.1 U1.J23
CPU_B+: PC1501.1 PC1502.1 PC1503.1 PC1504.1 PC1505.1 PC1506.1 PC1508.1 PC1523.1 PC1524.1 PC1525.1 PC1526.1 PC1527.1 PC1529.1 PC1545.1 PC1546.1 PC1547.1 PC1548.1 PC1549.1 PC1602.1 PC1603.1 PC1604.1 PC1605.1 PC1606.1 PC1607.1 PC1620.1 PC1621.1 PC1622.1 PC1623.1 PC1624.1 PC1625.1 PC1626.1 PC1639.1 PC1640.1 PC1641.1 PC1642.1 PC1643.1 PC1644.1 PC1645.1 PC1646.1 PC1651.1 PC1664.1 PC1665.1 PC1666.1 PC1667.1 PJ704.2 PJ1501.2 PJ1502.2 PJ1503.2 PR1196.1 PU1501.20 PU1501.21 PU1501.22 PU1501.23 PU1501.24 PU1501.25 PU1502.20 PU1502.21 PU1502.22 PU1502.23 PU1502.24 PU1502.25 PU1601.20 PU1601.21 PU1601.22 PU1601.23 PU1601.24 PU1601.25 PU1602.20 PU1602.21 PU1602.22 PU1602.23 PU1602.24 PU1602.25 PU1603.20 PU1603.21 PU1603.22 PU1603.23 PU1603.24 PU1603.25
CPU_CORE: C952.1 C953.1 C954.1 C955.1 C956.1 C957.1 C958.1 C959.1 C960.1 C961.1 C962.1 C974.1 C975.1 C976.1 C977.1 C978.1 C979.1 C980.1 C981.1 C982.1 C983.1 C984.1 C985.1 C986.1 C987.1 C988.1 C1007.1 C1008.1 C1009.1 C1010.1 C1011.1 C1012.1 C1013.1 C1014.1 C1015.1 C1016.1 C1017.1 C1018.1 C1019.1 C1020.1 C1021.1 C1040.2 C1041.2 C1042.2 C1043.2 C1044.2 C1045.2 C1046.2 C1047.2 C1048.2 C1049.2 C1050.2 C1051.2 C1052.2 C1053.2 C1054.2 C1055.2 C1056.2 C1057.2 C1058.2 C1059.2 C1060.2 C1061.2 C1062.2 C1086.2 C1087.2 C1088.2 C1089.2 C1090.2 C1091.2 C1092.2 C1093.2 C1094.2 C1095.2 C1096.2 C1097.2 C1098.2 C1099.2 C1100.2 C1101.2 C1102.2 C1103.2 C1104.2 C1105.2 C1106.2 C1107.2 C1108.2 C1132.2 C1133.2 C1134.2 C1135.2 C1136.2 C1137.2 C1138.2 C1139.2 C1140.2 C1141.2 C1142.2 C1143.2 C1144.2 C1145.2 C1146.2 C1147.2 C1148.2 C1149.2 C1150.2 C1151.2 C1152.2 C1153.2 C1154.2 C1178.1 C1179.1 C1180.1 C1181.2 C1182.2 C1183.2 C1184.2 PC1513.1 PC1514.1 PC1515.1 PC1516.1 PC1517.1 PC1518.1 PC1519.1 PC1521.1 PC1522.1 PC1533.1 PC1534.1 PC1535.1 PC1536.1 PC1537.1 PC1538.1 PC1539.1 PC1540.1 PC1543.1 PC1544.1 PC1611.1 PC1612.1 PC1613.1 PC1614.1 PC1615.1 PC1616.1 PC1617.1 PC1618.1 PC1630.1 PC1631.1 PC1632.1 PC1633.1 PC1634.1 PC1635.1 PC1636.1 PC1637.1 PL1501.4 PL1502.4 PL1601.4 PL1602.4 PR1164.1 U1.AA13 U1.AA31 U1.AA32 U1.AA33 U1.AA34 U1.AA35 U1.AA36 U1.AA37 U1.AA38 U1.AB29 U1.AB30 U1.AB31 U1.AB32 U1.AB35 U1.AB36 U1.AB37 U1.AB38 U1.AC13 U1.AC14 U1.AC29 U1.AC30 U1.AC31 U1.AC32 U1.AC33 U1.AC34 U1.AC35 U1.AC36 U1.AD13 U1.AD14 U1.AD31 U1.AD32 U1.AD33 U1.AD34 U1.AD35 U1.AD36 U1.AD37 U1.AD38 U1.AE13 U1.AE14 U1.AE30 U1.AE31 U1.AE32 U1.AE35 U1.AE36 U1.AE37 U1.AE38 U1.AF35 U1.AF36 U1.AF37 U1.AF38 U1.K13 U1.K14 U1.L13 U1.L14 U1.N13 U1.N14 U1.N30 U1.N31 U1.N32 U1.N35 U1.N36 U1.N37 U1.N38 U1.P13 U1.P14 U1.P29 U1.P30 U1.P31 U1.P32 U1.P33 U1.P34 U1.P35 U1.P36 U1.R13 U1.R31 U1.R32 U1.R33 U1.R34 U1.R35 U1.R36 U1.R37 U1.R38 U1.T29 U1.T30 U1.T31 U1.T32 U1.T35 U1.T36 U1.T37 U1.T38 U1.U29 U1.U30 U1.U31 U1.U32 U1.U33 U1.U34 U1.U35 U1.U36 U1.V13 U1.V14 U1.V31 U1.V32 U1.V33 U1.V34 U1.V35 U1.V36 U1.V37 U1.V38 U1.W13 U1.W14 U1.W29 U1.W30 U1.W31 U1.W32 U1.W35 U1.W36 U1.W37 U1.W38 U1.Y29 U1.Y30 U1.Y31 U1.Y32 U1.Y33 U1.Y34 U1.Y35 U1.Y36
CPU_CSREF: PC1422.2 PC1423.2 PC1424.2 PC1425.2 PC1426.2 PC1427.1 PR907.1 PR914.1 PR1006.1 PR1013.1 PR3532.1 PR3562.2 PR3563.2 PR3564.2 PR3565.2 PR3566.2 PU1605.21
CPU_EDP_HPD: R934.2 U2.BD7
CPU_PLTRST_N: R176.2 U1.BP35
CPU_PLTRST_N_R: R176.1 U2.AK2
CPU_SVID_ALERT_N: R9.2 U1.BH31
CPU_SVID_CLK: R46.2 U1.BH32
CPU_SVID_DATA: R48.2 U1.BH29
CPU_SVIDALERT_N: PR1239.2 R8.1 R9.1
CPU_SVIDCLK: PR1234.1 PR1238.1 R46.1
CPU_SVIDDATA: PR1235.2 PR1237.2 R7.2 R48.1
CPU_VCCIO_VCC_SENSE: PR1227.1 U1.H14
CPU_VCCIO_VSS_SENSE: PR1229.1 U1.J14
CPU_VCCSA_VCC_SENSE: PR1172.2 PR1175.1 U1.M38
CPU_VCCSA_VSS_SENSE: PR1169.1 PR1173.2 U1.M37
CPU_VCORE_VCC_SENSE: PR1121.1 PR1164.2 R59.1 U1.AG37
CPU_VCORE_VSS_SENSE: PR1163.2 PR1165.1 R59.2 U1.AG38
CPU_VR_HOT_N: PR1233.1 R556.2
CPU_VR_PWRGD: PR1241.1 R260.2
CSCOMP_1PH_A: PC1154.1 PC1155.1 PH1106.1 PR1199.1 PR1211.2 PU1101.19
CSCOMP_3PH_A: PC1130.1 PC1140.1 PH1103.1 PR1148.1 PR1208.2 PU1101.47
CSN1_3PH_A: PC1148.1 PR1155.2 PR1505.2 PU1101.38
CSN2_3PH_A: PC1147.1 PR1158.2 PR1511.2 PU1101.40
CSN3_3PH_A: PC1145.1 PR1161.2 PR1605.2 PU1101.42
CSN4_3PH_A: PC1166.1 PR1206.2 PR1613.2 PU1101.24
CSN_1PH: PC1167.1 PR1176.2 PR1619.2 PU1101.26
CSP1_3PH_A: PC1148.2 PR1185.2 PU1101.39
CSP2_3PH_A: PC1147.2 PR1184.2 PU1101.41
CSP3_3PH_A: PC1145.2 PR1183.2 PU1101.43
CSP4_3PH_A: PC1166.2 PR1186.2 PR1205.2 PU1101.23
CSP_1PH: PC1167.2 PR1212.2 PU1101.25
CSREF_3PH_A: PC1161.2 PR1155.1 PR1158.1 PR1161.1 PR1206.1 PU1101.44
CSSUM_1PH: PC1154.2 PC1155.2 PR1154.1 PR1198.2 PU1101.21
CSSUM_3PH_A: PC1130.2 PC1140.2 PR1145.1 PR1146.2 PR1147.1 PR1149.1 PR1151.1 PU1101.45
DDI1_AUX_DN: C2154.1 R585.2
DDI1_AUX_DP: C2153.1 R584.2
DDI1_AUX_OUT_DN: R510.1 R585.1 U2013.27
DDI1_AUX_OUT_DP: R489.1 R584.1 U2013.28
DDI1_DN0: C2044.2 U2013.22
DDI1_DN1: C2047.2 U2013.19
DDI1_DN2: C2050.2 U2013.16
DDI1_DN3: C2052.2 U2013.13
DDI1_DP0: C2043.2 U2013.23
DDI1_DP1: C2045.2 U2013.20
DDI1_DP2: C2049.2 U2013.17
DDI1_DP3: C2051.2 U2013.14
DDI1_HPD: R420.2 R2057.1 U2005.AA2
DDI2_AUX_DN: C2134.1 R632.2
DDI2_AUX_DP: C2133.1 R773.2
DDI2_AUX_OUT_DN: R439.1 R632.1 U2014.27
DDI2_AUX_OUT_DP: R438.1 R773.1 U2014.28
DDI2_DN0: C2057.2 U2014.22
DDI2_DN1: C2059.2 U2014.19
DDI2_DN2: C2061.2 U2014.16
DDI2_DN3: C2063.2 U2014.13
DDI2_DP0: C2056.2 U2014.23
DDI2_DP1: C2058.2 U2014.20
DDI2_DP2: C2060.2 U2014.17
DDI2_DP3: C2062.2 U2014.14
DDI2_HPD: R423.2 R2083.1 U2005.Y6
DDR0_A_ALERT_N: JDIMM1.116 JDIMM2.116 U1.AU5
DDR0_A_PARITY: JDIMM1.143 JDIMM2.143 U1.AG3
DDR1_B_ALERT_N: JDIMM3.116 JDIMM4.116 U1.AR8
DDR1_B_PARITY: JDIMM3.143 JDIMM4.143 U1.AJ7
DDR4_DRAMRST_N: JDIMM1.108 JDIMM2.108 JDIMM3.108 JDIMM4.108 R86.2
DDR_RCOMP0: R4.2 U1.G1
DDR_RCOMP1: R5.2 U1.H1
DDR_RCOMP2: R6.2 U1.J2
DDR_VREF_EN: PC433.1 PD401.2 PR451.2 PU401.8
DDR_VTT_PG_CTRL: R57.1 R838.2 U1.BT13
DGPU_AON_EN: PC3566.1 PR2187.2 PU8.B2 R2266.1
DGPU_AON_EN_N: Q100.5 Q100.6 R2265.2
DGPU_CORE_EN: PC801.1 PD801.1 PR804.1 PR3590.2 PU1605.36
DGPU_HOLD_RST_N: R110.1 U2.Y44 U63.2
DGPU_PEX_RST_N: G2.BK26 R808.2 R1001.2 R2172.2 R2261.1 U62.4
DGPU_PWR_EN: D2007.1 D2010.1 PR2187.1 R108.2 R2259.1 U2.V44
DGPU_PWROK: D69.1 D2009.1 D2013.1 PR3525.2 PU1605.38 R270.2 R1003.1 R2263.1
DGPU_PWROK_N: R270.1 U2.R42
DIFFOUT_1PH_A: PR1159.2 PR1195.2 PU1101.16
DIFFOUT_3PH_A: PR1157.2 PR1243.2 PU1101.50
DIMM0_CHA_EVENT_N: JDIMM1.134 TP126.1(TP-1)
DIMM0_CHB_EVENT_N: JDIMM3.134 TP102.1(TP-1)
DIMM1_CHA_EVENT_N: JDIMM2.134 TP127.1(TP-1)
DIMM1_CHB_EVENT_N: JDIMM4.134 TP128.1(TP-1)
DIMM_SMB_CLK: JDIMM1.253 JDIMM2.253 JDIMM3.253 JDIMM4.253 R81.2
DIMM_SMB_DAT: JDIMM1.254 JDIMM2.254 JDIMM3.254 JDIMM4.254 R82.2
DMI_IT_MR_0_DN: U1.E8 U2.C27
DMI_IT_MR_0_DP: U1.D8 U2.B27
DMI_IT_MR_1_DN: U1.F6 U2.B28
DMI_IT_MR_1_DP: U1.E6 U2.A28
DMI_IT_MR_2_DN: U1.E5 U2.B29
DMI_IT_MR_2_DP: U1.D5 U2.C29
DMI_IT_MR_3_DN: U1.J9 U2.B30
DMI_IT_MR_3_DP: U1.J8 U2.A30
DMI_MT_IR_0_DN: U1.A8 U2.L27
DMI_MT_IR_0_DP: U1.B8 U2.N27
DMI_MT_IR_1_DN: U1.B6 U2.E24
DMI_MT_IR_1_DP: U1.C6 U2.G24
DMI_MT_IR_2_DN: U1.A5 U2.G27
DMI_MT_IR_2_DP: U1.B5 U2.E26
DMI_MT_IR_3_DN: U1.B4 U2.L29
DMI_MT_IR_3_DP: U1.D4 U2.K29
DMIC_CLK: C338.2 JCAM1.6 R293.1
DMIC_CLK_R: R293.2 U7.53
DMIC_DATA: C2728.2 JCAM1.7 R295.1
DMIC_DATA_R: R295.2 U7.54
DP_AUX_C_DN_SDA: D24.2 JDP1.17 R406.2
DP_AUX_C_DP_SCL: D23.2 JDP1.15 R405.2
DP_AUX_OUT_DN_SDA: R406.1 R410.1 U2016.2
DP_AUX_OUT_DP_SCL: R405.1 R411.1 U2016.1
DP_HPD_CON: D22.2 JDP1.18 R409.1 R997.1
DP_TX0_C_DN: C467.2 D2018.4 D2018.7 JDP1.3
DP_TX0_C_DP: C466.2 D2018.5 D2018.6 JDP1.1
DP_TX0_OUT_DN: C467.1 U2015.34
DP_TX0_OUT_DP: C466.1 U2015.35
DP_TX1_C_DN: C469.2 D2018.1 D2018.10 JDP1.6
DP_TX1_C_DP: C468.2 D2018.2 D2018.9 JDP1.4
DP_TX1_OUT_DN: C469.1 U2015.31
DP_TX1_OUT_DP: C468.1 U2015.32
DP_TX2_C_DN: C471.2 D2019.4 D2019.7 JDP1.9
DP_TX2_C_DP: C470.2 D2019.5 D2019.6 JDP1.7
DP_TX2_OUT_DN: C471.1 U2015.28
DP_TX2_OUT_DP: C470.1 U2015.29
DP_TX3_C_DN: C473.2 D2019.1 D2019.10 JDP1.12
DP_TX3_C_DP: C472.2 D2019.2 D2019.9 JDP1.10
DP_TX3_OUT_DN: C473.1 U2015.25
DP_TX3_OUT_DP: C472.1 U2015.26
DPA_AUX_DN_C: C460.2 U2016.6
DPA_AUX_DP_C: C461.2 U2016.7
DPA_DDC_AUX_SEL: Q6.2 Q6.3 R387.1 U2016.10
DPA_DDC_EN: C599.2 Q6.6 Q7.2 Q7.5 R386.1
DPA_REP_ENI2C: R389.2 R2144.1 U2015.21
DPA_REP_EQ0: R394.2 U2015.39
DPA_REP_EQ1: R397.2 U2015.40
DPA_REP_EQ2: R398.2 U2015.41
DPA_REP_EQ3: R399.2 U2015.42
DPA_REP_FG0: R392.2 U2015.37
DPA_REP_FG1: R393.2 U2015.38
DPA_REP_I2C_DONE: TP96.1(TP-1) U2015.22
DPA_REP_SCL: R2109.1 R2242.2 U2015.19
DPA_REP_SDA: R2108.1 R2243.2 U2015.18
DPA_REP_SW0: R390.2 U2015.2
DPA_REP_SW1: R391.2 U2015.1
DPA_TX0_DN_C: C451.2 U2015.5
DPA_TX0_DP_C: C448.2 U2015.4
DPA_TX1_DN_C: C453.2 U2015.8
DPA_TX1_DP_C: C452.2 U2015.7
DPA_TX2_DN_C: C455.2 U2015.11
DPA_TX2_DP_C: C454.2 U2015.10
DPA_TX3_DN_C: C457.2 U2015.14
DPA_TX3_DP_C: C456.2 U2015.13
DPE_AUX_DN_C: C530.2 U2013.29
DPE_AUX_DP_C: C531.2 U2013.30
DPE_CAD_SNK: R2104.1 U2013.10
DPE_CAD_SRC: TP186.1(TP-1) U2013.8
DPE_CFG0: R492.2 R541.2 U2013.5
DPE_CFG1: R422.2 R454.2 U2013.40
DPE_HPD_SNK: R420.1 U2013.11
DPE_PD: TP97.1(TP-1) U2013.26
DPE_PEQ: R436.2 R518.2 U2013.4
DPE_RST_N: C2687.2 R2280.1 U2013.35
DPE_TX0_DN_C: C479.2 U2013.39
DPE_TX0_DP_C: C480.2 U2013.38
DPE_TX1_DN_C: C481.2 U2013.42
DPE_TX1_DP_C: C477.2 U2013.41
DPE_TX2_DN_C: C484.2 U2013.45
DPE_TX2_DP_C: C478.2 U2013.44
DPE_TX3_DN_C: C482.2 U2013.48
DPE_TX3_DP_C: C483.2 U2013.47
DPF_AUX_DN_C: C582.2 U2014.29
DPF_AUX_DP_C: C583.2 U2014.30
DPF_CAD_SNK: R2105.1 U2014.10
DPF_CAD_SRC: TP187.1(TP-1) U2014.8
DPF_CFG0: R590.2 R595.2 U2014.5
DPF_CFG1: R425.2 R487.2 U2014.40
DPF_HPD_SNK: R423.1 U2014.11
DPF_PD: TP185.1(TP-1) U2014.26
DPF_PEQ: R437.2 R591.2 U2014.4
DPF_RST_N: C2688.2 R2281.1 U2014.35
DPF_TX0_DN_C: C487.2 U2014.39
DPF_TX0_DP_C: C488.2 U2014.38
DPF_TX1_DN_C: C489.2 U2014.42
DPF_TX1_DP_C: C485.2 U2014.41
DPF_TX2_DN_C: C492.2 U2014.45
DPF_TX2_DP_C: C486.2 U2014.44
DPF_TX3_DN_C: C490.2 U2014.48
DPF_TX3_DP_C: C491.2 U2014.47
DPSNK_RBIAS: R2029.2 U2005.Y18
DQMA0: G2.U47 U48.P2
DQMA1: G2.Y48 U48.P13
DQMA2: G2.AG47 U48.D13
DQMA3: G2.AC48 U48.D2
DQMA4: G2.BB51 U2022.D2
DQMA5: G2.AV50 U2022.D13
DQMA6: G2.AM48 U2022.P13
DQMA7: G2.AR49 U2022.P2
DQMB0: G2.C32 U2023.P2
DQMB1: G2.E33 U2023.P13
DQMB2: G2.E44 U2023.D13
DQMB3: G2.G39 U2023.D2
DQMB4: G2.P49 U55.D2
DQMB5: G2.L48 U55.D13
DQMB6: G2.D50 U55.P13
DQMB7: G2.H50 U55.P2
DQMC0: G2.A5 U2025.P2
DQMC1: G2.C8 U2025.P13
DQMC2: G2.J18 U2025.D13
DQMC3: G2.F12 U2025.D2
DQMC4: G2.D29 U2024.D2
DQMC5: G2.E27 U2024.D13
DQMC6: G2.F20 U2024.P13
DQMC7: G2.E26 U2024.P2
DQMD0: G2.AJ1 U2026.P2
DQMD1: G2.AG1 U2026.P13
DQMD2: G2.AA7 U2026.D13
DQMD3: G2.AD5 U2026.D2
DQMD4: G2.D3 U60.D2
DQMD5: G2.H3 U60.D13
DQMD6: G2.U5 U60.P13
DQMD7: G2.M9 U60.P2
DQSA0: G2.R48 U48.R2
DQSA1: G2.V48 U48.R13
DQSA2: G2.AF44 U48.C13
DQSA3: G2.AA48 U48.C2
DQSA4: G2.BB52 U2022.C2
DQSA5: G2.AT50 U2022.C13
DQSA6: G2.AK48 U2022.R13
DQSA7: G2.AR51 U2022.R2
DQSB0: G2.B33 U2023.R2
DQSB1: G2.E35 U2023.R13
DQSB2: G2.G44 U2023.C13
DQSB3: G2.H38 U2023.C2
DQSB4: G2.P50 U55.C2
DQSB5: G2.J48 U55.C13
DQSB6: G2.D51 U55.R13
DQSB7: G2.F51 U55.R2
DQSC0: G2.D5 U2025.R2
DQSC1: G2.D8 U2025.R13
DQSC2: G2.E17 U2025.C13
DQSC3: G2.E12 U2025.C2
DQSC4: G2.E30 U2024.C2
DQSC5: G2.B29 U2024.C13
DQSC6: G2.G21 U2024.R13
DQSC7: G2.E24 U2024.R2
DQSD0: G2.AJ3 U2026.R2
DQSD1: G2.AG2 U2026.R13
DQSD2: G2.AA9 U2026.C13
DQSD3: G2.AF4 U2026.C2
DQSD4: G2.E3 U60.C2
DQSD5: G2.H2 U60.C13
DQSD6: G2.U6 U60.R13
DQSD7: G2.M5 U60.R2
DRAM_CRESET_N: C170.2 R84.1 R86.1 U2.BC14
DRON: PR1506.1 PR1512.1 PR1606.1 PR1611.1 PR1620.1 PU1101.35
EC_ADP_ID_ON_N: PQ101.5 U5.D12
EC_AGND: C241.1 J1.2 R558.2 U5.E10
EC_CK32K/GPJ6: R261.2 R526.2 U5.F2
EC_CLEAR_CMOS: C401.1 Q12.2 R428.2 R523.1
EC_CS_N: RP4.8 U5.A7
EC_FAN_PWM1: JFAN1.3 U5.M6
EC_FAN_PWM2: JFAN2.3 U5.N6
EC_FAN_TACH1: JFAN1.2 R253.2 U5.M11
EC_FAN_TACH2: JFAN2.2 R254.2 U5.M12
EC_I2C_CLK3: PR1314.1 PR3575.1 PR3580.1 PR3584.1 R563.2 R2240.1 R2242.1 R2341.2 U5.E8
EC_I2C_CLK3_R: R2341.1 U19.B3
EC_I2C_CLK5: R238.2 R319.1 U5.K6
EC_I2C_DATA3: PR1312.1 PR3578.1 PR3583.1 PR3587.1 R564.2 R2241.1 R2243.1 R2342.2 U5.D7
EC_I2C_DATA3_R: R2342.1 U19.B2
EC_I2C_DATA5: R244.2 R318.1 U5.J6
EC_INT_N: R370.1 R566.2 U2.R41
EC_INT_N_R: R370.2 U5.E12
EC_KSO16: R267.2 R578.2 U5.K13
EC_KSO17: R324.2 R579.2 U5.J10
EC_ON: PR313.1 PR505.1 PR1415.1 R152.1 R251.2 R256.2
EC_ON_R: R256.1 U5.N7
EC_PECI: C245.2 R252.1 U5.B1
EC_PUMP_FG: JPUMP1.4 R526.1 R2347.1
EC_PUMP_PWM: JPUMP1.3 U5.N5
EC_RST_N: R237.2 U5.M4
EC_SCI_N: D4.2 R173.2 U2.M44
EC_SCI_N_R: D4.1 U5.N4
EC_SCK: RP4.5 U5.B5
EC_SI: RP4.7 U5.B6
EC_SMB_CLK0: JDBUG1.2 PR101.1 PR228.1 R236.2 R2059.1 U5.A10
EC_SMB_CLK1: Q2.1 Q80.6 R166.2 U5.B3 U25.10
EC_SMB_DAT0: JDBUG1.3 PR102.1 PR227.1 R243.2 R2058.1 U5.B10
EC_SMB_DAT1: Q2.4 Q80.3 R165.2 U5.B2 U25.9
EC_SMI_N: D1.2 R182.2 U2.M45
EC_SMI_N_R: D1.1 U5.L2
EC_SO: RP4.6 U5.A6
EC_TEST1: R259.1 U5.E7
EC_THERM_ALERT_N: Q93.6 R337.1 U5.D2
EC_VCORE2/CK32KE: C243.1 U5.G1
EC_WRST_N: C244.1 R246.2 U5.L1
EDP_AUX_C_DN: C425.2 JEDP1.15 R373.1
EDP_AUX_C_DP: C424.2 JEDP1.14 R374.1
EDP_BL_EN: C418.2 D20.2 JEDP1.30 Q5.6 R985.2
EDP_BL_PWM: JEDP1.31 R979.2
EDP_RCOMP: R2.1 U1.D37
EDP_TX0_C_DN: C422.2 JEDP1.11
EDP_TX0_C_DP: C423.2 JEDP1.12
EDP_TX1_C_DN: C421.2 JEDP1.8
EDP_TX1_C_DP: C419.2 JEDP1.9
EDP_UTIL: TP1.1(TP-1) U1.A33
EDP_VDD_EN: PR1310.1 PR1311.2 PR1313.1 PR1410.1 R905.2
EDP_VDD_EN_N: PQ1405.5 PQ1405.6 PR1409.1
FB_1PH_A: PC1149.1 PC1151.2 PR1159.1 PR1194.1 PR1210.2 PU1101.17
FB_3PH_A: PC1120.1 PC1158.2 PR1157.1 PR1162.1 PR1209.2 PU1101.49
FB_3V: PR301.2 PR303.2 PU301.4
FB_5V: PR302.2 PR305.1 PU301.2
FB_REFPLL_AVDD_GPU: C688.1 C689.1 G2.AF42 G2.L29 R20.2
FBA_DEBUG0: G2.Y50 R607.1
FBA_DEBUG1: G2.AR50 R608.1
FBA_VREFC: C889.1 C890.1 R2212.1 R2213.1 R2217.2 U48.J14 U2022.J14
FBA_WCK01: G2.U45 U48.P4
FBA_WCK01_N: G2.U44 U48.P5
FBA_WCK23: G2.AC45 U48.D4
FBA_WCK23_N: G2.AC44 U48.D5
FBA_WCK45: G2.AV47 U2022.D4
FBA_WCK45_N: G2.AV46 U2022.D5
FBA_WCK67: G2.AR45 U2022.P4
FBA_WCK67_N: G2.AR44 U2022.P5
FBA_ZQ_1_B: R2211.1 U48.J13
FBA_ZQ_2_B: R826.1 U2022.J13
FBB_DEBUG0: G2.C35 R610.1
FBB_DEBUG1: G2.B50 R609.1
FBB_VREFC: C909.1 C910.1 R865.1 R866.1 R867.2 U55.J14 U2023.J14
FBB_WCK01: G2.J33 U2023.P4
FBB_WCK01_N: G2.H33 U2023.P5
FBB_WCK23: G2.J39 U2023.D4
FBB_WCK23_N: G2.H39 U2023.D5
FBB_WCK45: G2.L46 U55.D4
FBB_WCK45_N: G2.L45 U55.D5
FBB_WCK67: G2.H47 U55.P4
FBB_WCK67_N: G2.H46 U55.P5
FBB_ZQ_1_B: R868.1 U2023.J13
FBB_ZQ_2_B: R869.1 U55.J13
FBC_DEBUG0: G2.A9 R612.1
FBC_DEBUG1: G2.C24 R611.1
FBC_VREFC: C1354.1 C1355.1 R895.1 R897.2 R2224.1 U2024.J14 U2025.J14
FBC_WCK01: G2.F8 U2025.P4
FBC_WCK01_N: G2.G8 U2025.P5
FBC_WCK23: G2.H12 U2025.D4
FBC_WCK23_N: G2.G12 U2025.D5
FBC_WCK45: G2.J27 U2024.D4
FBC_WCK45_N: G2.H27 U2024.D5
FBC_WCK67: G2.G23 U2024.P4
FBC_WCK67_N: G2.H23 U2024.P5
FBC_ZQ_1_B: R898.1 U2025.J13
FBC_ZQ_2_B: R899.1 U2024.J13
FBD_DEBUG0: G2.AD3 R614.1
FBD_DEBUG1: G2.J3 R613.1
FBD_VREFC: C1374.1 C1375.1 R908.1 R909.1 R910.2 U60.J14 U2026.J14
FBD_WCK01: G2.AJ8 U2026.P4
FBD_WCK01_N: G2.AJ7 U2026.P5
FBD_WCK23: G2.AD8 U2026.D4
FBD_WCK23_N: G2.AD9 U2026.D5
FBD_WCK45: G2.J6 U60.D4
FBD_WCK45_N: G2.J7 U60.D5
FBD_WCK67: G2.P8 U60.P4
FBD_WCK67_N: G2.P7 U60.P5
FBD_ZQ_1_B: R911.1 U2026.J13
FBD_ZQ_2_B: R912.1 U60.J13
FBVDD_VCC_SENSE: PR3421.2 R1025.2
FBVDD_VSS_SENSE: PR3414.2 R1026.2
FBVDDQ_BS1: PR3404.1 PU701.1
FBVDDQ_BS2: PR3409.1 PU701.15
FBVDDQ_COMP: PC196.1 PR3418.1 PR3419.1 PU701.12
FBVDDQ_EN_R: PC704.1 PR3567.1 PU701.3
FBVDDQ_FB: PC196.2 PC3439.2 PR3417.1 PR3420.1 PR3572.2 PR3574.2 PU701.11
FBVDDQ_FBRTN: PC3436.1 PR3412.1 PR3414.1 PU701.10
FBVDDQ_FS: PR3416.2 PU701.9
FBVDDQ_HG1: PQ701.1 PU701.2
FBVDDQ_HG2: PQ702.1 PU701.14
FBVDDQ_LG1: PQ701.8 PU701.19
FBVDDQ_LG2: PQ702.8 PU701.17
FBVDDQ_PH1: PL701.1 PQ701.5 PQ701.6 PQ701.7 PR3405.1
FBVDDQ_PH2: PL711.1 PQ702.5 PQ702.6 PQ702.7 PR3410.1
FBVDDQ_PSI_R: PR3423.1 PR3424.2 PR3589.2 PU701.4
FBVDDQ_PVCC: PC3407.1 PR3401.2 PR3589.1 PU701.18
FBVDDQ_REFIN: PC3435.1 PR415.1 PR3411.2 PR3413.1 PR3415.1 PU701.7
FBVDDQ_SN1: PC3416.1 PR3405.2
FBVDDQ_SN2: PC3433.1 PR3410.2
FBVDDQ_TGR1: PC3409.2 PQ701.2 PU701.20
FBVDDQ_TGR2: PC3425.2 PQ702.2 PU701.16
FBVDDQ_VID_R: PC3424.1 PR3408.2 PU701.5
FBVDDQ_VIDBUF: PR3413.2 PU701.6
FBVDDQ_VREF: PC3434.1 PR3411.1 PU701.8
FP_RST_N: R178.2 TP57.1(TP-1)
FPBACK: Q5.2 R97.2 U2.P43
FRAME_LOCK_N: G2.BG2 Q49.6 R780.2 R2271.2
FRAME_LOCK_N_R: Q49.1 R780.1 R784.1 R894.1
GC6_FB_EN: G2.BB5 R660.2 R2189.1
GC6_FB_EN_LS: D2012.2 Q86.3 R2187.2 R2262.2 U2.BA35
GPU_ALL_PGOOD: D69.2 D70.2 D71.2 R113.1 R1006.1 R1007.2 U2.W39
GPU_B+: PC901.1 PC902.1 PC903.1 PC904.1 PC905.1 PC908.1 PC909.1 PC917.1 PC918.1 PC919.1 PC920.1 PC921.1 PC922.1 PC923.1 PC934.1 PC936.1 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1032.1 PC1033.1 PC1034.1 PC1035.1 PC1036.1 PC3548.1 PC3550.1 PC3552.1 PC3554.1 PC3555.1 PC3557.1 PC3560.1 PC3561.1 PR818.2 PR901.1 PU901.20 PU901.21 PU901.22 PU901.23 PU901.24 PU901.25 PU902.20 PU902.21 PU902.22 PU902.23 PU902.24 PU902.25 PU1001.20 PU1001.21 PU1001.22 PU1001.23 PU1001.24 PU1001.25 PU1002.20 PU1002.21 PU1002.22 PU1002.23 PU1002.24 PU1002.25 PU1606.20 PU1606.21 PU1606.22 PU1606.23 PU1606.24 PU1606.25
GPU_COMP: PC1430.1 PC1431.1 PU1605.30
GPU_CSCOMP: PC803.2 PC3576.2 PH1108.2 PR1446.1 PR1447.2 PU1605.23
GPU_CSP1: PC1426.1 PR1445.1 PR3566.1 PU1605.20
GPU_CSP2: PC1425.1 PR1442.1 PR3565.1 PU1605.19
GPU_CSP3: PC1424.1 PR1439.1 PR3564.1 PU1605.18
GPU_CSP4: PC1423.1 PR1436.1 PR3563.1 PU1605.17
GPU_CSP5: PC1422.1 PR1433.1 PR3562.1 PU1605.16
GPU_CSSUM: PC803.1 PC3576.1 PR1449.2 PR1450.1 PR1451.1 PR1452.1 PR1453.1 PR1457.1 PU1605.22
GPU_DIFF: PR1461.2 PR1462.2 PU1605.28
GPU_DISB: PR1459.1 PU1605.26
GPU_DPA_AUX_DN_SDA: C460.1 G2.BH11 R402.1 R919.1
GPU_DPA_AUX_DP_SCL: C461.1 G2.BG11 R403.1 R2208.1
GPU_DPA_HPD_R: G2.BG4 Q74.3 R993.2
GPU_DPA_SCL: Q7.4 R403.2 U2016.5
GPU_DPA_SDA: Q7.1 R402.2 U2016.4
GPU_DPA_TX0_DN: C451.1 G2.BF24
GPU_DPA_TX0_DP: C448.1 G2.BG24
GPU_DPA_TX1_DN: C453.1 G2.BF23
GPU_DPA_TX1_DP: C452.1 G2.BE23
GPU_DPA_TX2_DN: C455.1 G2.BG23
GPU_DPA_TX2_DP: C454.1 G2.BH23
GPU_DPA_TX3_DN: C457.1 G2.BF21
GPU_DPA_TX3_DP: C456.1 G2.BG21
GPU_DPE_AUX_DN_SDA: C530.1 G2.BL8 R925.1
GPU_DPE_AUX_DP_SCL: C531.1 G2.BK8 R924.1
GPU_DPE_HPD: R940.1 R988.1 U2013.9
GPU_DPE_HPD_R: G2.BE3 Q76.6 R987.2
GPU_DPE_TX0_DN: C479.1 G2.BG17
GPU_DPE_TX0_DP: C480.1 G2.BH17
GPU_DPE_TX1_DN: C481.1 G2.BF15
GPU_DPE_TX1_DP: C477.1 G2.BG15
GPU_DPE_TX2_DN: C484.1 G2.BF14
GPU_DPE_TX2_DP: C478.1 G2.BE14
GPU_DPE_TX3_DN: C482.1 G2.BG14
GPU_DPE_TX3_DP: C483.1 G2.BH14
GPU_DPF_AUX_DN: C582.1 G2.BM9 R927.1
GPU_DPF_AUX_DP: C583.1 G2.BM8 R926.1
GPU_DPF_HPD: R942.1 R991.1 U2014.9
GPU_DPF_HPD_R: G2.BD5 Q76.3 R990.2
GPU_DPF_TX0_DN: C487.1 G2.BK14
GPU_DPF_TX0_DP: C488.1 G2.BL14
GPU_DPF_TX1_DN: C489.1 G2.BL12
GPU_DPF_TX1_DP: C485.1 G2.BK12
GPU_DPF_TX2_DN: C492.1 G2.BM11
GPU_DPF_TX2_DP: C486.1 G2.BM12
GPU_DPF_TX3_DN: C490.1 G2.BK11
GPU_DPF_TX3_DP: C491.1 G2.BL11
GPU_DRON: PR906.1 PR922.1 PR1007.1 PR1024.1 PR3533.1 PU1605.12
GPU_EDP_AUX_DN: C425.1 G2.BF11 R920.1
GPU_EDP_AUX_DP: C424.1 G2.BE11 R921.1
GPU_EDP_BL_EN_LS: G2.BB1 R2307.1 U2029.1 U2029.2
GPU_EDP_BL_EN_R: R985.1 R2304.2 U2029.4
GPU_EDP_BL_PWM_LS: G2.BD7 R2305.1 U2027.1 U2027.2
GPU_EDP_BL_PWM_R: R979.1 R2300.2 U2027.4
GPU_EDP_HPD: JEDP1.25 R998.1
GPU_EDP_HPD_R: G2.BH1 Q75.3 R995.2
GPU_EDP_TX0_DN: C422.1 G2.BM17
GPU_EDP_TX0_DP: C423.1 G2.BM18
GPU_EDP_TX1_DN: C421.1 G2.BK17
GPU_EDP_TX1_DP: C419.1 G2.BL17
GPU_EDP_VDD_EN_LS: G2.BH3 R781.1 R2306.1 U2028.1 U2028.2
GPU_EDP_VDD_EN_R: R905.1 R2302.2 U2028.4
GPU_EDPC_OUTPUT_CAP: G2.BA3 PR3560.1
GPU_EVENT_N: D52.1 R112.1 R973.2 U2.BB36
GPU_EVENT_N_R: D52.2 G2.BD1 R973.1 R974.2
GPU_FB: PC1429.1 PC1430.2 PR1462.1 PR1463.2 PR3571.2 PR3585.2 PU1605.29
GPU_FSW: PR1460.1 PU1605.27
GPU_HDMI_CLK_DN: C2410.1 U2019.14
GPU_HDMI_CLK_DP: C2164.1 U2019.13
GPU_HDMI_DATA0_DN: C2414.1 U2019.11
GPU_HDMI_DATA0_DP: C2163.1 U2019.10
GPU_HDMI_DATA1_DN: C2412.1 U2019.8
GPU_HDMI_DATA1_DP: C2413.1 U2019.7
GPU_HDMI_DATA2_DN: C2411.1 U2019.5
GPU_HDMI_DATA2_DP: C2165.1 U2019.4
GPU_HDMI_DDC_CLK: G2.BK9 Q41.4 R2146.2
GPU_HDMI_DDC_DATA: G2.BL9 Q41.1 R2145.2
GPU_HDMI_HPD: D29.2 JHDMI1.19 R451.1 R568.1 R1018.1
GPU_HDMI_HPD_R: G2.BA4 Q74.6 R1016.2
GPU_ILIM: PR1447.1 PU1605.24
GPU_IOUT: PC3590.2 PR1458.1 PU1605.25
GPU_OVERT: Q87.5 Q87.6 R798.2
GPU_OVERT_N: G2.BG5 PR25.2 Q87.2 R796.2 R797.2
GPU_PEX_RST_HOLD_N: G2.BG3 R1000.2 U62.1
GPU_PSI_R: PR3528.2 PU1605.37
GPU_PWM1: PR992.2 PR1420.1 PU1605.11
GPU_PWM2: PR908.2 PR1419.1 PU1605.10
GPU_PWM3: PR1418.1 PR3535.2 PU1605.9
GPU_PWM4: PR1025.2 PR1417.1 PU1605.8
GPU_PWM5: PR1005.2 PR1416.1 PU1605.7
GPU_PWM6: PR3472.1 PU1605.6
GPU_PWM7: PR3471.1 PU1605.5
GPU_PWM8: PR3470.1 PU1605.4
GPU_REFADJ: PR3466.2 PU1605.40
GPU_SCL_R: PR1469.2 PU1605.35
GPU_SDA_R: PR1470.2 PU1605.34
GPU_SWN1: PL902.1 PR912.1 PR1445.2 PR1457.2 PR3558.1 PU902.12 PU902.13 PU902.14 PU902.15 PU902.16 PU902.17 PU902.18
GPU_SWN2: PL901.1 PR905.1 PR1442.2 PR1450.2 PU901.12 PU901.13 PU901.14 PU901.15 PU901.16 PU901.17 PU901.18
GPU_SWN3: PL1810.1 PR1439.2 PR1451.2 PR3531.1 PU1606.12 PU1606.13 PU1606.14 PU1606.15 PU1606.16 PU1606.17 PU1606.18
GPU_SWN4: PL1811.1 PR1011.1 PR1436.2 PR1452.2 PU1002.12 PU1002.13 PU1002.14 PU1002.15 PU1002.16 PU1002.17 PU1002.18
GPU_SWN5: PL1001.1 PR1004.1 PR1433.2 PR1453.2 PU1001.12 PU1001.13 PU1001.14 PU1001.15 PU1001.16 PU1001.17 PU1001.18
GPU_TERMP: G2.BL44 R606.1
GPU_VCC_R: PC1432.2 PR1471.1 PU1605.33
GPU_VRAM: PC809.1 PR818.1 PU1605.3
GPU_VREF: PC3543.1 PR3467.1 PU1605.2
GPU_VREFIN: PC3572.1 PR3542.1 PR3547.1 PU1605.1
GPU_VSN: PC3575.2 PR1472.1 PU1605.32
GPU_VSP: PC3575.1 PR1473.1 PU1605.31
GRM2103_EN: PC622.1 PR623.2 PU605.13
GRM2103_FB: PC601.1 PR621.1 PR622.2 PU605.30
GRM2103_OUT: PC623.1 PC624.1 PC625.1 PC681.1 PJ611.2 PR605.2 PR622.1 PU605.22 PU605.23 PU605.24 PU605.25 PU605.26 PU605.27 PU605.28 PU605.29
GRM2103_PVIN: PC675.1 PC679.1 PC680.1 PJ610.1 PU605.5 PU605.6 PU605.7 PU605.8 PU605.9 PU605.10
GRM2103_VIN: PC626.2 PR626.2 PU605.11
GSPI0_MOSI: R168.1 U2.BD28
GSPI1_MOSI: R171.1 R506.1 U2.AT29
H_A20GATE: R180.1 R239.1 U2.AW17
H_A20GATE_R: R239.2 U5.F1
H_CATERR_N: TP4.1(TP-1) U1.BM30
H_PECI: R174.2 R252.2 U1.BT34
H_PM_DOWN: R18.1 R177.1 U2.AH2
H_PM_DOWN_R: R18.2 U1.BP31
H_PM_SYNC: R175.2 U1.BM34
H_PM_SYNC_R: R175.1 U2.AJ4
H_PROCHOT_N: C633.2 Q53.6 R11.1 R13.2 R556.1 R580.1
H_PROCHOT_N_R: R13.1 U1.BR30
H_PWRGD: C33.1 R30.2 U1.BT31 U2.AM3
H_SKTOCC_N: TP115.1(TP-1) U1.BR33
H_THRMTRIP_N: C1329.1 C2683.1 Q87.3 Q98.6 R15.1 R287.2 U1.J31
H_VCCST_PWRGD: R14.1 R17.1 R64.2 R842.1 U58.4
H_VCCST_PWRGD_R: R17.2 U1.H13
HDA_BCLK: C339.1 R131.2 U7.13
HDA_BCLK_R: R131.1 U2.BA9
HDA_I2S_SEL: R289.1 TP94.1(TP-1) U7.6
HDA_JD1: TP95.1(TP-1) U7.8
HDA_JD2: C332.2 R310.1 R311.2 R312.1 U7.9
HDA_RST_N: R135.2 U7.15
HDA_RST_N_R: R135.1 U2.BD8
HDA_SDIN: R307.2 U2.BE7
HDA_SDIN_R: R307.1 U7.16
HDA_SDOUT: R134.2 R167.1 U7.17
HDA_SDOUT_R: R134.1 R2286.2 U2.BB7
HDA_SPKR: R164.1 R313.2 U2.BD26
HDA_SYNC: R132.2 U7.14
HDA_SYNC_R: R132.1 U2.BD9
HDMI_CEC: JDP1.14 R807.1
HDMI_CLK_DN: CM6.3 R453.1 U2019.25
HDMI_CLK_DP: CM6.2 R452.1 U2019.26
HDMI_CLK_R_DN: CM6.4 D26.1 D26.10 R453.2 R2279.1
HDMI_CLK_R_DP: CM6.1 D26.2 D26.9 R452.2 R2278.1
HDMI_CLK_RS_DN: JHDMI1.12 R2279.2
HDMI_CLK_RS_DP: JHDMI1.10 R2278.2
HDMI_DATA0_DN: CM3.3 R446.1 U2019.28
HDMI_DATA0_DP: CM3.2 R445.1 U2019.29
HDMI_DATA0_R_DN: CM3.4 D26.4 D26.7 R446.2 R2273.1
HDMI_DATA0_R_DP: CM3.1 D26.5 D26.6 R445.2 R2272.1
HDMI_DATA0_RS_DN: JHDMI1.9 R2273.2
HDMI_DATA0_RS_DP: JHDMI1.7 R2272.2
HDMI_DATA1_DN: CM4.3 R448.1 U2019.31
HDMI_DATA1_DP: CM4.2 R447.1 U2019.32
HDMI_DATA1_R_DN: CM4.4 D30.1 D30.10 R448.2 R2275.1
HDMI_DATA1_R_DP: CM4.1 D30.2 D30.9 R447.2 R2274.1
HDMI_DATA1_RS_DN: JHDMI1.6 R2275.2
HDMI_DATA1_RS_DP: JHDMI1.4 R2274.2
HDMI_DATA2_DN: CM5.3 R450.1 U2019.34
HDMI_DATA2_DP: CM5.2 R449.1 U2019.35
HDMI_DATA2_R_DN: CM5.4 D30.4 D30.7 R450.2 R2277.1
HDMI_DATA2_R_DP: CM5.1 D30.5 D30.6 R449.2 R2276.1
HDMI_DATA2_RS_DN: JHDMI1.3 R2277.2
HDMI_DATA2_RS_DP: JHDMI1.1 R2276.2
HDMI_DDC_CLK: Q41.3 R443.2 R862.1
HDMI_DDC_CLK_R: D27.2 JHDMI1.15 R443.1
HDMI_DDC_DATA: Q41.6 R444.2 R565.1
HDMI_DDC_DATA_R: D28.2 JHDMI1.16 R444.1
HDMI_DONGLE_DETECT: JDP1.13 Q6.5 R408.1
HDMI_REP_A1_VTH1: R2236.2 U2019.16
HDMI_REP_A4_VTH0: R2237.2 U2019.17
HDMI_REP_ENI2C: R2122.2 R2143.1 U2019.21
HDMI_REP_EQ0: R2141.2 U2019.39
HDMI_REP_EQ1: R2142.2 U2019.40
HDMI_REP_EQ2: R2125.2 U2019.41
HDMI_REP_EQ3: R2126.2 U2019.42
HDMI_REP_FG0: R2140.2 U2019.37
HDMI_REP_FG1: R2139.2 U2019.38
HDMI_REP_I2C_DONE_A0: R2239.2 U2019.22
HDMI_REP_PEN: Q106.2 U2019.20
HDMI_REP_SCL: R2131.1 R2240.2 U2019.19
HDMI_REP_SDA: R2130.1 R2241.2 U2019.18
HDMI_REP_SW0: R2123.2 U2019.2
HDMI_REP_SW1: R2138.2 U2019.1
HDMI_REP_VOD1: R2238.2 U2019.23
HP_JD: JIO1.61 R311.1
HP_OUTL: JIO1.71 U7.32
HP_OUTR: JIO1.72 U7.33
I2CB_SCL: G2.BG8 R2298.1
I2CB_SDA: G2.BF8 R2299.1
I2CC_SCL: PR1469.1 PU5.6 R2169.2 R2296.1
I2CC_SCL_R: G2.BG9 R2169.1
I2CC_SDA: PR23.2 PR1470.1 PU5.7 R2170.2 R2297.1
I2CC_SDA_R: G2.BH9 R2170.1
IFPAB_RSET: G2.BD23 R1015.1
IFPCD_RSET: G2.BD20 R922.1
IFPEF_RSET: G2.BD17 R923.1
ILIM_1PH_A: PR1211.1 PU1101.20
ILIM_3PH_A: PR1208.1 PU1101.46
IMON_3PH_A: PC1160.2 PR1152.2 PU1101.1
KBRST_N: D2.2 R181.2 U2.AT17
KBRST_N_R: D2.1 U5.H4
LAN_CK_REQ_N: Q35.1 R277.2 U6.4
LAN_LX: L4.1 U6.40
LAN_PPS: TP90.1(TP-1) U6.24
LAN_RBIAS: R280.1 U6.10
LAN_RST_N: R274.2 U6.2
LAN_WAKE_N: R276.1 U5.B7
LAN_WAKE_N_R: R275.2 R276.2 U6.3
LC_CK32K/GPJ6: R511.2 U19.F2
LC_CS_N: U16.1 U19.A7
LC_GPA4: R879.1 U19.K6
LC_GPA5: R880.1 U19.J6
LC_GPB0: R814.1 U19.A4
LC_GPB3: R825.1 U19.B4
LC_HOLD_N: R788.1 U16.7
LC_I2C_CLK: R524.2 TP153.1 U19.B1
LC_I2C_DATA: R513.2 TP154.1 U19.C1
LC_INT0_N: R567.2 R876.2 U2.R39
LC_INT0_N_R: R876.1 U19.D2
LC_INT1_N: R620.2 U19.F1
LC_KSI6: TP145.1 U19.H13
LC_KSI7: TP146.1 U19.G9
LC_KSO16: R578.1 U19.K13
LC_KSO17: R579.1 U19.J10
LC_SCK: R431.1 U19.B5
LC_SCK_R: R431.2 U16.6
LC_SI: R432.1 U19.B6
LC_SI_R: R432.2 U16.5
LC_SO: R434.2 U19.A6
LC_SO_R: R434.1 U16.2
LC_TEST1: R407.1 R793.1 U19.E7
LC_VCORE2/CK32KE: C249.1 U19.G1
LC_WP_N: R783.1 U16.3
LC_WRST_N: C1368.1 R525.2 U19.L1
LED_GPB6: TP142.1(TP-1) U19.H4
LED_GPC0: TP137.1(TP-1) U19.D1
LED_GPC6: TP139.1(TP-1) U19.E1
LED_GPH0: TP134.1(TP-1) U19.D8
LED_GPH3: TP135.1(TP-1) U19.A9
LED_GPH4: TP136.1(TP-1) U19.B8
LED_SPK_PWM_CB1: JKB1.19 JSPBL1.1
LED_SPK_PWM_CB2: JKB1.20 JSPBL1.2
LED_SPK_PWM_CB3: JKB1.21 JSPBL1.3
LED_SPK_PWM_CB4: JKB1.22 JSPBL1.4
LED_SPK_PWM_CB5: JKB1.23 JSPBL1.5
LED_SPK_PWM_CB6: JKB1.24 JSPBL1.6
LED_SPK_PWM_CB7: JKB1.25 JSPBL1.7
LED_SPK_PWM_CB8: JKB1.26 JSPBL1.8
LED_SPK_PWM_CB9: JKB1.27 JSPBL1.9
LED_TP_PWM_CA1: JKB1.7 JTPBL1.1
LED_TP_PWM_CA2: JKB1.8 JTPBL1.2
LED_TP_PWM_CA3: JKB1.9 JTPBL1.3
LED_TP_PWM_CA4: JKB1.10 JTPBL1.4
LED_TP_PWM_CA5: JKB1.11 JTPBL1.5
LED_TP_PWM_CA6: JKB1.12 JTPBL1.6
LED_TP_PWM_CA7: JKB1.13 JTPBL1.7
LED_TP_PWM_CA8: JKB1.14 JTPBL1.8
LED_TP_PWM_CA9: JKB1.15 JTPBL1.9
LG_3V: PQ301.8 PU301.11
LG_5V: PQ302.8 PU301.15
LID_30_N: D20.1 R368.2 R369.2 U51.2
LPC_AD0_ESPI_IO0: U2.AT22 U5.K1
LPC_AD1_ESPI_IO1: U2.AV22 U5.J2
LPC_AD2_ESPI_IO2: U2.AT19 U5.J1
LPC_AD3_ESPI_IO3: U2.BD16 U5.H2
LPC_FRAME_N_ESPI_CS_N: U2.BE16 U5.H1
LPC_PD_N_ESPI_RST_N: R240.1 U2.BC18
LPC_PD_N_R: R240.2 U5.M1
LX_1.2V: PL401.1 PQ401.5 PQ401.6 PQ401.7 PR403.1
M_A_A0: JDIMM1.144 JDIMM2.144 U1.AH3
M_A_A1: JDIMM1.133 JDIMM2.133 U1.AP4
M_A_A2: JDIMM1.132 JDIMM2.132 U1.AN4
M_A_A3: JDIMM1.131 JDIMM2.131 U1.AP5
M_A_A4: JDIMM1.128 JDIMM2.128 U1.AP2
M_A_A5: JDIMM1.126 JDIMM2.126 U1.AP1
M_A_A6: JDIMM1.127 JDIMM2.127 U1.AP3
M_A_A7: JDIMM1.122 JDIMM2.122 U1.AN1
M_A_A8: JDIMM1.125 JDIMM2.125 U1.AN3
M_A_A9: JDIMM1.121 JDIMM2.121 U1.AT4
M_A_A10_AP: JDIMM1.146 JDIMM2.146 U1.AH2
M_A_A11: JDIMM1.120 JDIMM2.120 U1.AN2
M_A_A12: JDIMM1.119 JDIMM2.119 U1.AU4
M_A_A13: JDIMM1.158 JDIMM2.158 U1.AE3
M_A_A14_WE_N: JDIMM1.151 JDIMM2.151 U1.AG4
M_A_A15_CAS_N: JDIMM1.156 JDIMM2.156 U1.AD1
M_A_A16_RAS_N: JDIMM1.152 JDIMM2.152 U1.AH4
M_A_ACT_N: JDIMM1.114 JDIMM2.114 U1.AU3
M_A_BA0: JDIMM1.150 JDIMM2.150 U1.AH5
M_A_BA1: JDIMM1.145 JDIMM2.145 U1.AH1
M_A_BG0: JDIMM1.115 JDIMM2.115 U1.AU1
M_A_BG1: JDIMM1.113 JDIMM2.113 U1.AU2
M_A_DIM0_CK_DDR0_DN: JDIMM1.139 U1.AG2
M_A_DIM0_CK_DDR0_DP: JDIMM1.137 U1.AG1
M_A_DIM0_CK_DDR1_DN: JDIMM1.140 U1.AK1
M_A_DIM0_CK_DDR1_DP: JDIMM1.138 U1.AK2
M_A_DIM0_CKE0: JDIMM1.109 U1.AT1
M_A_DIM0_CKE1: JDIMM1.110 U1.AT2
M_A_DIM0_CS0_N: JDIMM1.149 U1.AD5
M_A_DIM0_CS1_N: JDIMM1.157 U1.AE2
M_A_DIM0_ODT0: JDIMM1.155 U1.AD3
M_A_DIM0_ODT1: JDIMM1.161 U1.AE4
M_A_DIM1_CK_DDR2_DN: JDIMM2.139 U1.AK3
M_A_DIM1_CK_DDR2_DP: JDIMM2.137 U1.AL3
M_A_DIM1_CK_DDR3_DN: JDIMM2.140 U1.AL1
M_A_DIM1_CK_DDR3_DP: JDIMM2.138 U1.AL2
M_A_DIM1_CKE2: JDIMM2.109 U1.AT3
M_A_DIM1_CKE3: JDIMM2.110 U1.AT5
M_A_DIM1_CS2_N: JDIMM2.149 U1.AD2
M_A_DIM1_CS3_N: JDIMM2.157 U1.AE5
M_A_DIM1_ODT2: JDIMM2.155 U1.AE1
M_A_DIM1_ODT3: JDIMM2.161 U1.AD4
M_A_DQ0: JDIMM1.7 JDIMM2.7 U1.BR6
M_A_DQ1: JDIMM1.4 JDIMM2.4 U1.BT6
M_A_DQ2: JDIMM1.20 JDIMM2.20 U1.BP3
M_A_DQ3: JDIMM1.21 JDIMM2.21 U1.BR3
M_A_DQ4: JDIMM1.3 JDIMM2.3 U1.BN5
M_A_DQ5: JDIMM1.8 JDIMM2.8 U1.BP6
M_A_DQ6: JDIMM1.16 JDIMM2.16 U1.BP2
M_A_DQ7: JDIMM1.17 JDIMM2.17 U1.BN3
M_A_DQ8: JDIMM1.28 JDIMM2.28 U1.BL4
M_A_DQ9: JDIMM1.24 JDIMM2.24 U1.BL5
M_A_DQ10: JDIMM1.38 JDIMM2.38 U1.BL2
M_A_DQ11: JDIMM1.42 JDIMM2.42 U1.BM1
M_A_DQ12: JDIMM1.29 JDIMM2.29 U1.BK4
M_A_DQ13: JDIMM1.25 JDIMM2.25 U1.BK5
M_A_DQ14: JDIMM1.41 JDIMM2.41 U1.BK1
M_A_DQ15: JDIMM1.37 JDIMM2.37 U1.BK2
M_A_DQ16: JDIMM1.50 JDIMM2.50 U1.BG4
M_A_DQ17: JDIMM1.46 JDIMM2.46 U1.BG5
M_A_DQ18: JDIMM1.59 JDIMM2.59 U1.BF4
M_A_DQ19: JDIMM1.58 JDIMM2.58 U1.BF5
M_A_DQ20: JDIMM1.49 JDIMM2.49 U1.BG2
M_A_DQ21: JDIMM1.45 JDIMM2.45 U1.BG1
M_A_DQ22: JDIMM1.62 JDIMM2.62 U1.BF1
M_A_DQ23: JDIMM1.63 JDIMM2.63 U1.BF2
M_A_DQ24: JDIMM1.66 JDIMM2.66 U1.BD2
M_A_DQ25: JDIMM1.70 JDIMM2.70 U1.BD1
M_A_DQ26: JDIMM1.80 JDIMM2.80 U1.BC4
M_A_DQ27: JDIMM1.79 JDIMM2.79 U1.BC5
M_A_DQ28: JDIMM1.71 JDIMM2.71 U1.BD5
M_A_DQ29: JDIMM1.67 JDIMM2.67 U1.BD4
M_A_DQ30: JDIMM1.83 JDIMM2.83 U1.BC1
M_A_DQ31: JDIMM1.84 JDIMM2.84 U1.BC2
M_A_DQ32: JDIMM1.174 JDIMM2.174 U1.AB1
M_A_DQ33: JDIMM1.169 JDIMM2.169 U1.AB2
M_A_DQ34: JDIMM1.183 JDIMM2.183 U1.AA4
M_A_DQ35: JDIMM1.182 JDIMM2.182 U1.AA5
M_A_DQ36: JDIMM1.170 JDIMM2.170 U1.AB5
M_A_DQ37: JDIMM1.173 JDIMM2.173 U1.AB4
M_A_DQ38: JDIMM1.187 JDIMM2.187 U1.AA2
M_A_DQ39: JDIMM1.186 JDIMM2.186 U1.AA1
M_A_DQ40: JDIMM1.190 JDIMM2.190 U1.V5
M_A_DQ41: JDIMM1.191 JDIMM2.191 U1.V2
M_A_DQ42: JDIMM1.207 JDIMM2.207 U1.U1
M_A_DQ43: JDIMM1.208 JDIMM2.208 U1.U2
M_A_DQ44: JDIMM1.195 JDIMM2.195 U1.V1
M_A_DQ45: JDIMM1.194 JDIMM2.194 U1.V4
M_A_DQ46: JDIMM1.203 JDIMM2.203 U1.U5
M_A_DQ47: JDIMM1.204 JDIMM2.204 U1.U4
M_A_DQ48: JDIMM1.215 JDIMM2.215 U1.R2
M_A_DQ49: JDIMM1.216 JDIMM2.216 U1.P5
M_A_DQ50: JDIMM1.211 JDIMM2.211 U1.R4
M_A_DQ51: JDIMM1.225 JDIMM2.225 U1.P4
M_A_DQ52: JDIMM1.212 JDIMM2.212 U1.R5
M_A_DQ53: JDIMM1.229 JDIMM2.229 U1.P2
M_A_DQ54: JDIMM1.224 JDIMM2.224 U1.R1
M_A_DQ55: JDIMM1.228 JDIMM2.228 U1.P1
M_A_DQ56: JDIMM1.233 JDIMM2.233 U1.M4
M_A_DQ57: JDIMM1.232 JDIMM2.232 U1.M1
M_A_DQ58: JDIMM1.249 JDIMM2.249 U1.L4
M_A_DQ59: JDIMM1.246 JDIMM2.246 U1.L2
M_A_DQ60: JDIMM1.245 JDIMM2.245 U1.M5
M_A_DQ61: JDIMM1.236 JDIMM2.236 U1.M2
M_A_DQ62: JDIMM1.250 JDIMM2.250 U1.L5
M_A_DQ63: JDIMM1.237 JDIMM2.237 U1.L1
M_A_DQS_DN0: JDIMM1.11 JDIMM2.11 U1.BR5
M_A_DQS_DN1: JDIMM1.32 JDIMM2.32 U1.BL3
M_A_DQS_DN2: JDIMM1.53 JDIMM2.53 U1.BG3
M_A_DQS_DN3: JDIMM1.74 JDIMM2.74 U1.BD3
M_A_DQS_DN4: JDIMM1.177 JDIMM2.177 U1.AA3
M_A_DQS_DN5: JDIMM1.198 JDIMM2.198 U1.U3
M_A_DQS_DN6: JDIMM1.219 JDIMM2.219 U1.P3
M_A_DQS_DN7: JDIMM1.240 JDIMM2.240 U1.L3
M_A_DQS_DP0: JDIMM1.13 JDIMM2.13 U1.BP5
M_A_DQS_DP1: JDIMM1.34 JDIMM2.34 U1.BK3
M_A_DQS_DP2: JDIMM1.55 JDIMM2.55 U1.BF3
M_A_DQS_DP3: JDIMM1.76 JDIMM2.76 U1.BC3
M_A_DQS_DP4: JDIMM1.179 JDIMM2.179 U1.AB3
M_A_DQS_DP5: JDIMM1.200 JDIMM2.200 U1.V3
M_A_DQS_DP6: JDIMM1.221 JDIMM2.221 U1.R3
M_A_DQS_DP7: JDIMM1.242 JDIMM2.242 U1.M3
M_B_A0: JDIMM3.144 JDIMM4.144 U1.AJ9
M_B_A1: JDIMM3.133 JDIMM4.133 U1.AK6
M_B_A2: JDIMM3.132 JDIMM4.132 U1.AK5
M_B_A3: JDIMM3.131 JDIMM4.131 U1.AL5
M_B_A4: JDIMM3.128 JDIMM4.128 U1.AL6
M_B_A5: JDIMM3.126 JDIMM4.126 U1.AM6
M_B_A6: JDIMM3.127 JDIMM4.127 U1.AN7
M_B_A7: JDIMM3.122 JDIMM4.122 U1.AN10
M_B_A8: JDIMM3.125 JDIMM4.125 U1.AN8
M_B_A9: JDIMM3.121 JDIMM4.121 U1.AR11
M_B_A10_AP: JDIMM3.146 JDIMM4.146 U1.AH7
M_B_A11: JDIMM3.120 JDIMM4.120 U1.AN11
M_B_A12: JDIMM3.119 JDIMM4.119 U1.AR10
M_B_A13: JDIMM3.158 JDIMM4.158 U1.AF9
M_B_A14_WE_N: JDIMM3.151 JDIMM4.151 U1.AH11
M_B_A15_CAS_N: JDIMM3.156 JDIMM4.156 U1.AF8
M_B_A16_RAS_N: JDIMM3.152 JDIMM4.152 U1.AH10
M_B_ACT_N: JDIMM3.114 JDIMM4.114 U1.AT9
M_B_BA0: JDIMM3.150 JDIMM4.150 U1.AH8
M_B_BA1: JDIMM3.145 JDIMM4.145 U1.AH9
M_B_BG0: JDIMM3.115 JDIMM4.115 U1.AR9
M_B_BG1: JDIMM3.113 JDIMM4.113 U1.AR7
M_B_DIM0_CK_DDR0_DN: JDIMM3.139 U1.AN9
M_B_DIM0_CK_DDR0_DP: JDIMM3.137 U1.AM9
M_B_DIM0_CK_DDR1_DN: JDIMM3.140 U1.AM8
M_B_DIM0_CK_DDR1_DP: JDIMM3.138 U1.AM7
M_B_DIM0_CKE0: JDIMM3.109 U1.AT8
M_B_DIM0_CKE1: JDIMM3.110 U1.AT10
M_B_DIM0_CS0_N: JDIMM3.149 U1.AF11
M_B_DIM0_CS1_N: JDIMM3.157 U1.AE7
M_B_DIM0_ODT0: JDIMM3.155 U1.AF7
M_B_DIM0_ODT1: JDIMM3.161 U1.AE8
M_B_DIM1_CK_DDR2_DN: JDIMM4.139 U1.AM10
M_B_DIM1_CK_DDR2_DP: JDIMM4.137 U1.AM11
M_B_DIM1_CK_DDR3_DN: JDIMM4.140 U1.AJ11
M_B_DIM1_CK_DDR3_DP: JDIMM4.138 U1.AJ10
M_B_DIM1_CKE2: JDIMM4.109 U1.AT7
M_B_DIM1_CKE3: JDIMM4.110 U1.AT11
M_B_DIM1_CS2_N: JDIMM4.149 U1.AF10
M_B_DIM1_CS3_N: JDIMM4.157 U1.AE10
M_B_DIM1_ODT2: JDIMM4.155 U1.AE9
M_B_DIM1_ODT3: JDIMM4.161 U1.AE11
M_B_DQ0: JDIMM3.7 JDIMM4.7 U1.BT11
M_B_DQ1: JDIMM3.16 JDIMM4.16 U1.BR11
M_B_DQ2: JDIMM3.4 JDIMM4.4 U1.BT8
M_B_DQ3: JDIMM3.17 JDIMM4.17 U1.BR8
M_B_DQ4: JDIMM3.8 JDIMM4.8 U1.BP11
M_B_DQ5: JDIMM3.3 JDIMM4.3 U1.BN11
M_B_DQ6: JDIMM3.20 JDIMM4.20 U1.BP8
M_B_DQ7: JDIMM3.21 JDIMM4.21 U1.BN8
M_B_DQ8: JDIMM3.25 JDIMM4.25 U1.BL12
M_B_DQ9: JDIMM3.24 JDIMM4.24 U1.BL11
M_B_DQ10: JDIMM3.28 JDIMM4.28 U1.BL8
M_B_DQ11: JDIMM3.38 JDIMM4.38 U1.BJ8
M_B_DQ12: JDIMM3.37 JDIMM4.37 U1.BJ11
M_B_DQ13: JDIMM3.41 JDIMM4.41 U1.BJ10
M_B_DQ14: JDIMM3.29 JDIMM4.29 U1.BL7
M_B_DQ15: JDIMM3.42 JDIMM4.42 U1.BJ7
M_B_DQ16: JDIMM3.45 JDIMM4.45 U1.BG11
M_B_DQ17: JDIMM3.46 JDIMM4.46 U1.BG10
M_B_DQ18: JDIMM3.50 JDIMM4.50 U1.BG8
M_B_DQ19: JDIMM3.58 JDIMM4.58 U1.BF8
M_B_DQ20: JDIMM3.62 JDIMM4.62 U1.BF11
M_B_DQ21: JDIMM3.63 JDIMM4.63 U1.BF10
M_B_DQ22: JDIMM3.49 JDIMM4.49 U1.BG7
M_B_DQ23: JDIMM3.59 JDIMM4.59 U1.BF7
M_B_DQ24: JDIMM3.83 JDIMM4.83 U1.BB11
M_B_DQ25: JDIMM3.79 JDIMM4.79 U1.BC11
M_B_DQ26: JDIMM3.80 JDIMM4.80 U1.BB8
M_B_DQ27: JDIMM3.67 JDIMM4.67 U1.BC8
M_B_DQ28: JDIMM3.66 JDIMM4.66 U1.BC10
M_B_DQ29: JDIMM3.84 JDIMM4.84 U1.BB10
M_B_DQ30: JDIMM3.70 JDIMM4.70 U1.BC7
M_B_DQ31: JDIMM3.71 JDIMM4.71 U1.BB7
M_B_DQ32: JDIMM3.183 JDIMM4.183 U1.AA11
M_B_DQ33: JDIMM3.186 JDIMM4.186 U1.AA10
M_B_DQ34: JDIMM3.170 JDIMM4.170 U1.AC11
M_B_DQ35: JDIMM3.173 JDIMM4.173 U1.AC10
M_B_DQ36: JDIMM3.182 JDIMM4.182 U1.AA7
M_B_DQ37: JDIMM3.187 JDIMM4.187 U1.AA8
M_B_DQ38: JDIMM3.169 JDIMM4.169 U1.AC8
M_B_DQ39: JDIMM3.174 JDIMM4.174 U1.AC7
M_B_DQ40: JDIMM3.191 JDIMM4.191 U1.W8
M_B_DQ41: JDIMM3.195 JDIMM4.195 U1.W7
M_B_DQ42: JDIMM3.207 JDIMM4.207 U1.V10
M_B_DQ43: JDIMM3.204 JDIMM4.204 U1.V11
M_B_DQ44: JDIMM3.190 JDIMM4.190 U1.W11
M_B_DQ45: JDIMM3.194 JDIMM4.194 U1.W10
M_B_DQ46: JDIMM3.203 JDIMM4.203 U1.V7
M_B_DQ47: JDIMM3.208 JDIMM4.208 U1.V8
M_B_DQ48: JDIMM3.212 JDIMM4.212 U1.R11
M_B_DQ49: JDIMM3.225 JDIMM4.225 U1.P11
M_B_DQ50: JDIMM3.224 JDIMM4.224 U1.P7
M_B_DQ51: JDIMM3.215 JDIMM4.215 U1.R8
M_B_DQ52: JDIMM3.211 JDIMM4.211 U1.R10
M_B_DQ53: JDIMM3.228 JDIMM4.228 U1.P10
M_B_DQ54: JDIMM3.216 JDIMM4.216 U1.R7
M_B_DQ55: JDIMM3.229 JDIMM4.229 U1.P8
M_B_DQ56: JDIMM3.250 JDIMM4.250 U1.L11
M_B_DQ57: JDIMM3.232 JDIMM4.232 U1.M11
M_B_DQ58: JDIMM3.245 JDIMM4.245 U1.L7
M_B_DQ59: JDIMM3.233 JDIMM4.233 U1.M8
M_B_DQ60: JDIMM3.249 JDIMM4.249 U1.L10
M_B_DQ61: JDIMM3.236 JDIMM4.236 U1.M10
M_B_DQ62: JDIMM3.237 JDIMM4.237 U1.M7
M_B_DQ63: JDIMM3.246 JDIMM4.246 U1.L8
M_B_DQS_DN0: JDIMM3.11 JDIMM4.11 U1.BP9
M_B_DQS_DN1: JDIMM3.32 JDIMM4.32 U1.BL9
M_B_DQS_DN2: JDIMM3.53 JDIMM4.53 U1.BG9
M_B_DQS_DN3: JDIMM3.74 JDIMM4.74 U1.BC9
M_B_DQS_DN4: JDIMM3.177 JDIMM4.177 U1.AC9
M_B_DQS_DN5: JDIMM3.198 JDIMM4.198 U1.W9
M_B_DQS_DN6: JDIMM3.219 JDIMM4.219 U1.R9
M_B_DQS_DN7: JDIMM3.240 JDIMM4.240 U1.M9
M_B_DQS_DP0: JDIMM3.13 JDIMM4.13 U1.BR9
M_B_DQS_DP1: JDIMM3.34 JDIMM4.34 U1.BJ9
M_B_DQS_DP2: JDIMM3.55 JDIMM4.55 U1.BF9
M_B_DQS_DP3: JDIMM3.76 JDIMM4.76 U1.BB9
M_B_DQS_DP4: JDIMM3.179 JDIMM4.179 U1.AA9
M_B_DQS_DP5: JDIMM3.200 JDIMM4.200 U1.V9
M_B_DQS_DP6: JDIMM3.221 JDIMM4.221 U1.P9
M_B_DQS_DP7: JDIMM3.242 JDIMM4.242 U1.L9
MAINON: PR610.1 PR623.1 PR1253.2 PR1258.2 PR1302.2 PR1306.2 PR1405.1 PR3465.1 R299.2 R520.1 U5.D9
MAINON_N: PQ1401.5 PQ1401.6 PQ1403.2 PQ1403.5 PR1401.1
MBAT_PRES_N: JDBUG1.4 PR103.2 PR104.1 PR208.1 U5.G13
MBAT_PRES_N_R: JBAT1.7 PR104.2
MCT1_TL: DL1.1 R283.1 TL1.15 TL1.18 TL1.21 TL1.24
MDA0: G2.U51 U48.U4
MDA1: G2.U48 U48.U2
MDA2: G2.U50 U48.T4
MDA3: G2.U49 U48.T2
MDA4: G2.R51 U48.N4
MDA5: G2.R50 U48.N2
MDA6: G2.R47 U48.M4
MDA7: G2.U46 U48.M2
MDA8: G2.V46 U48.U11
MDA9: G2.Y45 U48.U13
MDA10: G2.Y47 U48.T11
MDA11: G2.Y46 U48.T13
MDA12: G2.V50 U48.N11
MDA13: G2.V47 U48.N13
MDA14: G2.U52 U48.M11
MDA15: G2.V51 U48.M13
MDA16: G2.AJ44 U48.A11
MDA17: G2.AG48 U48.A13
MDA18: G2.AJ45 U48.B11
MDA19: G2.AG49 U48.B13
MDA20: G2.AF46 U48.E11
MDA21: G2.AF47 U48.E13
MDA22: G2.AF48 U48.F11
MDA23: G2.AD47 U48.F13
MDA24: G2.AD49 U48.A4
MDA25: G2.AD48 U48.A2
MDA26: G2.AC46 U48.B4
MDA27: G2.AC47 U48.B2
MDA28: G2.AA47 U48.E4
MDA29: G2.AA46 U48.E2
MDA30: G2.AA45 U48.F4
MDA31: G2.Y44 U48.F2
MDA32: G2.AW51 U2022.A4
MDA33: G2.BA52 U2022.A2
MDA34: G2.AW50 U2022.B4
MDA35: G2.BA51 U2022.B2
MDA36: G2.BA50 U2022.E4
MDA37: G2.BB50 U2022.E2
MDA38: G2.BA49 U2022.F4
MDA39: G2.AW49 U2022.F2
MDA40: G2.AV48 U2022.A11
MDA41: G2.AT49 U2022.A13
MDA42: G2.AT47 U2022.B11
MDA43: G2.AT48 U2022.B13
MDA44: G2.AT46 U2022.E11
MDA45: G2.AV51 U2022.E13
MDA46: G2.AV52 U2022.F11
MDA47: G2.AV49 U2022.F13
MDA48: G2.AJ48 U2022.U11
MDA49: G2.AJ46 U2022.U13
MDA50: G2.AJ47 U2022.T11
MDA51: G2.AK49 U2022.T13
MDA52: G2.AM47 U2022.N11
MDA53: G2.AM46 U2022.N13
MDA54: G2.AN48 U2022.M11
MDA55: G2.AN49 U2022.M13
MDA56: G2.AM44 U2022.U4
MDA57: G2.AM45 U2022.U2
MDA58: G2.AN45 U2022.T4
MDA59: G2.AN46 U2022.T2
MDA60: G2.AR48 U2022.N4
MDA61: G2.AN47 U2022.N2
MDA62: G2.AR47 U2022.M4
MDA63: G2.AR46 U2022.M2
MDB0: G2.H32 U2023.U4
MDB1: G2.D32 U2023.U2
MDB2: G2.A33 U2023.T4
MDB3: G2.B32 U2023.T2
MDB4: G2.E32 U2023.N4
MDB5: G2.G32 U2023.N2
MDB6: G2.J30 U2023.M4
MDB7: G2.F32 U2023.M2
MDB8: G2.H36 U2023.U11
MDB9: G2.G36 U2023.U13
MDB10: G2.J36 U2023.T11
MDB11: G2.F36 U2023.T13
MDB12: G2.F33 U2023.N11
MDB13: G2.D33 U2023.N13
MDB14: G2.J32 U2023.M11
MDB15: G2.G33 U2023.M13
MDB16: G2.E45 U2023.A11
MDB17: G2.D45 U2023.A13
MDB18: G2.F45 U2023.B11
MDB19: G2.G45 U2023.B13
MDB20: G2.D42 U2023.E11
MDB21: G2.E42 U2023.E13
MDB22: G2.F42 U2023.F11
MDB23: G2.H41 U2023.F13
MDB24: G2.E41 U2023.A4
MDB25: G2.F39 U2023.A2
MDB26: G2.E39 U2023.B4
MDB27: G2.D39 U2023.B2
MDB28: G2.F38 U2023.E4
MDB29: G2.E38 U2023.E2
MDB30: G2.D36 U2023.F4
MDB31: G2.E36 U2023.F2
MDB32: G2.M50 U55.A4
MDB33: G2.P48 U55.A2
MDB34: G2.M51 U55.B4
MDB35: G2.M49 U55.B2
MDB36: G2.P47 U55.E4
MDB37: G2.P52 U55.E2
MDB38: G2.R46 U55.F4
MDB39: G2.P46 U55.F2
MDB40: G2.L50 U55.A11
MDB41: G2.L51 U55.A13
MDB42: G2.L52 U55.B11
MDB43: G2.L49 U55.B13
MDB44: G2.M46 U55.E11
MDB45: G2.L47 U55.E13
MDB46: G2.M48 U55.F11
MDB47: G2.M47 U55.F13
MDB48: G2.D48 U55.U11
MDB49: G2.C50 U55.U13
MDB50: G2.C48 U55.T11
MDB51: G2.C49 U55.T13
MDB52: G2.E49 U55.N11
MDB53: G2.E50 U55.N13
MDB54: G2.F49 U55.M11
MDB55: G2.F48 U55.M13
MDB56: G2.F50 U55.U4
MDB57: G2.D52 U55.U2
MDB58: G2.J50 U55.T4
MDB59: G2.H48 U55.T2
MDB60: G2.H51 U55.N4
MDB61: G2.J51 U55.N2
MDB62: G2.H49 U55.M4
MDB63: G2.H52 U55.M2
MDC0: G2.C6 U2025.U4
MDC1: G2.D6 U2025.U2
MDC2: G2.A6 U2025.T4
MDC3: G2.B6 U2025.T2
MDC4: G2.B4 U2025.N4
MDC5: G2.A4 U2025.N2
MDC6: G2.B3 U2025.M4
MDC7: G2.C4 U2025.M2
MDC8: G2.D9 U2025.U11
MDC9: G2.C9 U2025.U13
MDC10: G2.E9 U2025.T11
MDC11: G2.B9 U2025.T13
MDC12: G2.B8 U2025.N11
MDC13: G2.A8 U2025.N13
MDC14: G2.F6 U2025.M11
MDC15: G2.E6 U2025.M13
MDC16: G2.F18 U2025.A11
MDC17: G2.G18 U2025.A13
MDC18: G2.E18 U2025.B11
MDC19: G2.H18 U2025.B13
MDC20: G2.D15 U2025.E11
MDC21: G2.E15 U2025.E13
MDC22: G2.G17 U2025.F11
MDC23: G2.H17 U2025.F13
MDC24: G2.J15 U2025.A4
MDC25: G2.H15 U2025.A2
MDC26: G2.E14 U2025.B4
MDC27: G2.F14 U2025.B2
MDC28: G2.H11 U2025.E4
MDC29: G2.G11 U2025.E2
MDC30: G2.F11 U2025.F4
MDC31: G2.E11 U2025.F2
MDC32: G2.J29 U2024.A4
MDC33: G2.F30 U2024.A2
MDC34: G2.H29 U2024.B4
MDC35: G2.G30 U2024.B2
MDC36: G2.B30 U2024.E4
MDC37: G2.A30 U2024.E2
MDC38: G2.H30 U2024.F4
MDC39: G2.C30 U2024.F2
MDC40: G2.D27 U2024.A11
MDC41: G2.J26 U2024.A13
MDC42: G2.F27 U2024.B11
MDC43: G2.G27 U2024.B13
MDC44: G2.C27 U2024.E11
MDC45: G2.B27 U2024.E13
MDC46: G2.A27 U2024.F11
MDC47: G2.G29 U2024.F13
MDC48: G2.H20 U2024.U11
MDC49: G2.D18 U2024.U13
MDC50: G2.G20 U2024.T11
MDC51: G2.E20 U2024.T13
MDC52: G2.F23 U2024.N11
MDC53: G2.E21 U2024.N13
MDC54: G2.D21 U2024.M11
MDC55: G2.E23 U2024.M13
MDC56: G2.G24 U2024.U4
MDC57: G2.H26 U2024.U2
MDC58: G2.F24 U2024.T4
MDC59: G2.G26 U2024.T2
MDC60: G2.F26 U2024.N4
MDC61: G2.D26 U2024.N2
MDC62: G2.B26 U2024.M4
MDC63: G2.C26 U2024.M2
MDD0: G2.AK8 U2026.U4
MDD1: G2.AK4 U2026.U2
MDD2: G2.AK2 U2026.T4
MDD3: G2.AK3 U2026.T2
MDD4: G2.AK5 U2026.N4
MDD5: G2.AK6 U2026.N2
MDD6: G2.AK9 U2026.M4
MDD7: G2.AK7 U2026.M2
MDD8: G2.AG4 U2026.U11
MDD9: G2.AF9 U2026.U13
MDD10: G2.AG6 U2026.T11
MDD11: G2.AG7 U2026.T13
MDD12: G2.AJ4 U2026.N11
MDD13: G2.AJ5 U2026.N13
MDD14: G2.AJ6 U2026.M11
MDD15: G2.AG5 U2026.M13
MDD16: G2.Y6 U2026.A11
MDD17: G2.Y5 U2026.A13
MDD18: G2.V5 U2026.B11
MDD19: G2.Y4 U2026.B13
MDD20: G2.AA6 U2026.E11
MDD21: G2.AA5 U2026.E13
MDD22: G2.AC5 U2026.F11
MDD23: G2.AC4 U2026.F13
MDD24: G2.AD7 U2026.A4
MDD25: G2.AC6 U2026.A2
MDD26: G2.AF6 U2026.B4
MDD27: G2.AD6 U2026.B2
MDD28: G2.AF7 U2026.E4
MDD29: G2.AF8 U2026.E2
MDD30: G2.AF2 U2026.F4
MDD31: G2.AF3 U2026.F2
MDD32: G2.F4 U60.A4
MDD33: G2.E1 U60.A2
MDD34: G2.F3 U60.B4
MDD35: G2.F5 U60.B2
MDD36: G2.D2 U60.E4
MDD37: G2.D1 U60.E2
MDD38: G2.C3 U60.F4
MDD39: G2.C2 U60.F2
MDD40: G2.J5 U60.A11
MDD41: G2.J4 U60.A13
MDD42: G2.L8 U60.B11
MDD43: G2.J2 U60.B13
MDD44: G2.F1 U60.E11
MDD45: G2.F2 U60.E13
