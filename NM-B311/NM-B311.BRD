# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ4: length 97
  TOP w0.102: v2(132.32,72.72) 131.55,71.96 129.84,71.96 129.36,72.44 129.36,72.98 129.58,73.21 130.27,73.21 130.5,72.98 130.5,72.5 130.73,72.27 131.46,72.27 131.79,72.6 131.79,72.85 132.26,73.32 132.68,73.32 132.85,73.48 JDIMM4.8
  IN10 w0.076: 146.45,136.4 147.42,137.37 v2(148.72,137.37)
  IN10 w0.13: 146.45,136.4 141.88,131.83 141.88,129.95 132.47,120.54 132.47,117.74 131.61,116.89 131.61,87.04 128.64,84.07 128.64,82.27 131.46,79.45 131.46,73.57 v2(132.32,72.72)
  BOTTOM w0.102: v2(132.32,72.72) 133.32,71.72 133.32,69.37 132.44,68.49 132.18,68.49 131.91,68.22 131.91,67.88 132.15,67.64 133.88,67.64 134.55,66.97 JDIMM3.8
  BOTTOM w0.14: U1.BP11 150.41,137.27 150.1,137.58 149.21,137.58 149,137.37 v2(148.72,137.37)
M_B_DQ5: length 93.9
  TOP w0.102: JDIMM4.3 131.6,67.3 131.5,67.4 129.7,67.4 129.38,67.72 129.38,68.2 129.66,68.48 131.44,68.48 131.9,68.94 v2(132.32,68.94)
  IN10 w0.076: 146.46,135.98 147.39,136.91 149.06,136.91 149.8,137.66 v2(150.94,137.66)
  IN10 w0.13: v2(132.32,68.94) 133.01,69.64 133.01,71.05 132.8,71.26 132.8,92.45 131.97,93.27 131.97,116.41 132.83,117.27 132.83,120.39 142.23,129.8 142.23,131.75 146.46,135.98
  BOTTOM w0.102: JDIMM3.3 133.3,73.57 133,73.27 132.21,73.27 131.9,72.95 131.9,72.19 133.01,71.07 133.01,69.64 v2(132.32,68.94)
  BOTTOM w0.14: U1.BN11 151.27,137.34 v2(150.94,137.66)
M_B_DQ6: length 92.2
  TOP w0.102: v2(136.37,69.42) 136.39,69.42 136.77,69.8 136.77,72.77 136.43,73.11 136.15,73.11 135.85,73.41 JDIMM4.20
  IN10 w0.076: 147.01,134.21 147.43,134.64 147.43,135.16 147.76,135.49 148.29,135.49 v2(148.42,135.36)
  IN10 w0.13: v2(136.37,69.42) 136.79,69 136.79,67.52 136.66,67.39 136.01,67.39 135.88,67.52 135.88,73.36 135.74,73.5 135.74,80.89 135.04,81.6 135.04,93.09 134.66,93.47 134.66,100.21 134.4,100.47 134.4,115.21 134.95,115.75 134.95,119.61 143.91,128.58 143.91,131.11 147.01,134.21
  BOTTOM w0.076: v2(148.42,135.36) 148.58,135.2 149.44,135.2 149.68,135.44 149.68,135.79 149.87,135.98 150.33,135.98 U1.BP8
  BOTTOM w0.102: v2(136.37,69.42) 135.66,69.42 135.35,69.12 135.35,68.43 135.62,68.16 136.79,68.16 137.55,67.4 JDIMM3.20
M_B_DQ7: length 91.4
  TOP w0.102: v2(136.37,70.69) 136.14,70.69 135.89,70.45 135.89,68.27 136.1,68.06 JDIMM4.21
  IN10 w0.13: v2(150.94,136.09) 149.72,136.09 144.55,130.92 144.55,128.2 135.66,119.31 135.66,111.33 135.37,111.04 135.37,93.69 135.76,93.31 135.76,92.3 135.88,92.18 136.02,92.18 136.15,92.05 136.15,91.79 136.02,91.66 135.88,91.66 135.76,91.53 135.76,91.27 135.88,91.14 136.02,91.14 136.15,91.01 136.15,90.75 136.02,90.62 135.88,90.62 135.76,90.49 135.76,88.04 135.88,87.91 136.02,87.91 136.15,87.78 136.15,87.52 136.02,87.39 135.88,87.39 135.76,87.26 135.76,87 135.88,86.87 136.02,86.87 136.15,86.74 136.15,86.48 136.02,86.35 135.88,86.35 135.76,86.23 135.76,81.82 136.93,80.65 136.93,73.18 137.12,72.99 137.12,70.74 137.43,70.43 137.43,69.93 138.04,69.32 138.04,68.63 137.92,68.51 137.4,68.51 137.27,68.63 137.27,69.26 136.8,69.73 136.8,70.26 v2(136.37,70.69)
  BOTTOM w0.102: v2(136.37,70.69) 136.52,70.54 137.12,70.54 137.38,70.81 137.38,73.16 137.8,73.58 JDIMM3.21
  BOTTOM w0.14: v2(150.94,136.09) 150.94,135.97 151.22,135.69 U1.BN8
M_B_DQ8: length 88.1
  TOP w0.102: v2(138.54,69.42) 137.54,69.42 137.1,68.99 137.1,68.65 137.2,68.55 137.36,68.55 137.46,68.45 137.46,68.24 137.36,68.14 137.2,68.14 137.1,68.04 137.1,67.84 137.2,67.74 137.36,67.74 137.46,67.64 137.46,67.43 137.36,67.33 137.2,67.33 137.1,67.23 JDIMM4.25
  IN10 w0.076: 149.9,135.43 150.19,135.72 151.1,135.72 152.24,136.87 v2(152.24,137.66)
  IN10 w0.13: v2(138.54,69.42) 138.12,69.84 138.12,70.31 137.45,70.97 137.45,73.13 137.26,73.32 137.26,80.96 136.84,81.38 136.84,92.72 136.14,93.42 136.14,110.72 136.43,111.01 136.43,119.11 144.86,127.55 144.86,129.89 148.2,133.23 148.76,133.23 149.11,133.57 149.11,134.64 149.9,135.43
  BOTTOM w0.102: v2(138.54,69.42) 138.13,69.83 138.13,72.79 138.8,73.45 JDIMM3.25
  BOTTOM w0.14: v2(152.24,137.66) 152.24,137.73 U1.BL12
M_B_DQ9: length 87.3
  TOP w0.102: JDIMM4.24 136.85,73.58 137.11,73.32 137.24,73.32 137.53,73.04 137.53,72.91 137.52,72.91 137.52,71.06 137.89,70.69 v2(138.54,70.69)
  IN10 w0.076: 150.08,134.57 150.09,134.57 151.03,135.51 151.11,135.51 152.52,136.93 152.52,137.13 v2(153.04,137.65)
  IN10 w0.13: v2(138.54,70.69) 138.21,70.69 137.79,71.11 137.79,73.3 137.59,73.49 137.59,81.1 137.2,81.49 137.2,92.83 136.5,93.54 136.5,95.86 136.98,96.34 136.98,100.36 136.85,100.48 136.63,100.48 136.5,100.61 136.5,100.87 136.63,101 136.85,101 136.98,101.13 136.98,101.39 136.85,101.52 136.63,101.52 136.5,101.65 136.5,108.48 136.63,108.61 136.66,108.61 136.78,108.74 136.78,109 136.66,109.13 136.63,109.13 136.5,109.26 136.5,109.52 136.63,109.65 136.66,109.65 136.78,109.78 136.78,110.03 136.66,110.16 136.63,110.16 136.5,110.29 136.5,110.55 136.63,110.68 136.66,110.68 136.78,110.81 136.78,118.96 145.18,127.36 145.18,127.77 146.09,128.68 146.09,130.03 146.5,130.43 146.65,130.43 147.6,131.39 147.6,131.41 148.25,132.06 148.27,132.06 148.55,132.34 148.91,132.34 149.32,132.74 149.32,133.81 150.08,134.57
  BOTTOM w0.102: JDIMM3.24 138.55,67.89 138.94,68.28 138.94,70.29 v2(138.54,70.69)
  BOTTOM w0.14: v2(153.04,137.65) U1.BL11
M_B_DQ10: length 88.4
  TOP w0.102: JDIMM4.28 137.85,73.48 138.01,73.32 138.37,73.32 138.47,73.22 138.47,73.05 138.4,72.98 137.94,72.98 137.83,72.87 137.83,72.71 137.94,72.6 138.05,72.6 138.14,72.5 138.14,72.36 138.05,72.27 137.95,72.27 137.83,72.14 137.83,71.19 137.92,71.1 138.04,71.1 138.13,71.19 138.13,71.94 138.26,72.06 138.44,72.06 v2(138.54,71.96)
  IN10 w0.076: v2(152.24,136.09) 151.47,135.31 151.04,135.31 150.31,134.58 150.31,134.5 150.08,134.27 150.08,134.26
  IN10 w0.13: v2(138.54,71.96) 138.35,71.96 138.12,72.19 138.12,73.58 137.93,73.77 137.93,81.29 137.56,81.66 137.56,93.05 136.85,93.75 136.85,95.71 137.34,96.19 137.34,101.88 137.21,102 136.98,102 136.85,102.13 136.85,102.4 136.98,102.52 137.21,102.52 137.34,102.65 137.34,102.91 137.21,103.04 136.98,103.04 136.85,103.17 136.85,103.43 136.98,103.56 137.21,103.56 137.34,103.69 137.34,103.95 137.21,104.08 136.98,104.08 136.85,104.2 136.85,104.47 136.98,104.6 137.21,104.6 137.34,104.72 137.34,104.99 137.21,105.11 136.98,105.11 136.85,105.24 136.85,105.5 136.98,105.63 137.21,105.63 137.34,105.76 137.34,106.02 137.21,106.15 136.98,106.15 136.85,106.28 136.85,106.54 136.98,106.67 137.21,106.67 137.34,106.8 137.34,107.06 137.21,107.19 136.98,107.19 136.85,107.31 136.85,107.73 136.98,107.86 137.02,107.86 137.14,107.99 137.14,118.72 145.49,127.06 145.49,127.69 146.41,128.62 146.41,128.95 149.52,132.06 149.52,133.69 150.08,134.26
  BOTTOM w0.102: v2(138.54,71.96) 139.37,71.13 139.37,67.65 139.55,67.47 JDIMM3.28
  BOTTOM w0.14: v2(152.24,136.09) U1.BL8
M_B_DQ11: length 88
  TOP w0.102: JDIMM4.38 140.35,73.53 141.04,72.84 141.04,71.99 141.42,71.61 141.42,70.44 141.65,70.21 141.99,70.21 v2(142.48,70.69)
  IN10 w0.076: v2(153.91,135.7) 153.49,135.28 153.49,134.59 152.4,133.49 151.7,133.49 151.15,132.95
  IN10 w0.13: v2(142.48,70.69) 142.27,70.69 141.64,71.33 141.64,75.52 141.12,76.03 141.12,79.88 140.79,80.21 140.79,93.42 139.74,94.47 139.74,104.79 139.87,104.92 140.1,104.92 140.23,105.05 140.23,105.31 140.1,105.44 139.87,105.44 139.74,105.57 139.74,105.83 139.87,105.96 140.1,105.96 140.23,106.09 140.23,106.35 140.1,106.48 139.87,106.48 139.74,106.61 139.74,106.87 139.87,106.99 140.1,106.99 140.23,107.12 140.23,107.38 140.1,107.51 139.87,107.51 139.74,107.64 139.74,107.9 139.87,108.03 140.1,108.03 140.23,108.16 140.23,108.42 140.1,108.55 139.87,108.55 139.74,108.68 139.74,108.94 139.87,109.07 140.1,109.07 140.23,109.2 140.23,109.46 140.1,109.59 139.87,109.59 139.74,109.71 139.74,109.98 139.87,110.1 140.1,110.1 140.23,110.23 140.23,118.4 147.17,125.34 147.17,126.94 151.15,130.92 151.15,132.95
  BOTTOM w0.102: JDIMM3.38 142.05,67.24 142.15,67.34 142.23,67.34 142.34,67.44 142.34,67.64 142.23,67.75 142.15,67.75 142.05,67.85 142.05,68.08 142.15,68.18 142.67,68.18 142.95,68.46 142.95,70.22 142.48,70.69 v2(142.48,70.69)
  BOTTOM w0.14: U1.BJ8 v2(153.91,135.7)
M_B_DQ12: length 88.8
  TOP w0.102: JDIMM4.37 140.1,67.54 140.98,68.42 140.98,71.56 v2(140.57,71.96)
  IN10 w0.076: v2(153.91,137) 153.5,136.59 153.5,136.21 153.07,135.78 153.07,134.76 152.22,133.91 151.48,133.91 150.69,133.12
  IN10 w0.13: 150.69,133.12 150.69,131.17 146.7,127.18 146.7,125.89 139.03,118.21 139.03,117.94 139.16,117.82 139.38,117.82 139.51,117.69 139.51,117.43 139.38,117.3 139.16,117.3 139.03,117.17 139.03,116.91 139.16,116.78 139.38,116.78 139.51,116.65 139.51,116.39 139.38,116.26 139.16,116.26 139.03,116.13 139.03,115.87 139.16,115.74 139.38,115.74 139.51,115.61 139.51,115.35 139.38,115.22 139.16,115.22 139.03,115.09 139.03,114.84 139.16,114.71 139.38,114.71 139.51,114.58 139.51,114.32 139.38,114.19 139.16,114.19 139.03,114.06 139.03,113.8 139.16,113.67 139.38,113.67 139.51,113.54 139.51,113.28 139.38,113.15 139.16,113.15 139.03,113.02 139.03,94.21 139.59,93.65 139.59,80.47 139.86,80.2 139.86,76.41 139.86,76.41 139.86,75.69 140.11,75.44 140.11,72.34 140.49,71.96 v2(140.57,71.96)
  BOTTOM w0.102: JDIMM3.37 141.8,73.45 141.67,73.32 140.84,73.32 140.72,73.2 140.72,73.02 140.84,72.9 141.64,72.9 141.76,72.78 141.76,72.6 141.64,72.47 141.3,72.47 141.19,72.36 141.19,72.2 141.3,72.09 141.5,72.09 141.61,71.98 141.61,71.82 141.5,71.71 141.07,71.71 140.81,71.96 v2(140.57,71.96)
  BOTTOM w0.14: v2(153.91,137) U1.BJ11
M_B_DQ13: length 88.1
  TOP w0.102: JDIMM4.41 141.1,67.04 141.42,67.36 141.42,67.67 141.52,67.78 141.61,67.78 141.73,67.89 141.73,68.06 141.61,68.18 141.52,68.18 141.42,68.28 141.42,68.49 141.52,68.59 141.65,68.59 141.75,68.69 141.75,68.89 141.65,68.99 141.52,68.99 141.42,69.1 141.42,69.55 141.68,69.8 142.09,69.8 v2(142.48,69.42)
  IN10 w0.076: v2(153.91,136.35) 153.91,136.26 153.28,135.63 153.28,134.67 152.31,133.7 151.6,133.7 150.9,133
  IN10 w0.13: v2(142.48,69.42) 142.02,69.42 141.26,70.18 141.26,75.39 140.79,75.86 140.79,79.74 139.95,80.58 139.95,93.78 139.39,94.34 139.39,110.46 139.52,110.59 139.74,110.59 139.87,110.72 139.87,110.98 139.74,111.11 139.52,111.11 139.39,111.24 139.39,111.5 139.52,111.63 139.74,111.63 139.87,111.76 139.87,112.02 139.74,112.15 139.52,112.15 139.39,112.28 139.39,112.53 139.52,112.66 139.74,112.66 139.87,112.79 139.87,118.55 146.94,125.61 146.94,127.06 150.9,131.02 150.9,133
  BOTTOM w0.102: v2(142.48,69.42) 142.07,69.83 142.07,73.06 142.25,73.24 142.57,73.24 142.8,73.47 JDIMM3.41
  BOTTOM w0.14: U1.BJ10 v2(153.91,136.35)
M_B_DQ14: length 87.4
  TOP w0.102: JDIMM4.29 138.1,67.31 137.89,67.52 137.89,67.92 138.12,68.15 138.75,68.15 139.47,68.86 139.47,69.09 139.8,69.42 v2(140.57,69.42)
  IN10 w0.076: v2(152.29,135.27) 152.18,135.16 151.12,135.16 150.46,134.5 150.46,134.32 150.34,134.19
  IN10 w0.13: v2(140.57,69.42) 139.73,69.42 138.96,70.2 138.96,73.37 138.88,73.45 138.88,77.61 138.26,78.23 138.26,81.42 137.91,81.77 137.91,93.16 137.21,93.86 137.21,95.48 137.7,95.96 137.7,107.54 137.5,107.73 137.5,108.28 137.7,108.47 137.7,108.79 137.5,108.99 137.5,109.31 137.7,109.51 137.7,109.83 137.5,110.02 137.5,110.35 137.7,110.54 137.7,110.87 137.5,111.06 137.5,111.39 137.7,111.58 137.7,111.9 137.5,112.1 137.5,112.42 137.7,112.62 137.7,112.94 137.5,113.13 137.5,113.46 137.7,113.65 137.7,113.98 137.5,114.17 137.5,114.49 137.7,114.69 137.7,115.01 137.5,115.21 137.5,115.53 137.7,115.72 137.7,116.05 137.5,116.24 137.5,116.57 137.7,116.76 137.7,117.08 137.5,117.28 137.5,117.67 137.7,117.86 137.7,118.19 137.5,118.38 137.5,118.57 145.79,126.86 145.79,127.61 146.81,128.63 146.81,128.86 149.73,131.78 149.73,133.58 150.34,134.19
  BOTTOM w0.102: v2(140.57,69.42) 139.8,70.19 JDIMM3.29
  BOTTOM w0.14: U1.BL7 v2(152.29,135.27)
M_B_DQ15: length 88.4
  TOP w0.102: v2(142.48,71.96) 142.34,71.96 142.03,71.65 142.03,70.68 141.94,70.59 141.82,70.59 141.73,70.68 141.73,71.73 141.35,72.11 141.35,72.71 141.45,72.81 141.56,72.81 141.68,72.93 141.68,73.1 141.56,73.22 141.45,73.22 141.35,73.32 141.35,74.37 JDIMM4.42
  IN10 w0.076: v2(153.91,135.05) 153.91,134.72 152.48,133.29 151.8,133.29 151.39,132.88
  IN10 w0.13: 151.39,132.88 151.39,130.79 147.4,126.79 147.4,125.05 140.59,118.24 140.59,104.42 140.46,104.29 140.26,104.29 140.13,104.16 140.13,103.91 140.26,103.78 140.46,103.78 140.59,103.65 140.59,103.39 140.46,103.26 140.26,103.26 140.13,103.13 140.13,102.87 140.26,102.74 140.46,102.74 140.59,102.61 140.59,102.35 140.46,102.22 140.26,102.22 140.13,102.09 140.13,101.83 140.26,101.7 140.46,101.7 140.59,101.57 140.59,101.32 140.46,101.19 140.26,101.19 140.13,101.06 140.13,100.8 140.26,100.67 140.46,100.67 140.59,100.54 140.59,100.28 140.46,100.15 140.26,100.15 140.13,100.02 140.13,99.76 140.26,99.63 140.46,99.63 140.59,99.5 140.59,99.24 140.46,99.11 140.26,99.11 140.13,98.98 140.13,98.72 140.26,98.59 140.46,98.59 140.59,98.47 140.59,98.21 140.46,98.08 140.26,98.08 140.13,97.95 140.13,97.69 140.26,97.56 140.46,97.56 140.59,97.43 140.59,97.17 140.46,97.04 140.26,97.04 140.13,96.91 140.13,96.65 140.26,96.52 140.46,96.52 140.59,96.39 140.59,96.13 140.46,96 140.26,96 140.13,95.87 140.13,95.62 140.26,95.49 140.46,95.49 140.59,95.36 140.59,94.16 141.14,93.61 141.14,80.34 141.48,79.99 141.48,76.31 142.02,75.77 142.02,72.22 142.27,71.96 v2(142.48,71.96)
  BOTTOM w0.102: JDIMM3.42 143.05,68.07 143.25,68.27 143.25,70.35 142.88,70.72 142.88,71.5 142.48,71.9 v2(142.48,71.96)
  BOTTOM w0.14: U1.BJ7 v2(153.91,135.05)
M_B_DQ16: length 88.1
  TOP w0.102: JDIMM4.45 142.1,66.97 142.89,67.76 143.52,67.76 143.65,67.89 143.65,68.35 143.55,68.46 143.15,68.46 143.05,68.56 143.05,69.32 143.15,69.42 v2(144.38,69.42)
  IN10 w0.076: 153.35,131.63 153.36,131.64 153.36,133.91 153.77,134.32 153.88,134.32 155.21,135.64 155.21,137.1 v2(155.74,137.64)
  IN10 w0.13: 153.35,131.63 147.95,126.23 147.95,124.84 141.35,118.24 141.35,94.56 141.49,94.42 141.49,81.19 142.69,79.99 142.69,73.05 142.9,72.85 142.9,70.91 v2(144.38,69.42)
  BOTTOM w0.102: JDIMM3.45 143.8,73.58 143.53,73.31 143.28,73.31 142.97,73 142.97,71.96 143.33,71.61 143.33,71 143.97,70.35 143.97,69.83 v2(144.38,69.42)
  BOTTOM w0.14: U1.BG11 v2(155.74,137.64)
M_B_DQ17: length 87.9
  TOP w0.102: JDIMM4.46 142.35,73.34 142.92,72.77 142.92,70.18 143.05,70.06 v2(144.38,70.06)
  IN10 w0.076: v2(155.74,137) 155.36,136.62 155.36,135.43 154.13,134.2 154.13,131.66 153.46,130.99 153.08,130.99
  IN10 w0.13: v2(144.38,70.06) 143.23,71.21 143.23,73.1 143.03,73.3 143.03,80.12 141.85,81.3 141.85,94.55 141.71,94.69 141.71,101.53 141.84,101.65 142.06,101.65 142.19,101.78 142.19,102.06 142.07,102.17 141.84,102.17 141.71,102.3 141.71,102.56 141.84,102.69 142.06,102.69 142.19,102.82 142.19,103.09 142.07,103.21 141.84,103.21 141.71,103.34 141.71,118.09 148.28,124.66 148.28,126.19 153.08,130.99
  BOTTOM w0.102: v2(144.38,70.06) 144.55,70.06 144.8,69.8 144.8,68.33 144.72,68.25 144.24,68.25 144.11,68.13 144.11,67.95 144.24,67.82 144.7,67.82 144.82,67.69 144.82,67.54 144.7,67.42 144.15,67.42 144.05,67.31 JDIMM3.46
  BOTTOM w0.14: U1.BG10 v2(155.74,137)
M_B_DQ18: length 87.1
  TOP w0.102: JDIMM4.50 143.35,73.36 143.22,73.23 143.22,70.56 143.35,70.44 143.81,70.44 143.96,70.59 143.96,70.91 v2(144.38,71.33)
  IN10 w0.076: v2(155.74,135.7) 155.74,135.59 154.35,134.2 154.35,131.58 153.59,130.81 153.28,130.81
  IN10 w0.13: v2(144.38,71.33) 143.56,72.15 143.56,73.41 143.36,73.61 143.36,80.26 142.69,80.93 142.69,93.1 142.55,93.24 142.55,103.42 142.42,103.55 142.19,103.55 142.07,103.67 142.07,103.93 142.19,104.06 142.42,104.06 142.55,104.18 142.55,104.44 142.42,104.57 142.19,104.57 142.07,104.7 142.07,104.96 142.19,105.09 142.42,105.09 142.55,105.22 142.55,105.48 142.42,105.61 142.19,105.61 142.07,105.73 142.07,106 142.19,106.13 142.42,106.13 142.55,106.25 142.55,106.52 142.42,106.64 142.19,106.64 142.07,106.77 142.07,107.03 142.19,107.16 142.42,107.16 142.55,107.29 142.55,107.55 142.42,107.68 142.19,107.68 142.07,107.81 142.07,108.07 142.19,108.2 142.42,108.2 142.55,108.33 142.55,108.59 142.42,108.72 142.19,108.72 142.07,108.84 142.07,109.11 142.19,109.23 142.42,109.23 142.55,109.36 142.55,109.63 142.42,109.75 142.19,109.75 142.07,109.88 142.07,117.94 148.61,124.49 148.61,126.14 153.28,130.81
  BOTTOM w0.102: v2(144.38,71.33) 144.62,71.33 144.8,71.15 144.8,70.29 145.13,69.96 145.13,67.38 145.05,67.3 JDIMM3.50
  BOTTOM w0.14: U1.BG8 v2(155.74,135.7)
M_B_DQ19: length 87.8
  TOP w0.102: JDIMM4.58 145.28,74.31 145.28,70.03 v2(146.4,68.91)
  IN10 w0.076: 155.42,132.85 155.42,133.29 157.02,134.9 157.02,135.33 v2(156.65,135.7)
  IN10 w0.13: 155.42,132.85 155.42,130.08 150.79,125.45 150.79,123.71 145.08,117.99 145.08,111.35 144.98,111.25 144.75,111.25 144.6,111.1 144.6,110.88 144.75,110.73 144.98,110.73 145.08,110.63 145.08,110.32 144.98,110.21 144.75,110.21 144.6,110.06 144.6,109.85 144.75,109.7 144.98,109.7 145.08,109.59 145.08,109.28 144.98,109.18 144.75,109.18 144.6,109.02 144.6,108.81 144.75,108.66 144.98,108.66 145.08,108.56 145.08,108.25 144.98,108.14 144.75,108.14 144.6,107.99 144.6,93.43 144.93,93.1 144.93,81.48 146.63,79.78 146.63,74.18 146.82,73.99 146.82,69.33 v2(146.4,68.91)
  BOTTOM w0.102: JDIMM3.58 147.05,67.09 146.89,67.25 145.8,67.25 145.64,67.41 145.64,68.03 145.74,68.13 146.08,68.13 146.2,68.25 146.2,68.42 146.08,68.54 145.74,68.54 145.58,68.7 145.58,69.01 145.7,69.13 146.27,69.13 146.4,69.01 v2(146.4,68.91)
  BOTTOM w0.14: U1.BF8 v2(156.65,135.7)
M_B_DQ20: length 87.2
  TOP w0.102: v2(148.57,69.8) 148.57,70.29 146.81,72.05 146.81,72.27 146.35,72.72 JDIMM4.62
  IN10 w0.076: 155.86,131.56 155.86,133.25 157.34,134.73 157.34,135.45 157.19,135.59 157.19,135.62 157.19,135.62 157.19,136.84 157.12,136.91 157.12,137.17 v2(156.65,137.64)
  IN10 w0.13: 155.86,131.56 155.86,129.81 155.86,129.81 155.86,129.45 151.91,125.5 151.61,125.2 151.61,123.51 145.8,117.7 145.8,107.38 145.67,107.25 145.5,107.25 145.37,107.12 145.37,106.87 145.5,106.74 145.67,106.74 145.8,106.61 145.8,106.35 145.67,106.22 145.5,106.22 145.37,106.09 145.37,105.83 145.5,105.7 145.67,105.7 145.8,105.57 145.8,105.31 145.67,105.18 145.5,105.18 145.37,105.05 145.37,104.79 145.5,104.66 145.67,104.66 145.8,104.53 145.8,103.47 145.79,103.46 145.79,81.57 147.3,80.06 147.3,74.69 147.49,74.5 147.49,70.89 v2(148.57,69.8)
  BOTTOM w0.102: v2(148.57,69.8) 148.18,69.8 147.89,69.51 147.76,69.51 147.64,69.39 147.64,69.22 147.76,69.11 147.93,69.11 148.05,68.99 148.05,68.82 147.93,68.7 147.81,68.7 147.7,68.58 147.7,68.41 147.81,68.29 147.95,68.29 148.05,68.19 148.05,67.99 147.95,67.89 147.8,67.89 147.7,67.78 147.7,67.58 147.8,67.48 147.95,67.48 148.05,67.38 JDIMM3.62
  BOTTOM w0.14: U1.BF11 v2(156.65,137.64)
M_B_DQ21: length 88.6
  TOP w0.102: JDIMM4.63 146.6,66.97 147.82,68.19 147.82,70.01 147.92,70.11 148.06,70.11 148.16,70.01 148.16,68.94 v2(148.57,68.53)
  IN10 w0.076: 155.64,132.57 155.64,133.28 157.19,134.83 157.19,135.38 157.04,135.53 157.04,135.55 157.03,135.56 157.03,136.62 v2(156.65,137)
  IN10 w0.13: v2(148.57,68.53) 147.15,69.95 147.15,74.25 146.96,74.44 146.96,79.92 145.38,81.5 145.38,93.12 145,93.5 145,107.52 145.44,107.96 145.44,117.85 151.2,123.61 151.2,125.35 155.64,129.8 155.64,129.92 155.64,129.92 155.64,132.57
  BOTTOM w0.102: v2(148.57,68.53) 148.57,68.59 148.98,69 148.98,70.09 148.17,70.9 148.17,72.51 148.3,72.65 JDIMM3.63
  BOTTOM w0.14: U1.BF10 v2(156.65,137)
M_B_DQ22: length 89
  TOP w0.102: v2(144.38,72.6) 144.79,72.19 144.79,68.6 143.58,67.39 143.45,67.39 143.1,67.04 JDIMM4.49
  IN10 w0.076: v2(155.74,135.05) 154.55,133.87 154.55,131.45 153.74,130.63 153.46,130.63
  IN10 w0.13: v2(144.38,72.6) 144.38,73.47 143.69,74.16 143.69,80.4 143.05,81.04 143.05,93.21 142.91,93.35 142.91,110.06 142.81,110.16 142.55,110.16 142.42,110.29 142.42,110.52 142.55,110.65 142.78,110.65 142.91,110.77 142.91,111.06 142.78,111.19 142.55,111.19 142.42,111.32 142.42,111.58 142.55,111.71 142.78,111.71 142.91,111.84 142.91,112.1 142.78,112.23 142.55,112.23 142.42,112.36 142.42,112.62 142.55,112.75 142.78,112.75 142.91,112.87 142.91,113.14 142.78,113.26 142.55,113.26 142.42,113.39 142.42,113.65 142.55,113.78 142.78,113.78 142.91,113.91 142.91,114.17 142.78,114.3 142.55,114.3 142.42,114.43 142.42,114.69 142.55,114.82 142.78,114.82 142.91,114.95 142.91,115.21 142.78,115.34 142.55,115.34 142.42,115.47 142.42,115.73 142.55,115.86 142.78,115.86 142.91,115.98 142.91,116.25 142.78,116.37 142.55,116.37 142.42,116.5 142.42,116.76 142.55,116.89 142.78,116.89 142.91,117.02 142.91,117.28 142.78,117.41 142.55,117.41 142.42,117.54 142.42,117.8 148.94,124.31 148.94,126.11 153.46,130.63
  BOTTOM w0.102: JDIMM3.49 144.8,73.43 144.67,73.31 144.06,73.31 143.76,73 143.4,73 143.3,72.9 143.3,72.75 143.4,72.65 143.61,72.65 143.73,72.54 143.73,72.38 143.61,72.27 143.38,72.27 143.3,72.19 143.3,72.06 143.63,71.73 143.63,71.12 143.73,71.03 143.86,71.03 143.96,71.12 143.96,72.38 144.18,72.6 v2(144.38,72.6)
  BOTTOM w0.14: v2(155.74,135.05) U1.BG7
M_B_DQ23: length 89.3
  TOP w0.102: v2(146.4,72.09) 146.4,72.03 147.52,70.91 147.52,68.32 147.01,67.81 146.12,67.81 145.6,67.29 JDIMM4.59
  IN10 w0.076: v2(156.65,135.05) 156.65,134.87 155.19,133.4 155.19,132.97
  IN10 w0.13: 155.19,132.97 155.19,130.33 150.36,125.51 150.36,123.85 144.72,118.21 144.72,117.92 144.59,117.79 144.37,117.79 144.24,117.66 144.24,117.4 144.37,117.27 144.59,117.27 144.72,117.14 144.72,116.88 144.59,116.75 144.37,116.75 144.24,116.62 144.24,116.36 144.37,116.23 144.6,116.23 144.72,116.11 144.72,115.84 144.6,115.71 144.37,115.71 144.24,115.59 144.24,115.32 144.37,115.2 144.6,115.2 144.72,115.07 144.72,114.81 144.6,114.68 144.37,114.68 144.24,114.55 144.24,114.29 144.37,114.16 144.6,114.16 144.72,114.03 144.72,113.77 144.6,113.64 144.37,113.64 144.24,113.51 144.24,113.25 144.37,113.12 144.6,113.12 144.72,113 144.72,112.73 144.6,112.61 144.37,112.61 144.24,112.48 144.24,112.21 144.37,112.09 144.59,112.09 144.72,111.96 144.72,111.7 144.59,111.57 144.37,111.57 144.24,111.44 144.24,93.32 144.6,92.96 144.6,81.35 145.79,80.15 145.79,75.9 146.27,75.41 146.27,75.16 146.02,74.9 146.02,74.64 146.27,74.39 146.27,73.74 146.4,73.61 v2(146.4,72.09)
  BOTTOM w0.14: JDIMM3.59 147.3,73.5 147.8,73 147.8,70.13 147.67,70.01 147.09,70.01 146.96,70.13 146.96,71.71 146.58,72.09 v2(146.4,72.09) ; U1.BF7 v2(156.65,135.05)
M_B_DQ24: length 91.8
  TOP w0.102: JDIMM4.83 151.6,67.37 151.75,67.52 152.4,67.52 152.91,68.03 152.91,71.81 v2(152.38,72.34)
  IN10 w0.076: v2(159.4,137.65) 159.93,137.12 159.93,135.6 160.08,135.45 160.08,134.14 159.85,133.91 159.85,129.09 159.74,128.98
  IN10 w0.13: 159.74,128.98 159.74,126.69 156.46,123.4 156.46,122.75 151.37,117.66 151.37,99.36 151.24,99.23 150.65,99.23 150.53,99.11 150.53,98.84 150.65,98.72 151.24,98.72 151.37,98.59 151.37,98.33 151.24,98.2 150.65,98.2 150.53,98.07 150.53,97.81 150.65,97.68 151.24,97.68 151.37,97.55 151.37,97.29 151.24,97.16 150.65,97.16 150.53,97.03 150.53,96.77 150.65,96.64 151.24,96.64 151.37,96.51 151.37,96.25 151.24,96.12 150.65,96.12 150.53,96 150.53,95.73 150.65,95.61 151.24,95.61 151.37,95.48 151.37,95.22 151.24,95.09 150.63,95.09 150.5,94.96 150.5,94.57 150.63,94.44 151.02,94.44 151.73,93.73 151.73,72.67 152.06,72.34 v2(152.38,72.34)
  BOTTOM w0.102: v2(152.38,72.34) 152.45,72.34 152.77,72.03 153.17,72.03 153.3,72.15 153.3,72.79 153.43,72.91 153.6,72.91 153.73,72.79 153.73,72.1 153.85,71.98 154.02,71.98 154.14,72.1 154.14,72.71 154.24,72.81 154.51,72.81 154.63,72.93 154.63,73.1 154.51,73.22 153.4,73.22 153.3,73.32 JDIMM3.83
  BOTTOM w0.14: U1.BB11 v2(159.4,137.65)
M_B_DQ25: length 91.1
  TOP w0.102: JDIMM4.79 150.6,67.55 150.74,67.69 150.91,67.69 151.08,67.52 151.25,67.52 151.37,67.64 151.37,67.8 151.27,67.9 151.27,68.05 151.37,68.15 151.53,68.15 151.78,68.4 151.78,68.6 151.68,68.7 151.35,68.7 151.23,68.83 151.23,69.17 151.35,69.29 151.62,69.29 v2(152.38,68.53)
  IN10 w0.076: v2(158.48,137.64) 157.95,137.1 157.95,135.58 157.57,135.2 157.57,134.6 157.46,134.49 157.46,133.59 157.17,133.29 157.17,133.15
  IN10 w0.13: 157.17,133.15 157.17,133.02 156.74,132.59 156.74,129.06 152.37,124.69 152.37,123.65 146.56,117.85 146.56,94.03 147.23,93.37 147.23,81.5 147.63,81.11 147.63,74.95 147.82,74.76 147.82,71.15 148.99,69.98 148.99,69.42 150.3,68.11 150.65,68.11 151.07,68.53 v2(152.38,68.53)
  BOTTOM w0.102: v2(152.38,68.53) 152.37,68.53 151.98,68.93 151.98,73.25 152.3,73.58 JDIMM3.79
  BOTTOM w0.14: U1.BC11 v2(158.48,137.64)
M_B_DQ26: length 89.8
  TOP w0.102: JDIMM4.80 150.85,73.53 151.4,72.98 151.4,70.77 152.37,69.8 v2(152.38,69.8)
  IN10 w0.076: 159.23,129.16 159.43,129.37 159.43,134.21 159.76,134.54 159.76,135.23 159.4,135.6 v2(159.4,135.7)
  IN10 w0.13: v2(152.38,69.8) 151.04,71.14 151.04,93.03 150.92,93.16 150.48,93.16 150.35,93.28 150.35,93.78 149.81,94.32 149.81,105.15 149.94,105.27 150.53,105.27 150.65,105.4 150.65,105.67 150.53,105.79 149.94,105.79 149.81,105.92 149.81,106.18 149.94,106.31 150.53,106.31 150.65,106.44 150.65,106.7 150.53,106.83 149.94,106.83 149.81,106.96 149.81,107.22 149.94,107.35 150.53,107.35 150.65,107.47 150.65,107.74 150.53,107.86 149.94,107.86 149.81,107.99 149.81,108.26 149.94,108.38 150.53,108.38 150.65,108.51 150.65,108.77 150.53,108.9 149.94,108.9 149.81,109.03 149.81,109.32 149.94,109.45 150.53,109.45 150.65,109.57 150.65,109.83 150.53,109.96 149.94,109.96 149.81,110.09 149.81,110.35 149.94,110.48 150.52,110.48 150.65,110.61 150.65,118 155.65,122.99 155.65,123.47 159.23,127.05 159.23,129.16
  BOTTOM w0.102: v2(152.38,69.8) 152.52,69.8 152.95,69.37 152.95,68.2 152.5,67.75 152,67.75 151.88,67.63 151.88,67.46 152,67.34 152.45,67.34 152.55,67.24 JDIMM3.80
  BOTTOM w0.14: U1.BB8 v2(159.4,135.7)
M_B_DQ27: length 90.7
  TOP w0.102: JDIMM4.67 147.6,66.95 147.87,67.23 148.42,67.23 148.66,67.47 148.66,67.82 148.81,67.97 148.99,67.97 149.09,68.08 149.09,68.9 149.21,69.02 149.38,69.02 149.5,68.9 149.5,68.08 149.6,67.97 149.92,67.97 v2(150.48,68.53)
  IN10 w0.076: v2(158.48,135.7) 158.48,135.59 158.33,135.43 158.32,135.43 158.1,135.21 158.1,135.21 158.06,135.16 158.06,134.44 157.77,134.15 157.77,133.46 157.58,133.27 157.58,132.9
  IN10 w0.13: 157.58,132.9 157.58,132.48 157.27,132.17 157.27,127.98 153.46,124.17 153.46,123.73 147.28,117.55 147.28,116.79 147.41,116.66 147.63,116.66 147.76,116.53 147.76,116.31 147.63,116.18 147.41,116.18 147.28,116.06 147.28,115.83 147.41,115.7 147.63,115.7 147.76,115.57 147.76,105.32 147.63,105.19 147.41,105.19 147.28,105.07 147.28,104.8 147.41,104.67 147.63,104.67 147.76,104.55 147.76,104.28 147.63,104.15 147.41,104.15 147.28,104.03 147.28,103.76 147.41,103.64 147.63,103.64 147.76,103.51 147.76,103.25 147.63,103.12 147.41,103.12 147.28,102.99 147.28,102.73 147.41,102.6 147.63,102.6 147.76,102.47 147.76,102.21 147.63,102.08 147.41,102.08 147.28,101.96 147.28,101.69 147.41,101.56 147.63,101.56 147.76,101.44 147.76,101.18 147.63,101.05 147.41,101.05 147.28,100.92 147.28,94.26 147.95,93.59 147.95,81.96 148.29,81.61 148.29,78.51 148.8,78.01 148.8,75.99 148.48,75.67 148.48,73.59 148.99,73.08 148.99,70.45 149.38,70.06 149.38,69.5 150.35,68.53 v2(150.48,68.53)
  BOTTOM w0.102: JDIMM3.67 149.3,72.73 150.07,71.96 150.07,69 150.48,68.59 v2(150.48,68.53)
  BOTTOM w0.14: U1.BC8 v2(158.48,135.7)
M_B_DQ28: length 91
  TOP w0.102: JDIMM4.66 147.35,73.45 147.25,73.35 147.17,73.35 147.09,73.27 147.09,73.16 147.17,73.08 148.05,73.08 148.13,73 148.13,72.88 148.05,72.8 147.18,72.8 147.09,72.7 147.09,72.57 147.18,72.47 148.04,72.47 148.17,72.34 148.17,72.14 148.08,72.05 148.08,71.78 148.3,71.56 148.42,71.56 v2(148.57,71.71)
  IN10 w0.076: 157.38,133.05 157.38,133.28 157.62,133.53 157.62,134.3 157.83,134.52 157.83,135.24 158.1,135.51 158.1,136.62 v2(158.48,137)
  IN10 w0.13: v2(148.57,71.71) 148.28,71.71 148.15,71.83 148.15,72.52 148.48,72.85 148.48,73.12 148.15,73.45 148.15,75.01 147.96,75.2 147.96,81.36 147.59,81.73 147.59,93.48 146.92,94.15 146.92,105.4 147.05,105.53 147.28,105.53 147.4,105.65 147.4,105.92 147.28,106.04 147.05,106.04 146.92,106.17 146.92,106.43 147.05,106.56 147.28,106.56 147.4,106.68 147.4,106.95 147.28,107.08 147.05,107.08 146.92,107.2 146.92,107.47 147.05,107.59 147.28,107.59 147.4,107.72 147.4,107.99 147.28,108.11 147.05,108.11 146.92,108.24 146.92,108.5 147.05,108.63 147.28,108.63 147.4,108.76 147.4,109.02 147.28,109.15 147.05,109.15 146.92,109.28 146.92,109.54 147.05,109.67 147.28,109.67 147.4,109.79 147.4,110.06 147.28,110.18 147.05,110.18 146.92,110.31 146.92,110.58 147.05,110.7 147.28,110.7 147.4,110.83 147.4,111.09 147.28,111.22 147.05,111.22 146.92,111.35 146.92,111.61 147.05,111.74 147.28,111.74 147.4,111.87 147.4,112.13 147.28,112.26 147.05,112.26 146.92,112.38 146.92,112.65 147.05,112.78 147.28,112.78 147.4,112.9 147.4,113.17 147.28,113.29 147.05,113.29 146.92,113.42 146.92,113.69 147.05,113.81 147.28,113.81 147.4,113.94 147.4,114.2 147.28,114.33 147.05,114.33 146.92,114.46 146.92,114.72 147.05,114.85 147.28,114.85 147.4,114.98 147.4,115.24 147.28,115.37 147.05,115.37 146.92,115.49 146.92,117.7 152.78,123.55 152.78,124.64 156.97,128.83 156.97,132.34 157.38,132.75 157.38,133.05
  BOTTOM w0.102: JDIMM3.66 149.05,66.97 149.4,67.32 149.4,68.18 149.71,68.5 149.71,70.56 v2(148.57,71.71)
  BOTTOM w0.14: U1.BC10 v2(158.48,137)
M_B_DQ29: length 89.9
  TOP w0.102: v2(152.38,71.07) 152.25,70.95 151.96,70.95 151.71,71.2 151.71,72.5 151.96,72.75 152.52,72.75 152.64,72.86 152.64,73.19 152.55,73.28 151.99,73.28 151.85,73.42 JDIMM4.84
  IN10 w0.076: 159.49,128.87 159.49,129.11 159.63,129.25 159.63,134.08 159.92,134.37 159.92,135.4 159.78,135.54 159.78,136.62 v2(159.4,137)
  IN10 w0.13: v2(152.38,71.07) 152.38,71.1 151.38,72.1 151.38,93.55 150.82,94.11 150.49,94.11 150.17,94.43 150.17,99.58 150.3,99.7 150.89,99.7 151.01,99.83 151.01,100.09 150.89,100.22 150.3,100.22 150.17,100.35 150.17,100.61 150.3,100.74 150.89,100.74 151.01,100.87 151.01,101.13 150.89,101.26 150.3,101.26 150.17,101.39 150.17,101.65 150.3,101.78 150.89,101.78 151.01,101.9 151.01,102.17 150.89,102.29 150.3,102.29 150.17,102.42 150.17,102.69 150.3,102.81 150.89,102.81 151.01,102.94 151.01,103.2 150.89,103.33 150.3,103.33 150.17,103.46 150.17,103.72 150.3,103.85 150.89,103.85 151.01,103.98 151.01,104.23 150.89,104.36 150.3,104.36 150.17,104.49 150.17,104.75 150.3,104.88 150.88,104.88 151.01,105.01 151.01,117.82 156.05,122.86 156.05,123.4 159.49,126.84 159.49,128.87
  BOTTOM w0.102: v2(152.38,71.07) 153.36,70.09 153.36,67.46 153.55,67.27 JDIMM3.84
  BOTTOM w0.14: U1.BB10 v2(159.4,137)
M_B_DQ30: length 90.6
  TOP w0.102: JDIMM4.70 148.35,73.21 148.99,72.57 148.99,70.44 150.26,69.17 v2(150.48,69.17)
  IN10 w0.076: 157.79,132.88 157.79,133.26 157.92,133.4 157.92,133.99 158.48,134.55 v2(158.48,135.05)
  IN10 w0.13: v2(150.48,69.17) 150.19,69.17 149.77,69.59 149.77,70.15 149.32,70.59 149.32,73.47 148.82,73.98 148.82,75.4 149.13,75.72 149.13,78.52 148.63,79.02 148.63,80.07 148.79,80.24 148.79,85.72 148.28,86.23 148.28,87.56 148.79,88.07 148.79,90.2 148.66,90.33 148.56,90.33 148.43,90.46 148.43,90.72 148.56,90.85 148.66,90.85 148.79,90.98 148.79,91.24 148.66,91.37 148.56,91.37 148.43,91.5 148.43,91.76 148.56,91.89 148.66,91.89 148.79,92.02 148.79,93.22 148.12,93.89 148.12,94.87 147.99,95 147.76,95 147.64,95.13 147.64,95.39 147.76,95.52 147.99,95.52 148.12,95.65 148.12,95.91 147.99,96.04 147.77,96.04 147.64,96.17 147.64,96.43 147.77,96.56 147.99,96.56 148.12,96.69 148.12,96.94 147.99,97.07 147.76,97.07 147.64,97.2 147.64,97.46 147.76,97.59 147.99,97.59 148.12,97.72 148.12,97.98 147.99,98.11 147.76,98.11 147.64,98.23 147.64,98.5 147.76,98.63 147.99,98.63 148.12,98.75 148.12,99.02 147.99,99.14 147.76,99.14 147.64,99.27 147.64,99.53 147.76,99.66 147.99,99.66 148.12,99.79 148.12,100.05 147.99,100.18 147.76,100.18 147.64,100.31 147.64,100.57 147.76,100.7 147.99,100.7 148.12,100.83 148.12,116.87 147.99,117 147.76,117 147.64,117.12 147.64,117.4 147.76,117.53 147.99,117.53 148.12,117.66 148.12,117.88 153.83,123.59 153.84,123.61 153.84,124.13 157.64,127.93 157.64,132.08 157.79,132.23 157.79,132.88
  BOTTOM w0.102: v2(150.48,69.17) 150.6,69.29 150.77,69.29 150.9,69.17 150.9,68.26 150.77,68.13 150.51,68.13 150.39,68 150.39,67.9 150.28,67.8 150.14,67.8 150.03,67.9 150.03,68.08 149.94,68.18 149.82,68.18 149.7,68.05 149.7,67.63 149.79,67.54 150.47,67.54 150.56,67.45 150.56,67.32 150.47,67.23 150.18,67.23 150.05,67.1 JDIMM3.70
  BOTTOM w0.14: U1.BC7 v2(158.48,135.05)
M_B_DQ31: length 92.7
  TOP w0.102: v2(150.48,72.34) 150.51,72.34 150.92,71.93 150.92,68.31 149.95,67.33 148.96,67.33 148.6,66.97 JDIMM4.71
  IN10 w0.076: v2(159.4,135.05) 159.4,134.52 159.22,134.34 159.22,129.61 158.97,129.37
  IN10 w0.13: v2(150.48,72.34) 150.71,72.58 150.71,86.18 150.58,86.31 150.08,86.31 149.96,86.43 149.96,86.7 150.08,86.83 150.58,86.83 150.71,86.95 150.71,92.24 150.58,92.37 149.98,92.37 149.85,92.5 149.85,93.8 149.45,94.2 149.45,110.71 149.58,110.84 150.17,110.84 150.3,110.96 150.3,111.23 150.17,111.35 149.58,111.35 149.45,111.48 149.45,111.75 149.58,111.87 150.17,111.87 150.3,112 150.3,112.26 150.17,112.39 149.58,112.39 149.45,112.52 149.45,112.78 149.58,112.91 150.17,112.91 150.3,113.04 150.3,113.3 150.17,113.43 149.58,113.43 149.45,113.55 149.45,113.82 149.58,113.95 150.17,113.95 150.3,114.07 150.3,114.34 150.17,114.46 149.58,114.46 149.45,114.59 149.45,114.85 149.58,114.98 150.17,114.98 150.3,115.11 150.3,115.37 150.17,115.5 149.58,115.5 149.45,115.63 149.45,115.89 149.58,116.02 150.17,116.02 150.3,116.15 150.3,118.17 155.24,123.12 155.24,123.52 158.97,127.26 158.97,129.37
  BOTTOM w0.102: JDIMM3.71 150.3,73.42 150.17,73.29 149.87,73.29 149.74,73.16 149.74,72.72 149.87,72.59 150.08,72.59 150.27,72.77 150.8,72.77 151.01,72.99 151.01,73.11 151.14,73.24 151.33,73.24 151.51,73.06 151.51,71.5 151.38,71.38 151.14,71.38 151.01,71.5 151.01,72.28 150.81,72.48 150.61,72.48 v2(150.48,72.34)
  BOTTOM w0.14: U1.BB7 v2(159.4,135.05)
M_B_DQ32: length 87.1
  TOP w0.102: v2(181.39,69.04) 181.29,69.14 181.07,69.14 180.92,68.99 180.92,68.25 180.31,67.64 179.45,67.64 179.32,67.52 179.32,67.37 179.22,67.28 179.08,67.28 178.99,67.37 178.99,67.54 178.89,67.64 178.72,67.64 178.6,67.52 JDIMM4.183
  IN10 w0.076: v2(175.86,137.65) 176.39,137.12 176.39,135.62 176.68,135.34 176.68,134.47 177.16,133.99 177.16,129.06 180.88,125.34 180.88,125.23
  IN10 w0.13: v2(181.39,69.04) 181.87,69.52 181.87,75.55 182.21,75.9 182.21,78.31 184.5,80.6 184.5,87.87 185.36,88.74 185.36,92.96 184.79,93.54 184.79,100.66 184.66,100.79 184.35,100.79 184.23,100.92 184.23,101.18 184.35,101.31 184.66,101.31 184.79,101.44 184.79,117.12 181.69,120.22 181.69,123.67 180.88,124.48 180.88,125.23
  BOTTOM w0.102: JDIMM3.183 180.3,72.8 180.62,72.48 180.62,69.81 v2(181.39,69.04)
  BOTTOM w0.14: U1.AA11 v2(175.86,137.65)
M_B_DQ33: length 86.7
  TOP w0.102: JDIMM4.186 179.35,73.45 180.77,72.04 180.77,71.91 180.69,71.83 180.42,71.83 180.32,71.73 180.32,71.04 180.42,70.94 180.64,70.94 180.74,71.04 180.74,71.3 180.82,71.38 181.32,71.38 181.39,71.44 v2(181.39,71.58)
  IN10 w0.076: 180.49,125.1 180.49,125.44 176.96,128.97 176.96,133.9 176.5,134.35 176.5,135.3 176.24,135.56 176.24,136.62 v2(175.86,137)
  IN10 w0.13: 180.49,125.1 180.49,124.31 181.15,123.65 181.15,120.25 184.43,116.97 184.43,106.09 184.3,105.96 184,105.96 183.87,105.83 183.87,105.57 184,105.44 184.3,105.44 184.43,105.31 184.43,105.05 184.3,104.92 184,104.92 183.87,104.79 183.87,104.53 184,104.4 184.3,104.4 184.43,104.27 184.43,104.02 184.3,103.89 184,103.89 183.87,103.76 183.87,103.5 184,103.37 184.3,103.37 184.43,103.24 184.43,102.98 184.3,102.85 184,102.85 183.87,102.72 183.87,102.46 184,102.33 184.3,102.33 184.43,102.2 184.43,101.94 184.3,101.81 184,101.81 183.99,101.81 183.87,101.68 183.87,95.43 183.99,95.3 184.33,95.3 184.46,95.18 184.46,88.3 184.12,87.96 184.12,80.72 181.83,78.44 181.83,76.13 181.39,75.68 v2(181.39,71.58)
  BOTTOM w0.102: v2(181.39,71.58) 181.79,71.17 181.79,68.87 181.05,68.13 JDIMM3.186
  BOTTOM w0.14: U1.AA10 v2(175.86,137)
M_B_DQ34: length 89.2
  TOP w0.102: v2(178.09,69.04) 178.63,69.59 178.63,71.69 178.19,72.13 176.76,72.13 175.35,73.54 JDIMM4.170
  IN10 w0.076: 175.74,126.44 175.6,126.58 175.6,126.95 174.72,127.83 174.72,134.3 174.26,134.77 174.26,135.45 174.41,135.6 174.41,136.77 174.49,136.86 174.49,137.2 v2(174.94,137.65)
  IN10 w0.13: v2(178.09,69.04) 177,70.13 177,78.43 179.32,80.75 179.32,89.79 180.16,90.63 180.16,92.97 180.03,93.1 180.03,112 179.35,112.67 179.35,117.24 178.03,118.57 178.03,122.28 176.52,123.78 176.52,125.66 175.74,126.44
  BOTTOM w0.076: U1.AC11 v2(174.94,137.65)
  BOTTOM w0.102: v2(178.09,69.04) 178.09,69.38 177.69,69.78 175.76,69.78 175.64,69.65 175.64,67.52 175.76,67.39 176.92,67.39 177.05,67.26 JDIMM3.170
M_B_DQ35: length 87.6
  TOP w0.102: v2(178.09,70.31) 177.79,70.31 177.46,69.98 177.46,69.84 177.58,69.72 177.58,69.55 177.46,69.43 177.3,69.43 177.18,69.55 177.03,69.55 176.89,69.41 176.89,69.26 177.08,69.07 177.08,68.9 176.96,68.78 176.79,68.78 176.6,68.97 176.46,68.97 176.3,68.81 176.3,67.69 176.1,67.5 JDIMM4.173
  IN10 w0.076: 175.95,126.53 175.8,126.67 175.8,127.01 174.92,127.88 174.92,134.31 174.41,134.83 174.41,135.38 174.56,135.54 174.56,136.62 v2(174.94,137)
  IN10 w0.13: v2(178.09,70.31) 177.33,71.06 177.33,78.13 180.18,80.98 180.18,90.12 180.52,90.46 180.52,93.42 180.38,93.55 180.38,102.28 180.51,102.4 180.97,102.4 181.09,102.53 181.09,102.79 180.97,102.92 180.51,102.92 180.38,103.05 180.38,103.31 180.51,103.44 180.96,103.44 181.09,103.57 181.09,103.83 180.96,103.96 180.51,103.96 180.38,104.08 180.38,104.35 180.51,104.48 180.96,104.48 181.09,104.6 181.09,104.86 180.96,104.99 180.51,104.99 180.38,105.12 180.38,112.14 179.71,112.82 179.71,117.39 178.38,118.72 178.38,122.43 176.83,123.98 176.83,125.64 175.95,126.53
  BOTTOM w0.102: v2(178.09,70.31) 178.38,70.31 178.51,70.44 178.51,71.74 178.25,71.99 177.31,71.99 176.93,72.37 176.93,73.08 177.16,73.31 177.53,73.31 177.8,73.58 JDIMM3.173
  BOTTOM w0.14: U1.AC10 v2(174.94,137)
M_B_DQ36: length 86.9
  TOP w0.14: JDIMM4.182 178.35,73.41 178.22,73.28 177.54,73.28 177.41,73.16 177.41,73 177.54,72.88 178.58,72.88 178.93,73.23 179.11,73.23 179.33,73.02 179.33,72.73 179.2,72.61 179.17,72.61 179.04,72.48 179.04,72.27 179.34,71.96 v2(179.74,71.96)
  IN10 w0.076: v2(175.86,135.05) 175.98,134.93 175.98,128.46 179.62,124.82
  IN10 w0.13: v2(179.74,71.96) 180.12,71.96 180.56,72.41 180.56,78.18 182.85,80.47 182.85,87.89 183.71,88.75 183.71,93.08 183.59,93.21 183.27,93.21 183.14,93.34 183.14,111 183.27,111.13 183.59,111.13 183.71,111.25 183.71,111.52 183.59,111.64 183.19,111.64 183.06,111.77 183.06,112.34 182.93,112.46 182.67,112.46 182.54,112.59 182.54,112.85 182.67,112.98 183.09,112.98 183.21,113.11 183.21,113.37 183.09,113.5 182.67,113.5 182.54,113.63 182.54,113.89 182.67,114.02 183.09,114.02 183.21,114.14 183.21,114.41 183.09,114.54 182.67,114.54 182.55,114.66 182.55,114.93 182.67,115.05 183.09,115.05 183.21,115.18 183.21,115.45 183.09,115.57 182.63,115.57 182.5,115.7 182.5,115.96 182.63,116.09 183.09,116.09 183.21,116.22 183.21,116.48 183.09,116.61 182.6,116.61 182.47,116.74 182.47,117 182.6,117.13 182.78,117.13 182.91,117.26 182.91,117.47 180.43,119.96 180.43,123.28 179.62,124.09 179.62,124.82
  BOTTOM w0.102: JDIMM3.182 180.05,68.08 180.25,68.28 180.25,71.45 v2(179.74,71.96)
  BOTTOM w0.14: U1.AA7 v2(175.86,135.05)
M_B_DQ37: length 86.9
  TOP w0.102: JDIMM4.187 179.6,67.13 179.74,67.26 180.36,67.26 181.9,68.8 181.9,69.8 v2(181.39,70.31)
  IN10 w0.076: 180.09,125.15 180.09,125.52 176.75,128.86 176.75,133.88 176.35,134.29 176.35,135.21 v2(175.86,135.7)
  IN10 w0.13: 180.09,125.15 180.09,124.12 180.79,123.42 180.79,120.1 183.57,117.32 183.57,114.28 183.7,114.15 183.71,114.15 183.84,114.02 183.84,113.76 183.71,113.63 183.7,113.63 183.57,113.5 183.57,113.24 183.7,113.11 183.71,113.11 183.84,112.98 183.84,112.72 183.71,112.59 183.7,112.59 183.57,112.46 183.57,112.17 184.07,111.67 184.07,110.77 183.94,110.64 183.63,110.64 183.5,110.51 183.5,110.25 183.63,110.12 183.94,110.12 184.07,109.99 184.07,109.73 183.94,109.6 183.63,109.6 183.5,109.48 183.5,109.21 183.63,109.08 183.94,109.08 184.07,108.96 184.07,108.69 183.94,108.57 183.63,108.57 183.5,108.44 183.5,108.18 183.63,108.05 183.94,108.05 184.07,107.92 184.07,107.66 183.94,107.53 183.63,107.53 183.5,107.4 183.5,107.14 183.63,107.01 183.94,107.01 184.07,106.88 184.07,106.62 183.94,106.49 183.64,106.49 183.51,106.36 183.51,94.31 183.64,94.19 183.97,94.19 184.1,94.06 184.1,88.53 183.74,88.17 183.74,80.85 180.94,78.06 180.94,70.76 v2(181.39,70.31)
  BOTTOM w0.102: v2(181.39,70.31) 180.96,70.74 180.96,71.89 181.12,72.04 181.53,72.04 181.64,72.15 181.64,72.31 181.53,72.42 181.07,72.42 180.96,72.53 180.96,72.57 180.84,72.69 180.84,73.08 180.97,73.21 181.17,73.21 181.3,73.33 JDIMM3.187
  BOTTOM w0.14: U1.AA8 v2(175.86,135.7)
M_B_DQ38: length 87.4
  TOP w0.102: v2(178.09,71.58) 175.99,69.49 175.99,67.86 175.1,66.97 JDIMM4.169
  IN10 w0.076: 176.12,126.65 175.99,126.78 175.99,127.07 175.91,127.15 175.13,127.93 175.13,134.33 174.56,134.89 174.56,135.32 v2(174.94,135.7)
  IN10 w0.13: v2(178.09,71.58) 177.67,72 177.67,77.95 180.56,80.85 180.56,90.03 180.97,90.44 180.97,93.09 181.45,93.58 181.45,105.35 181.32,105.48 180.87,105.48 180.74,105.61 180.74,105.87 180.87,106 181.32,106 181.45,106.13 181.45,106.39 181.32,106.52 180.87,106.52 180.74,106.64 180.74,106.91 180.87,107.04 181.32,107.04 181.45,107.16 181.45,107.42 181.32,107.55 180.87,107.55 180.74,107.68 180.74,107.94 180.87,108.07 181.32,108.07 181.45,108.2 181.45,108.46 181.32,108.59 180.87,108.59 180.74,108.72 180.74,108.98 180.87,109.11 181.32,109.11 181.45,109.24 181.45,109.5 181.32,109.63 180.87,109.63 180.74,109.75 180.74,112.29 180.07,112.97 180.07,117.54 178.74,118.87 178.74,122.57 177.16,124.16 177.16,125.6 176.12,126.65
  BOTTOM w0.102: v2(178.09,71.58) 177.59,71.58 177.25,71.24 177.25,70.72 177.12,70.59 176.43,70.59 176.04,70.98 176.04,72.74 176.8,73.5 JDIMM3.169
  BOTTOM w0.14: U1.AC8 v2(174.94,135.7)
M_B_DQ39: length 88.5
  TOP w0.102: v2(179.74,68.79) 179.6,68.79 178.94,69.45 178.94,71.83 178.23,72.55 177.18,72.55 176.35,73.38 JDIMM4.174
  IN10 w0.076: v2(174.94,135.05) 174.94,134.81 175.33,134.42 175.33,127.98 176.14,127.18 176.14,126.92 176.36,126.7
  IN10 w0.13: v2(179.74,68.79) 179.23,68.79 178.59,69.42 178.59,78.25 180.94,80.6 180.94,89.87 181.81,90.73 181.81,109.86 181.68,109.98 181.23,109.98 181.1,110.11 181.1,110.38 181.23,110.5 181.68,110.5 181.81,110.63 181.81,110.85 181.68,110.97 181.23,110.97 181.1,111.1 181.1,112.44 180.43,113.12 180.43,117.69 179.1,119.02 179.1,122.72 177.49,124.33 177.49,125.57 176.36,126.7
  BOTTOM w0.102: JDIMM3.174 178.05,67.11 177.92,67.24 177.54,67.24 176.98,67.8 176.27,67.8 176.14,67.92 176.14,68.3 176.32,68.48 177.87,68.48 178.05,68.3 179.57,68.3 179.74,68.46 v2(179.74,68.79)
  BOTTOM w0.14: U1.AC7 v2(174.94,135.05)
M_B_DQ40: length 91.2
  TOP w0.102: v2(183.29,71.58) 183.76,71.11 183.76,68.5 182.8,67.53 181.61,67.53 181.3,67.23 180.83,67.23 180.6,67 JDIMM4.191
  IN10 w0.076: 182.24,124.62 182.24,124.81 177.69,129.35 177.69,134.43 177.3,134.82 177.3,135.25 177.68,135.63 v2(177.68,135.7)
  IN10 w0.13: v2(183.29,71.58) 183.29,75.21 184.12,76.04 184.12,78.18 186.15,80.22 186.15,87.64 187.02,88.5 187.02,93.79 187.18,93.96 187.18,100.41 187.05,100.53 186.54,100.53 186.41,100.66 186.41,100.93 186.54,101.05 187.05,101.05 187.18,101.18 187.18,101.44 187.05,101.57 186.54,101.57 186.41,101.7 186.41,101.96 186.54,102.09 187.05,102.09 187.18,102.21 187.18,102.48 187.05,102.6 186.54,102.6 186.41,102.73 186.41,103 186.54,103.12 187.05,103.12 187.18,103.25 187.18,103.51 187.05,103.64 186.54,103.64 186.41,103.77 186.41,104.03 186.54,104.16 186.86,104.16 186.99,104.29 186.99,104.55 186.86,104.68 186.54,104.68 186.41,104.8 186.41,117.67 182.96,121.13 182.96,123.9 182.24,124.62
  BOTTOM w0.102: v2(183.29,71.58) 183.29,71.99 183.17,72.11 182.99,72.11 182.86,71.99 182.86,70.28 182.76,70.18 182.63,70.18 182.53,70.28 182.53,72.62 182.66,72.75 182.82,72.75 182.94,72.88 182.94,73.19 182.82,73.32 182.48,73.32 182.3,73.5 JDIMM3.191
  BOTTOM w0.14: U1.W8 v2(177.68,135.7)
M_B_DQ41: length 89.7
  TOP w0.102: v2(184.94,68.66) 184.75,68.66 184.53,68.89 184.53,69.24 184.4,69.37 184.2,69.37 184.07,69.24 184.07,68.08 183.22,67.23 181.74,67.23 181.6,67.09 JDIMM4.195
  IN10 w0.076: v2(177.68,135.05) 177.68,134.66 177.87,134.47 177.87,129.39 182.59,124.67
  IN10 w0.13: 182.59,124.67 183.31,123.95 183.31,121.28 186.77,117.82 186.77,108.23 186.9,108.11 187.04,108.11 187.17,107.98 187.17,107.72 187.04,107.59 186.9,107.59 186.77,107.46 186.77,107.23 186.9,107.1 187.41,107.1 187.54,106.98 187.54,106.71 187.41,106.58 186.9,106.58 186.77,106.46 186.77,106.19 186.9,106.07 187.41,106.07 187.54,105.94 187.54,105.68 187.41,105.55 186.9,105.55 186.77,105.43 186.77,105.16 186.9,105.04 187.41,105.04 187.54,104.91 187.54,93.84 187.37,93.68 187.37,88.39 186.48,87.5 186.48,85.78 187.17,85.09 187.17,80.72 184.5,78.06 184.5,75.95 183.74,75.19 183.74,69.87 v2(184.94,68.66)
  BOTTOM w0.102: JDIMM3.195 183.3,72.41 183.7,72.01 183.7,70.34 184,70.03 184,69.6 v2(184.94,68.66)
  BOTTOM w0.14: U1.W7 v2(177.68,135.05)
M_B_DQ42: length 90.8
  TOP w0.102: v2(186.6,71.58) 187,71.17 187,68.87 186.76,68.63 186.43,68.63 186.12,68.94 185.91,68.94 185.76,68.79 185.76,68.41 184.6,67.25 JDIMM4.207
  IN10 w0.076: v2(178.6,137) 178.82,137 178.98,136.84 178.98,135.58 179.19,135.37 179.19,134.39 179.44,134.15 179.44,130.16 184.3,125.3 184.53,125.3
  IN10 w0.13: v2(186.6,71.58) 186.68,71.67 186.68,75.21 187.12,75.64 187.55,75.64 187.67,75.77 187.67,78.06 190.6,80.98 190.6,85.8 189.73,86.67 189.73,86.86 189.86,86.99 190.06,86.99 190.19,87.12 190.19,87.38 190.06,87.51 189.86,87.51 189.73,87.64 189.73,87.9 189.86,88.03 190.06,88.03 190.19,88.16 190.19,88.42 190.06,88.55 189.86,88.55 189.73,88.68 189.73,90.18 189.86,90.3 190.09,90.3 190.21,90.43 190.21,90.69 190.09,90.82 189.86,90.82 189.73,90.95 189.73,91.21 189.86,91.34 190.09,91.34 190.21,91.47 190.21,91.73 190.09,91.86 189.86,91.86 189.73,91.99 189.73,93.07 189.84,93.17 189.84,117.69 185.36,122.17 185.36,124.46 184.53,125.3
  BOTTOM w0.102: JDIMM3.207 186.3,73.58 185.74,73.02 184.02,73.02 183.91,72.9 183.91,72.67 184.04,72.54 185.13,72.54 185.36,72.31 185.36,71.48 185.49,71.35 185.87,71.35 186.1,71.58 v2(186.6,71.58)
  BOTTOM w0.14: v2(178.6,137) U1.V10
M_B_DQ43: length 89.7
  TOP w0.102: JDIMM4.204 183.85,73.55 185.83,71.57 185.83,69.81 v2(186.6,69.04)
  IN10 w0.076: v2(178.6,137.65) 179.13,137.12 179.13,135.64 179.42,135.36 179.42,134.47 179.65,134.24 179.65,130.23 184.32,125.56 184.78,125.56
  IN10 w0.13: 184.78,125.56 185.72,124.62 185.72,122.32 190.19,117.84 190.19,93.34 190.57,92.96 190.57,86.52 190.95,86.14 190.95,80.83 188.06,77.93 188.06,75.39 187.93,75.26 187.28,75.26 187.08,75.07 187.08,69.53 v2(186.6,69.04)
  BOTTOM w0.102: JDIMM3.204 185.55,67.1 185.42,67.23 185,67.23 184.91,67.32 184.91,67.45 185,67.54 185.63,67.54 185.94,67.23 186.08,67.23 186.18,67.33 186.18,68.16 186.3,68.28 186.46,68.28 186.58,68.16 186.58,68.03 186.69,67.92 186.84,67.92 186.94,68.03 186.94,68.91 186.82,69.04 v2(186.6,69.04)
  BOTTOM w0.14: v2(178.6,137.65) U1.V11
M_B_DQ44: length 89.9
  TOP w0.102: JDIMM4.190 180.35,73.58 182.58,71.35 182.58,70.59 182.89,70.29 182.89,69.45 v2(183.29,69.04)
  IN10 w0.076: v2(177.68,137.65) 177.16,137.13 177.16,136.69 177.15,136.68 177.15,135.58 176.98,135.41 176.98,134.45 177.34,134.09 177.34,129.16 181.27,125.23 181.27,124.92
  IN10 w0.13: 181.27,124.92 181.27,124.74 182.24,123.78 182.24,120.83 185.7,117.37 185.7,95.78 185.82,95.66 186.28,95.66 186.4,95.53 186.4,95.26 186.28,95.14 185.82,95.14 185.7,95.01 185.7,94.75 185.82,94.62 186.34,94.62 186.46,94.49 186.46,94.18 185.84,93.56 185.84,88.27 185.39,87.82 185.39,80.47 182.85,77.93 182.85,75.95 182.49,75.59 182.49,69.84 v2(183.29,69.04)
  BOTTOM w0.102: v2(183.29,69.04) 183.04,69.04 182.89,69.19 182.89,69.77 182.78,69.88 182.64,69.88 182.53,69.77 182.53,68.52 182.67,68.38 183.19,68.38 183.31,68.26 183.31,68.09 183.19,67.97 182.65,67.97 182.05,67.38 JDIMM3.190
  BOTTOM w0.14: v2(177.68,137.65) U1.W11
M_B_DQ45: length 88.2
  TOP w0.102: v2(183.29,70.31) 182.89,70.72 182.89,71.62 181.35,73.16 JDIMM4.194
  IN10 w0.076: 181.66,124.92 181.66,125.1 177.51,129.24 177.51,134.32 177.15,134.68 177.15,135.35 177.3,135.5 177.3,136.62 v2(177.68,137)
  IN10 w0.13: 181.66,124.92 181.66,124.77 182.6,123.83 182.6,120.98 186.06,117.52 186.06,100.31 186.19,100.18 186.58,100.18 186.71,100.05 186.71,99.79 186.58,99.66 186.19,99.66 186.06,99.53 186.06,99.25 186.18,99.12 186.69,99.12 186.82,99 186.82,98.73 186.69,98.6 186.18,98.6 186.06,98.48 186.06,98.21 186.18,98.09 186.69,98.09 186.82,97.96 186.82,97.7 186.69,97.57 186.18,97.57 186.06,97.44 186.06,97.18 186.18,97.05 186.69,97.05 186.82,96.92 186.82,96.66 186.69,96.53 186.18,96.53 186.06,96.4 186.06,96.14 186.18,96.01 186.69,96.01 186.82,95.89 186.82,94.07 186.17,93.42 186.17,88.13 185.77,87.73 185.77,80.34 183.74,78.31 183.74,76.13 182.85,75.24 182.85,70.59 183.13,70.31 v2(183.29,70.31)
  BOTTOM w0.102: v2(183.29,70.31) 183.7,69.9 183.7,68.88 183.62,68.79 183.62,67.97 183.32,67.67 183.05,67.67 182.87,67.49 182.87,67.15 183.05,66.97 JDIMM3.194
  BOTTOM w0.14: v2(177.68,137) U1.W10
M_B_DQ46: length 90.6
  TOP w0.102: JDIMM4.203 183.6,66.97 184.65,68.02 184.94,68.02 185.45,68.53 185.45,71.33 v2(184.94,71.83)
  IN10 w0.076: 183.53,125.2 183.29,125.44 182.69,125.44 178.45,129.68 178.45,134.9 v2(178.6,135.05)
  IN10 w0.13: 183.53,125.2 184.65,124.09 184.65,121.83 188.11,118.37 188.11,118.16 188.23,118.03 188.49,118.03 188.61,117.9 188.61,117.64 188.49,117.51 188.23,117.51 188.11,117.38 188.11,117.12 188.23,116.99 188.64,116.99 188.77,116.86 188.77,116.6 188.64,116.48 188.36,116.48 188.26,116.37 188.26,116.11 188.58,115.78 188.58,113.79 188.87,113.5 188.87,92.99 189.04,92.82 189.04,92.37 188.91,92.24 188.57,92.24 188.44,92.11 188.44,91.85 188.57,91.72 188.91,91.72 189.04,91.59 189.04,91.33 188.91,91.2 188.57,91.2 188.44,91.07 188.44,90.81 188.57,90.69 188.91,90.69 189.04,90.56 189.04,88.46 188.91,88.33 188.57,88.33 188.44,88.2 188.44,87.94 188.57,87.81 188.91,87.81 189.04,87.68 189.04,87.43 188.91,87.3 188.39,87.3 188.26,87.17 188.26,86.9 188.39,86.78 188.91,86.78 189.04,86.65 189.04,86.41 188.94,86.31 188.69,86.31 188.59,86.21 188.59,86.03 188.69,85.93 189.07,85.93 189.2,85.8 189.2,80.85 186.15,77.8 186.15,75.79 186.01,75.64 186.01,72.38 185.46,71.83 v2(184.94,71.83)
  BOTTOM w0.102: v2(184.94,71.83) 184.53,71.42 184.53,70.95 184.4,70.82 184.17,70.82 184.04,70.95 184.04,72.1 183.6,72.54 183.6,73.19 183.73,73.32 185.17,73.32 185.3,73.45 JDIMM3.203
  BOTTOM w0.14: U1.V7 v2(178.6,135.05)
