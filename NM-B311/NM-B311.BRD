# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCIO: length 122.3
  TOP w0.508: 185.39,145.75 185.01,146.13 185.01,148.29 184.29,149.01 v2(184.29,149.71)
  IN03 w0.508: v2(135.91,158.42) 136.24,158.09 136.24,149.3 137.64,147.91 137.64,140.92 136.11,139.4 131.16,139.4 130.65,138.89 v2(130.65,138)
  IN08 w0.508: v2(196.56,131.27) 198.17,132.88 198.17,148.37 200.25,150.45 200.25,153.62 199.99,153.88 v2(199.99,162.51)
  BOTTOM w0.097: 185.76,141.94 U1.G17 185.76,142.5 ; 185.03,142.53 U1.H17 ; U1.H17 185.66,141.91 ; U1.H17 185.03,141.91 ; U1.H17 185.66,142.53 ; U1.J15 184.69,140.27 184.7,140.26 ; U1.J15 185.01,140.33 ; U1.J15 185.01,140.96 ; U1.J15 184.38,140.96 ; U1.J15 184.54,140.49 184.35,140.49 ; U1.J16 185.01,141.74 ; U1.J16 184.38,141.74 ; U1.J16 184.38,141.12 ; U1.J16 185.01,141.12 ; 185.03,140.96 U1.H15 ; U1.H15 185.66,140.33 ; U1.H15 185.66,140.96 ; U1.H15 185.03,140.33 ; 184.38,142.53 U1.J17 ; U1.J17 185.01,141.91 ; U1.J17 185.01,142.53 ; U1.J17 184.38,141.91 ; U1.H16 185.66,141.74 ; U1.H16 185.03,141.74 ; U1.H16 185.03,141.12 ; U1.H16 185.66,141.12 ; 185.76,140.93 U1.G15 185.76,140.36
  BOTTOM w0.127: 184.38,145.06 U1.J21 ; U1.J21 185.01,145.06 ; U1.J21 184.38,145.68 ; U1.J21 185.01,145.68 ; U1.J20 185.01,144.89 ; U1.J20 185.01,144.27 ; U1.J20 184.38,144.27 ; U1.J20 184.38,144.89 ; 185.03,144.11 U1.H19 ; U1.H19 185.66,144.11 ; U1.H19 185.03,143.48 ; U1.H19 185.66,143.48 ; U1.J27 185.01,150.41 ; U1.J27 184.38,150.41 ; U1.J27 185.01,149.78 ; U1.J27 184.38,149.78 ; 185.76,144.08 U1.G19 185.76,143.51 ; U1.J26 185.01,149 ; U1.J26 185.01,149.62 ; U1.J26 184.38,149.62 ; U1.J26 184.38,149 ; U1.H20 185.66,144.27 ; U1.H20 185.66,144.89 ; U1.H20 185.03,144.89 ; U1.H20 185.03,144.27 ; U1.H21 185.66,145.06 ; U1.H21 185.03,145.06 ; U1.H21 185.66,145.68 ; U1.H21 185.03,145.68 ; 184.38,144.11 U1.J19 ; U1.J19 185.01,144.11 ; U1.J19 184.38,143.48 ; U1.J19 185.01,143.48 ; 185.03,150.41 U1.H27 185.03,149.78 ; 185.76,145.65 U1.G21 185.76,145.09 ; 185.03,149.62 U1.H26 185.03,149
  BOTTOM w0.203: v2(135.91,158.42) 135.43,157.94 PR1201.2
  BOTTOM w0.254: v2(171.28,138.28) 171.17,138.28 170.88,137.98 U1.AG12
  BOTTOM w0.457: v2(196.56,131.27) 196.44,131.27 192.17,127 R1.1
  BOTTOM w0.508: C311.2 202.66,162.35 202.66,160.61 198.47,156.42 195.17,156.42 191.23,160.35 R2.2
  vias: v1(127.48,138.64) v2(127.48,138) v2(127.48,137.24) v2(127.48,136.48) v2(127.48,135.72) v2(127.48,134.95) v2(128.37,138) v2(128.37,137.24) v2(128.37,136.48) v2(128.37,135.72) v2(128.37,134.95) v2(129.13,138) v2(129.13,137.24) v2(129.13,136.48) v2(129.13,135.72) v2(129.13,134.95) v2(129.89,138) v2(129.89,137.24) v2(129.89,136.48) v2(129.89,135.72) v2(129.89,134.95) v2(130.65,137.24) v2(130.65,136.48) v2(130.65,135.72) v2(130.65,134.95) v2(184.1,145.37) v2(184.14,144.58) v2(184.13,143.79) v2(184.1,142.22) v2(184.1,141.43) v2(184.1,140.8) v2(203.8,163.4) v2(203.8,162.77) v2(203.8,162.13) v2(204.44,163.4) v2(204.44,162.77) v2(204.44,162.13) v2(205.07,163.4) v2(205.07,162.77) v2(205.07,162.13) v2(205.07,161.5)
+VCCMPHY_1P0:
  vias: v1(240.38,76.15) v3(235.3,64.85) v3(235.99,66.17) v3(236.06,64.85) v3(237.33,65.92) v3(238.37,65.92)
+VCCPDSW_3P3: length 2.4
  BOTTOM w0.203: U2.BA24 236.11,53.67 v3(235.93,53.67)
  BOTTOM w0.508: v2(238.09,44.02) 238.86,44.78 R206.1
+VCCPFUSE_3P3:
  vias: v1(249.6,49.41)
+VCCPHVC_3P3: length 0.9
  BOTTOM w0.254: U2.AN5 245.99,57.33 v3(245.59,57.74)
  vias: v1(247.14,58.12)
+VCCPRIM_1P0: length 10.5
  BOTTOM w0.254: U2.AC28 234.54,62.53 v3(234.54,62.56) 234.54,62.61 U2.AA28 ; v3(239.11,59.52) 239.11,59.44 U2.AJ20 ; U2.AA28 234.54,63.3 v3(234.54,63.33) ; U2.AA28 235.27,62.56 v3(235.3,62.56) 235.3,62.54 U2.AC26 ; U2.AA28 235.25,63.33 v3(235.3,63.33) 235.43,63.2 235.43,63.19 U2.AA26 ; U2.AE26 235.66,61.4 v3(235.3,61.04) ; U2.AE23 237.59,61.03 v3(237.59,61.04) ; U2.AJ21 237.98,59.12 v3(237.59,59.52) 237.2,59.13 U2.AJ23 ; v3(237.59,64.09) 237.56,64.09 U2.Y23 237.2,63.71 v3(237.59,63.33) 237.22,62.96 U2.AA23 237.2,62.94 v3(237.59,62.56) U2.AC23 ; U2.Y25 v3(236.04,64.12) ; v3(235.93,58.63) 235.97,58.63 U2.AJ25
  vias: v2(268.07,67.14) v2(268.07,65.74) v2(268.7,67.14) v2(268.7,65.74) v2(269.34,67.14) v2(269.34,65.74) v2(269.97,67.14) v2(269.97,65.74) v2(270.61,67.14) v2(270.61,65.74)
+VCCPRTC_3P3: length 1.1
  BOTTOM w0.254: U2.BA22 237.33,53.79 237.33,53.88 v3(237.18,54.03)
  vias: v1(236.49,53.7)
+VCCPRTCPRIM_3P3: length 14.4
  TOP w0.356: C226.1 C227.2 237.97,52.91 v3(238.47,53.42)
  IN05 w0.254: v3(238.47,53.42) 238.35,53.55 236.82,53.55 236.57,53.29 236.57,52.02 236.19,51.64 236.19,50.37 236.39,50.17 236.39,49.53 238.09,47.83 238.09,46.36 238.73,45.72 v2(238.73,45.47)
  BOTTOM w0.254: v3(238.47,53.42) 238.6,53.3 U2.BA20
  BOTTOM w0.457: R222.2 239.19,45.93 v2(238.73,45.47)
+VCCPUSBDSW_3P3: length 0.8
  BOTTOM w0.305: U2.W15 241.01,63.81 240.63,63.43 v3(240.63,63.33)
  vias: v1(248.69,64.34) v2(251.68,64.21)
+VCCSA: length 13.7
  TOP w0.305: C934.1 182.82,153.02 v2(183.01,153.22)
  BOTTOM w0.203: U1.M32 182.62,153.54 182.62,153.54 ; v2(182.57,150.89) 182.62,150.93 U1.M29 ; U1.K30 U1.K31 184.07,153.02 184,153.02 183.8,153.22 v2(183.8,153.22) ; U1.L32 183.08,153.22 v2(183.01,153.22)
  BOTTOM w0.254: 182.94,154.52 v2(183.01,154.52) ; 182.94,154.52 182.94,154.52 U1.M33 ; 182.94,154.52 U1.M34 ; U1.L31 183.34,152.89 v2(183.01,153.22) ; U1.M35 182.94,155.17 v2(183.01,155.17) 183.08,155.17 U1.L35 ; 184.52,153.87 U1.K33 ; 184.52,153.87 U1.K32 ; 184.52,153.87 v2(184.59,153.87) ; U1.J30 184.44,151.54 U1.K29 U1.K30 ; U1.M30 U1.M29 ; v2(183.36,161.62) 183.23,161.5 PR1172.1 ; 183.08,157.12 U1.L38 ; 183.08,157.12 U1.L37 ; 183.08,157.12 v2(183.01,157.12) ; 184.52,155.17 v2(184.59,155.17) ; 184.52,155.17 U1.K35 ; 184.52,155.17 U1.K34 ; 182.62,153.54 182.94,153.87 v2(183.01,153.87) ; U1.L36 183.08,155.82 v2(183.01,155.82) 182.94,155.82 U1.M36
  BOTTOM w0.305: v2(183.01,153.22) 182.69,152.89 U1.M31
  vias: v1(203.93,174.07) v2(202.03,175.34) v2(202.03,174.58) v2(202.03,173.69) v2(202.03,172.8) v2(202.03,171.91) v2(204.18,172.67) v2(204.18,171.66) v2(204.18,170.77) v2(204.18,169.88) v2(204.18,168.99) v2(206.6,175.34) v2(206.6,174.58) v2(206.6,173.69) v2(206.6,172.8) v2(206.6,171.91)
+VCCSFR_OC: length 2.6
  TOP w0.305: v2(154.82,138.33) 154.68,138.47 C950.2
  TOP w0.381: v2(186.37,137.1) 186.38,137.11 C951.2
  BOTTOM w0.203: U1.BH13 154.5,138.63 v2(154.82,138.33)
  BOTTOM w0.305: v2(186.37,137.1) 186.05,137.43 U1.G11
  vias: v1(199.23,133.05) v2(197.58,134.06) v2(197.58,133.3)
+VCCVDDQ_CLK: length 1.3
  TOP w0.356: C949.1 177.03,137.95 v2(176.77,137.69)
  BOTTOM w0.254: U1.Y12 176.48,137.98 v2(176.77,137.69)
+VDD33_LAN: length 7.8
  TOP w0.203: U6.1 48.76,65.76 48.93,65.93
  TOP w0.356: R282.2 v2(48.48,69.8)
  TOP w0.381: v2(49.24,66.25) 48.93,65.93 ; Q35.2 52.67,73.23 v1(52.85,73.05) 53.23,72.67 R477.2 53.23,71 52.42,70.18 v2(52.42,69.93)
  TOP w0.457: v2(52.42,69.93) 52.52,69.83 R275.1
AGND: length 78.8
  TOP w0.203: 299.11,30.33 299.2,30.42 299.2,34.17 297.46,35.91 v2(297.46,36.14) ; U7.20 287.53,29.35 287.27,29.08 287.27,28.3 v2(287.47,28.09) ; v2(291.43,30.43) 291.31,30.43 290.86,30.89 290.86,31.19 291.07,31.41 U7.30 ; U7.42 291.97,36.21 292.32,36.56 292.32,37.42 v2(292.83,37.93) ; v2(297.12,33.73) 297.6,33.25 297.6,31.61 297.4,31.41
  TOP w0.254: v2(299.72,19.05) 299.08,19.05 298.83,19.3 298.83,30.05 299.11,30.33
  TOP w0.356: C315.2 294.56,28.83 v2(294.86,28.53) ; v2(295.12,36.53) 295.43,36.53 J3.2 296.1,36.5 297.1,36.5 v2(297.46,36.14) ; C317.2 v2(294.18,27.33)
  TOP w0.381: v2(297.15,13.74) 297.11,13.74 295.36,15.49 295.36,28.03 v2(294.86,28.53)
  TOP w0.457: C300.1 C301.1 290.32,26.59 v2(290.54,26.59) 290.82,26.32 R315.2 ; v2(292.83,37.93) 293.11,38.2 C307.2 C306.1 293.11,39.76 292.71,40.16 291.72,40.16 291.33,39.77 C309.2
  TOP w0.508: 297.4,31.41 297.05,31.06 v2(297.05,26.42) 297.05,16.51 v2(297.18,16.38)
  IN03 w0.254: v2(297.46,36.14) 297.41,36.14 297.02,36.53 v2(295.12,36.53)
  BOTTOM w0.254: JIO1.73 v2(299.34,15.18) ; JIO1.70 300.1,16.38 v2(299.72,16.76) ; JIO1.63 299.85,19.18 v2(299.72,19.05) ; JIO1.76 300.1,13.98 299.86,13.74 v2(299.43,13.74)
  BOTTOM w0.381: v2(297.46,36.14) 297.1,36.5 R316.2
  vias: v1(294.74,29.42)
GND: length 3517.2
  TOP w0.089: 29.43,80.72 C2139.2
  TOP w0.152: v3(242.88,125.77) 242.88,125.54 242.89,125.54 242.89,125.2 242.88,125.19 242.88,125.1 C701.2
  TOP w0.178: C1343.2 242.88,127.03 242.88,127.26 242.9,127.28 242.9,127.66 242.88,127.68 v3(242.88,127.87)
  TOP w0.203: v2(13.51,83.75) 14.14,83.75 D61.1 ; v3(256.89,141.87) 256.89,141.15 C2357.2 ; v2(15.11,78.13) 14.97,78 D66.1 ; v2(174.03,137.69) 173.72,138 C1020.2 ; v3(250.58,141.87) 250.58,140.86 C619.2 ; D60.1 14.69,82.44 v2(14.78,82.35) ; v2(46.96,61.42) 47.56,60.82 U6.27 ; C1013.2 180.34,138.29 179.74,137.69 v2(179.51,137.69) ; v2(138.34,85.8) 138.27,85.87 138.27,86.43 138.15,86.55 JDIMM2.30 ; D67.1 14.05,76.24 v2(14.4,75.9) ; C2093.2 46.34,85.97 46.69,86.33 v1(46.69,86.36) ; U2011.3 26.67,79.68 26.26,80.09 v2(26.26,80.22)
  TOP w0.254: JDIMM2.218 187.15,88.61 186.79,88.98 v2(186.6,88.98) 186.15,88.54 JDIMM2.214 ; v3(262.26,170.2) 262.34,170.12 C2489.2 ; R2211.2 249.91,170.02 C887.2 250.85,170.01 v3(250.91,169.95) ; JDIMM4.99 155.6,65.03 v2(155.16,64.6) ; v2(74.67,3.64) 75.03,3.99 C1368.2 ; v3(287.3,156.94) 287.17,157.06 C2551.2 ; JDIMM2.188 179.65,88.89 v2(179.74,88.98) ; PQ101.4 82.76,92.77 v2(83.03,93.04) ; C225.1 246.35,59.26 246.86,58.75 v3(247.03,58.75) ; C220.2 240.68,62.82 240.38,62.82 v3(239.87,63.33) ; R2216.1 232.51,172.11 v3(232.62,172) ; JDIMM4.57 145.1,64.85 v2(144.85,64.6) ; v3(237.56,123.55) 237.21,123.9 R923.2 ; JDIMM4.107 157.6,64.87 v2(157.32,64.6) 157.07,64.6 156.6,65.06 JDIMM4.103 ; JHDMI1.11 v2(7.75,132.25) ; U2027.3 204.45,199.74 204.16,199.44 v2(204.16,198.07) ; C2587.2 292.23,135.98 v3(292.23,136.72) ; C2562.2 290.86,145.38 v3(290.5,145.74) ; v1(53.82,88.33) 53.93,88.22 C2080.2 ; v3(293.7,147.34) 293.59,147.22 R2194.2 ; C2467.2 236.24,169.31 v3(236.07,169.15) ; R1017.1 68.32,81.21 68.68,80.85 68.68,79.71 68.41,79.44 Q74.1 67.78,78.99 67.61,78.82 v2(67.48,78.82) 67.02,78.82 66.78,78.57 Q74.4 ; v3(241.65,119.84) 241.8,119.69 C695.2 ; U8.33 275.46,29.95 275.18,29.67 274.8,29.67 ; C1134.1 175.03,148.03 v2(175.28,147.78) ; JDIMM2.202 183.15,88.84 v2(183.29,88.98) 183.86,88.98 184.15,88.69 JDIMM2.206 ; JDIMM4.51 v2(143.6,64.6) ; PQ1403.1 111.47,69.6 v2(112.09,68.97) ; Q100.4 v2(205.07,125.93) 205.07,125.18 205.32,124.93 Q100.1 206.04,124.59 C2685.2 ; v2(175.28,147.78) 175.54,148.03 C1054.1 ; v2(175.28,147.78) 174.98,147.48 C1135.1 174.72,146.93 C1058.1 ; v2(175.28,147.78) 175.59,147.48 C1055.1 175.86,147.17 C979.2 ; v2(21.3,39.45) 21.56,39.19 U21.14 ; C2532.2 271.25,169.27 v3(271.13,169.15) ; v2(181.39,76.28) 180.85,75.74 JDIMM4.192 ; PC191.1 v2(298.67,174.58) ; C2465.2 240.35,170.67 v3(239.92,171.1) ; v2(242.41,105.64) 242.28,105.64 242.06,105.87 R2155.1 ; JDIMM4.35 139.6,65.17 140.18,64.6 v2(140.6,64.6) JDIMM4.39 ; JDIMM2.244 193.65,88.92 v2(193.71,88.98) 194.41,88.98 194.65,88.73 JDIMM2.248 ; PC809.2 v2(293.59,190.2) ; R2208.2 239.69,121.64 v3(239.69,121.87) ; v3(297.83,139.92) 297.98,140.07 C2575.2 ; JDIMM4.243 193.6,64.77 193.77,64.6 v2(194.6,64.6) ; R869.2 281.48,170.39 C1326.2 279.51,170.38 v3(279.33,170.2) ; JDIMM2.234 191.15,88.77 191.36,88.98 v2(191.8,88.98) 192.15,88.63 JDIMM2.238 ; v2(67.02,61.93) 67.58,62.49 R425.1 ; v2(221.66,117.17) 221.91,117.43 R2166.2 ; v2(60.67,88.9) 59.86,88.9 59.58,89.18 R2119.2 ; v1(47.31,89.64) 46.65,90.3 R2048.1 ; C1056.1 172.18,146.51 171.83,146.86 v2(171.83,147.09) ; R989.1 245.41,105.24 v2(245.87,105.24) 245.87,104.14 245.58,103.86 Q76.1 245.58,102.94 245.46,102.82 244.7,102.82 244.58,102.7 Q76.4 244.58,102.2 244.32,101.93 243.86,101.93 243.55,101.63 243.55,100.66 243.76,100.46 R992.1 ; C2560.2 292.09,148.95 v3(292.1,148.94) ; R422.1 v2(76.55,72.09) ; C2680.2 301.42,83.72 v2(301.59,83.9) 301.73,83.76 Q94.1 ; Q85.1 v2(288.12,174.44) ; v2(174.06,142.32) 173.72,142.66 C1147.1 ; v2(174.06,142.32) 174.39,142.65 C1144.1 ; v2(174.06,142.32) 174.29,142.09 C1145.1 ; v2(174.06,142.32) 173.84,142.1 C1150.1 ; JDIMM4.1 v2(131.1,64.6) ; v2(187.02,149.7) 187.5,149.22 R2292.2 ; v2(190.85,151.34) 190.9,151.29 R2291.2 ; R26.1 149.12,141.48 149.64,142.01 v2(149.64,142.38) ; Q5.1 205.84,199.12 205.84,198.1 v2(205.81,198.07) 205.91,198.07 R2300.1 ; Q92.1 210.52,153.87 v2(210.66,154) ; v3(279.33,166.35) 279.39,166.42 C2511.2 ; U8.15 269.82,30.45 v2(269.84,30.43) ; JDIMM4.31 138.6,67.34 139.92,68.66 140.44,68.66 v2(140.57,68.79) ; C2534.2 267.89,167.58 v3(267.93,167.55) ; v1(47.97,89.63) 47.97,89.44 48.18,89.23 48.18,88.78 C2091.2 ; U19.E10 70.06,12.4 v1(69.89,12.4) ; R23.1 148.74,145.11 v3(148.3,145.55) ; v1(49.92,83.13) 49.82,83.23 C2107.2 ; v3(263.42,144.48) 263.8,144.11 R1021.1 ; JDIMM4.85 v2(152.1,64.6) ; JDIMM4.205 v2(184.1,64.6) 183.74,64.6 183.1,65.23 JDIMM4.201 ; C2529.2 275.2,170.63 274.98,170.86 v3(274.98,171.1) ; R2311.1 11.53,146.94 v2(11.53,147.78) ; C2484.2 250.23,177.83 v3(250.91,177.15) ; C2586.2 296.16,132.78 v3(296.23,132.72) ; v2(110.97,90) 111.26,90.29 PU401.1 ; JDIMM4.217 v2(187.1,64.6) 186.35,64.6 186.1,64.85 JDIMM4.213 ; v3(279.33,164.75) 279.59,164.49 C2525.2 ; U19.F4 U19.G4 71.6,8.72 v1(71.22,8.33) ; v3(279.38,172.2) 280.15,172.97 C2533.2 ; JDIMM2.260 197.65,88.65 197.33,88.98 v2(196.98,88.98) ; Q85.4 v2(289.39,173.44) ; Q88.1 300.97,61.79 300.83,61.93 v2(300.07,61.93) 299.61,61.47 C1332.2 ; v1(49.27,85.08) 49.23,85.08 49.02,84.86 49.02,84.84 48.85,84.67 C2108.2 48.85,84.34 48.66,84.15 C2112.2 ; R2207.2 293.75,138.39 v3(293.83,138.32) ; v2(175.86,138.94) 176.08,139.16 C1057.1 ; v3(258.11,177.15) 258.07,177.18 C2498.2 ; R2153.1 242.11,110.16 v2(241.9,110.37) ; R921.2 240.83,118.82 v3(240.48,119.17) ; C915.2 172.21,140.21 v2(171.96,140.47) ; JDP1.11 v2(11.64,157.8) ; v2(179.74,76.28) 179.85,76.17 JDIMM4.188 ; JTYPC1.1 9,83.03 9.31,83.34 v2(9.8,83.34) ; Q75.4 201.26,129.12 201.08,129.3 201.08,130.32 201.64,130.89 203.8,130.89 v2(204.06,130.64) 204.06,130.18 R996.1 ; C2557.2 295.36,149.07 v3(296.1,149.81) ; v2(53.44,10.37) 53.82,9.98 PQ1402.4 ; U8.20 269.78,27.95 v2(269.84,27.89) ; PR413.2 107.69,91.88 108.2,91.88 v2(108.25,91.82) ; U63.3 v2(302.59,71.09) ; R898.2 295.52,120.83 294.98,120.29 v3(294.62,120.29) ; JDIMM4.247 v2(194.6,64.6) ; v2(194.6,64.6) 194.94,64.6 195.6,65.26 JDIMM4.251 ; 275.05,28.15 275.24,27.95 U8.29 ; R2206.2 293.71,112.17 v3(293.82,112.29) ; U8.46 274.97,36.45 274.92,36.4 ; PU605.17 v2(80.58,48.52) ; C2552.2 294.07,157.37 293.64,156.94 v3(292.9,156.94) ; v1(51.22,88.98) 51.67,88.53 C2076.2 C2089.2 51.67,87.6 51.76,87.51 C2101.2 51.44,87.25 v1(51.22,87.03) ; JDIMM4.197 v2(182.1,64.6) ; v3(262.11,177.95) 262.25,177.81 C2482.2 ; Q94.4 302.73,82.26 v2(302.36,82.63) ; C907.2 244.47,170.01 v3(244.27,170.2) 245.03,170.96 R826.2 ; R2082.2 63.42,90.45 v2(62.96,90) ; JDIMM4.81 v2(151.1,64.6) 150.59,64.6 150.1,65.09 JDIMM4.77 ; C2461.2 244.5,166.17 v3(244.32,166.35) ; v3(255.06,173.18) 255.27,173.39 C2490.2 ; C2478.2 v2(265.32,170.36) ; JDIMM4.223 188.6,64.92 188.28,64.6 v2(188.05,64.6) ; v2(11.65,160.3) JDP1.16 ; C2449.2 C2455.2 232.4,177.48 v3(232.88,177.95) ; v1(46.67,84.43) 46.49,84.43 C2094.2 ; v3(269.51,152.73) 270.28,151.97 274.29,151.97 274.99,151.27 274.99,150.46 R1026.1 ; C2564.2 295.52,136.63 v3(296.23,135.92) ; C2683.2 v2(300.58,57.61) ; JDIMM4.27 v2(137.6,64.6) ; v3(260.51,170.75) 260.53,170.72 R2200.2 ; v2(76.55,70.69) 76.42,70.56 C496.1 ; JDIMM4.43 141.6,64.82 141.83,64.6 v2(142.6,64.6) JDIMM4.47 ; v3(288.23,136.72) 288.23,136.01 C2589.2 ; Q98.1 302.86,55.97 v2(303.37,55.45) ; v2(287.37,178.64) 287.75,178.64 288.06,178.95 PC1427.2 ; JDIMM4.235 v2(191.6,64.6) 192.12,64.6 192.6,65.08 JDIMM4.239 ; U8.10 269.82,32.95 v2(269.84,32.97) ; v1(53.82,88.98) 53.49,88.65 C2079.2 ; C1061.1 179.38,147.44 C1087.1 179.11,147.48 v2(178.81,147.78) ; JDIMM4.19 135.6,65.23 134.97,64.6 v2(134.6,64.6) JDIMM4.15 ; v3(297.83,128.72) 298.81,127.74 C2572.2 ; C2687.1 76.22,77.22 76.68,77.68 v2(76.93,77.68) ; JDP1.2 v2(11.64,153.3) ; v3(234.28,119.08) 233.9,119.08 233.75,119.23 R926.2 ; v3(295.23,128.42) 295.41,128.42 C2571.2 296.15,127.68 C2569.2 ; Q90.1 294.24,173.81 294.48,173.56 v2(294.48,173.31) 294.48,173.05 294.73,172.81 Q90.4 ; v3(296.63,117.73) 296.37,117.47 C2612.2 ; v1(55.12,88.98) 55.13,88.98 55.85,88.98 56.05,89.18 R2083.2 ; D2018.8 D2018.3 v3(15.13,153.78) ; C1088.1 178.56,148.03 v2(178.81,147.78) ; JDIMM4.189 v2(180.1,64.6) 179.67,64.6 179.1,65.17 JDIMM4.185 ; v2(302.36,77.93) 302.11,78.18 Q86.1 ; v2(274.92,32.97) 274.94,32.95 U8.39 277.32,32.95 277.46,33.1 v2(278.1,33.1) ; v3(236.87,173.15) 236.87,172.55 236.7,172.38 C2470.2 ; v3(288.9,145.74) 289.55,145.09 C2545.2 ; R2253.2 235.99,117.35 236.25,117.62 v3(237.13,117.62) ; v3(289.03,139.92) 289.15,140.04 C2580.2 ; R994.1 v2(67.15,75.77) ; PU1610.3 301.16,172.36 v2(300.96,172.16) ; PU401.3 v2(110.46,89.49) ; JDIMM4.73 v2(149.1,64.6) ; v1(53.17,88.98) 52.71,89.45 C2081.2 ; U9.24 284.47,51.62 ; R2196.2 269.45,170.68 v3(269.53,170.75) ; v2(110.97,88.98) 110.86,88.87 PU401.14 ; v3(243.99,116.97) 243.76,116.74 R660.1 ; v2(296.64,72.85) 296.39,73.1 Q91.1 ; 274.16,27.26 274.16,26.88 274.59,26.45 U8.26 ; U2029.3 208.77,162.29 v2(208.61,162.13) ; v3(292.23,113.88) 292.23,114.65 C2615.2 ; U19.H5 U19.G5 71.6,9.48 v1(71.22,9.86) 71.1,9.74 U19.F5 U19.E5 ; v3(261.39,145.77) 261.58,145.57 R1023.2 ; v2(247.36,47.45) 246.6,48.21 246.22,48.21 245.33,49.1 245.33,49.81 244.7,50.45 244.7,51.01 245.21,51.51 R934.1 ; R2302.1 205.48,193.27 v2(205.45,193.25) ; v3(299.3,145.74) 299.02,145.46 C2538.2 ; JDIMM4.175 v2(176.6,64.6) 176.12,64.6 175.6,65.11 JDIMM4.171 ; C2475.2 240.83,166.79 v3(240.87,166.75) ; JDIMM4.65 v2(147.1,64.6) 146.65,64.6 146.1,65.15 JDIMM4.61 ; v1(51.22,85.73) 51.22,85.98 C2102.2 50.89,86.31 50.64,86.31 C2090.2 ; JDIMM4.9 v2(133.1,64.6) ; v2(107.54,96.73) 107.7,96.56 U56.3 ; U9.8 281.46,49.67 ; C1059.1 178.28,146.93 C1089.1 178.51,147.48 v2(178.81,147.78) ; v2(81.25,48.52) 81.08,48.69 PU605.18 ; Q97.4 292.95,75.8 292.79,75.64 v2(292.25,75.64) 292.25,76.68 291.9,77.03 Q97.1 ; v1(46.72,82.48) 46.65,82.55 C2109.2 ; v3(255.18,129.62) 255.18,129.76 C593.2 ; v3(237.01,127.75) 236.87,127.88 R1015.2 ; C2222.2 v2(299.18,77.68) ; C1086.1 179.06,148.03 v2(178.81,147.78) ; v3(294.5,155.34) 295.06,155.34 295.4,155.67 R868.2 ; v2(11.65,162.09) 11.95,161.8 JDP1.19 ; R2054.2 56.56,88.04 56.2,87.68 v1(55.12,87.68) ; JHDMI1.8 v2(7.73,130.75) ; JDP1.8 v2(11.64,156.3) ; v2(238.98,110.44) 239.29,110.14 R2151.1 ; v3(271.13,165.15) 271.21,165.07 C2526.2 ; v3(235.27,166.75) 235.32,166.79 C2471.2 ; v3(294.63,130.32) 295.29,130.32 295.48,130.13 R899.2 ; v3(258.91,169.15) 258.8,169.26 C2492.2 ; C1342.2 v2(291.31,173.31) ; Q86.4 v2(303.74,77.18) ; JDIMM4.89 v2(153.1,64.6) ; Q101.1 287.89,171.9 288.13,171.66 v2(288.13,170.89) 288.14,170.9 Q101.4 ; Q92.4 208.75,152.62 v2(208.25,153.11) ; C1151.1 172.82,152.53 v2(172.78,152.57) ; JDIMM4.69 v2(148.1,64.6) ; v3(15.08,157.18) D2019.3 D2019.8 ; 269.84,36.53 269.77,36.45 U8.3 ; JDIMM2.210 185.15,88.77 v2(184.94,88.98) ; C1007.2 172.95,150.33 173.61,150.99 v2(173.61,151.01) ; v3(240.07,173.15) 239.99,173.06 C2468.2 ; C2530.2 275.1,173.12 v3(275.13,173.15) ; JDIMM4.227 189.6,65.21 190.21,64.6 v2(190.6,64.6) JDIMM4.231 ; JDIMM2.230 190.15,88.98 v2(190.15,88.98) ; JDIMM2.69 147.9,78.03 v2(148.38,77.55) 148.62,77.55 148.9,77.83 JDIMM2.73 ; v3(255.06,171.1) 254.58,170.62 C2497.2 ; U9.3 281.4,52.92 ; v2(180.94,146.89) 181.16,146.68 C1060.1 ; v3(288.9,156.94) 289,157.04 C2558.2 ; PC421.2 208.3,112.04 v2(208.12,112.22) ; JDIMM4.193 v2(181.1,64.6) ; v3(295.08,140.22) 295.57,140.71 R904.1 ; PR820.1 299.89,185.25 300.32,184.81 v2(300.32,184.61) ; v3(267.93,165.95) 267.65,166.22 C2516.2 ; R267.1 39.19,51.87 39.03,51.72 39.03,51.01 C237.1 ; JDIMM4.23 v2(136.6,64.6) ; v2(173.61,151.01) C984.2 ; v2(173.61,151.01) 173.84,150.77 C1008.2 ; PU1252.6 206.02,155.13 206.02,154.52 v2(206.01,154.51) ; JDIMM4.209 v2(185.1,64.6) ; R920.2 239.04,118.06 v3(239.04,117.69) ; C2686.2 v2(286.61,170.26) ; JDIMM4.5 v2(132.1,64.6) ; v3(294.9,157.04) 295.83,157.97 C2553.2 ; U9.19 284.55,48.37 ; v3(296.1,152.76) 296.24,152.62 C2556.2 ; v2(301.85,75.26) 301.97,75.26 302.47,75.76 U62.3 ; JHDMI1.17 v2(7.8,135.25) ; JDIMM4.93 v2(154.1,64.6) ; D49.3 v2(14.35,37.67) ; JDIMM4.167 174.6,64.6 v2(174.47,64.47) ; JDIMM2.252 195.65,88.52 195.36,88.82 v2(195.36,88.98) ; C1330.2 v2(304.59,57.48) ; JDIMM4.181 178.1,65.05 177.64,64.6 v2(177.51,64.6) ; JHDMI1.2 v2(7.75,127.75) ; JDIMM2.196 181.65,88.72 v2(181.39,88.98) 180.94,88.98 180.65,88.69 JDIMM2.192 ; v2(78,48.52) 78.08,48.6 PU605.12 ; JDIMM2.222 188.15,88.63 v2(188.5,88.98) 188.69,88.98 189.15,88.52 JDIMM2.226 ; C2055.2 v2(53.82,97.74) ; JDP1.5 v2(11.64,154.8) ; v1(53.82,85.73) 53.82,85.52 C2078.2 ; C1329.2 v2(301.14,59.77) 301.48,59.43 Q87.1 ; U9.4 281.39,52.27 ; C2221.2 v2(284.96,174.2) ; JHDMI1.5 v2(11.2,129.25)
  TOP w0.305: C227.1 237.66,54.03 C228.2 ; C1014.2 174.57,143.67 v2(174.06,143.15) 173.48,143.72 C983.2 ; C1015.2 177.34,143.61 v2(177.82,143.13) 178.26,143.57 C1016.2 ; v2(183.29,76.28) 183.35,76.22 JDIMM4.202 ; JDIMM4.10 133.35,76.5 133.76,76.91 v2(134.27,76.91) 134.65,76.91 134.78,76.79 134.78,75.9 134.35,75.47 JDIMM4.14 ; C1140.1 178,142.57 v2(177.74,142.32) ; JDIMM2.93 153.9,77.37 153.45,76.91 v2(152.18,76.91) ; C1040.1 179.35,156.84 v2(179.07,157.12) 178.8,156.84 C1041.1 ; C2559.2 288.01,153.65 v3(288.1,153.74) ; v2(177.74,142.32) 177.44,142.01 C1143.1 ; v2(177.74,142.32) 177.49,142.57 C1142.1 ; v2(177.74,142.32) 178.05,142.01 C1141.1 ; JTYPC1.A12 6.85,76.57 JTYPC1.B1 ; 145.88,88.98 v2(146.21,88.98) 146.65,88.54 JDIMM2.64 ; 145.88,88.98 145,88.98 144.65,88.63 JDIMM2.56 ; 145.88,88.98 145.65,88.75 JDIMM2.60 ; C655.2 241.69,137.37 v3(241.09,137.97) ; C946.1 185.52,149.65 185.58,149.7 v2(185.72,149.7) ; JDIMM4.106 157.35,75.69 v2(157.89,76.23) ; R2167.2 R2166.2 ; v2(81.38,87.84) 80.94,88.27 C2170.1 ; v2(20.57,58.83) 20.52,58.88 D54.8 D54.3 17.7,58.88 17.06,58.25 v2(16.86,58.25) ; JDIMM2.31 138.4,77.62 138.35,77.56 v2(138.35,77.55) 137.57,77.55 137.4,77.72 JDIMM2.27 ; v3(300.22,114.69) 300.24,114.71 C2610.2 ; C2613.2 295.49,114.07 v3(296.23,114.81) ; 156.18,88.98 156.94,88.98 157.15,88.77 JDIMM2.106 ; 156.18,88.98 v2(155.61,88.98) 155.42,88.98 155.15,88.72 JDIMM2.98 ; 156.18,88.98 156.15,88.95 JDIMM2.102 ; JDIMM2.176 176.65,88.76 v2(176.44,88.98) 175.74,88.98 175.65,88.89 JDIMM2.172 ; JDIMM4.180 177.85,76.04 v2(178.09,76.28) ; JDIMM2.1 130.9,78.13 131.48,77.55 v2(132.11,77.55) ; JDIMM4.56 144.85,76.75 144.69,76.91 v2(144.18,76.91) 143.67,76.91 143.54,76.79 143.54,75.77 143.85,75.46 JDIMM4.52 ; v3(275.93,168.35) 275.29,168.35 C2512.2 ; JDIMM4.168 174.85,75.38 174.4,75.82 ; 172.36,140.87 v2(171.96,140.47) ; 172.36,140.87 172.28,140.87 171.98,141.18 v2(171.93,141.18) 172.18,141.43 C1132.1 ; 172.36,140.87 C1133.1 ; v2(301.34,96.85) 300.83,97.36 PC3407.2 ; JDIMM4.94 154.35,76.93 154.92,77.5 v2(155.61,77.5) ; C2504.2 250.91,165.95 v3(250.91,165.95) ; C512.1 v2(7.21,146) ; JDIMM2.251 195.4,77.59 v2(195.36,77.55) ; C1107.1 172.5,154.24 v2(172.78,154.52) 173.06,154.24 C1106.1 ; C437.1 67.1,92.36 v2(67.66,92.92) ; v2(187.02,138.68) 186.48,138.68 C951.1 ; v2(15.08,147.27) 15.26,147.45 C2701.2 v2(15.26,149.51) ; C1146.1 177.78,154.24 v2(177.5,154.52) 177.22,154.24 C1154.1 ; C526.2 73.63,73.74 v2(73.88,73.49) ; JDIMM4.86 152.35,76.11 v2(152.18,76.28) 153.07,76.28 153.35,76 JDIMM4.90 ; v3(245.29,137.32) 244.51,137.32 C657.2 ; JDIMM2.52 143.65,89.28 143.99,89.61 v2(144.18,89.61) ; v2(183.19,141.01) 183.17,141 C1010.2 ; C2547.2 300.11,149.75 v3(300.1,149.74) ; v3(291.43,118.69) 291.43,117.97 C2614.2 ; C2620.2 297.93,122.58 v3(298.63,121.88) ; v2(155.61,77.5) 155.61,78.18 155.4,78.39 JDIMM2.99 ; v2(155.61,77.5) 156.19,77.5 156.4,77.71 JDIMM2.103 ; v2(171.83,147.09) 172.24,147.5 C987.2 ; JDIMM2.6 132.15,88.94 v2(132.11,88.98) ; v3(254.87,98.32) 255,98.45 C2672.2 ; JDIMM2.89 152.9,77.77 152.69,77.55 v2(152.18,77.55) 151.9,77.83 JDIMM2.85 ; v3(247.67,85.52) 248.39,85.52 C2679.2 ; U2030.5 v2(17.11,146.76) ; v2(81.38,84.15) 81.25,84.28 C2722.1 ; C1108.1 181.16,154.24 v2(181.44,154.52) 181.72,154.24 C1149.1 ; JDIMM2.209 184.9,77.59 v2(184.94,77.55) 185.58,77.55 185.9,77.87 JDIMM2.213 ; JDIMM2.86 152.15,88.95 v2(152.18,88.98) 153.13,88.98 ; C1152.1 178.8,154.24 v2(179.07,154.52) 179.35,154.24 C1053.1 ; JDIMM4.196 181.85,75.82 v2(181.39,76.28) ; JDIMM4.6 132.35,76.04 v2(132.11,76.28) 131.6,76.28 131.35,76.03 JDIMM4.2 ; C976.2 176.51,150.42 v2(175.93,151.01) ; JDIMM2.247 194.4,77.86 194.09,77.55 v2(193.71,77.55) 193.4,77.86 JDIMM2.243 ; JDIMM2.217 186.9,77.86 v2(186.6,77.55) ; JDIMM4.230 190.35,76.08 v2(190.15,76.28) 189.64,76.28 189.35,75.99 JDIMM4.226 ; JDIMM2.23 136.4,77.78 v2(136.18,77.55) 135.67,77.55 135.4,77.82 JDIMM2.19 ; 153.13,88.98 154.02,88.98 154.15,88.85 JDIMM2.94 ; 153.13,88.98 153.15,88.96 JDIMM2.90 ; v2(174.4,77.6) 174.4,77.65 ; 174.4,77.65 JDIMM2.167 ; 174.4,77.65 174.58,77.83 175,77.83 175.4,78.24 JDIMM2.171 ; v2(138.34,88.98) 138.15,88.8 JDIMM2.30 ; JDIMM2.197 181.9,77.78 181.67,77.55 v2(181.39,77.55) 181.16,77.55 180.9,77.8 JDIMM2.193 ; JDIMM4.206 184.35,75.69 v2(184.94,76.28) 185.35,75.87 JDIMM4.210 ; C1046.1 180.93,156.84 v2(180.65,157.12) 180.37,156.84 C1045.1 ; JTYPC1.B12 6.85,82.07 JTYPC1.A1 ; JDIMM4.44 141.85,75.86 v2(142.27,76.28) 142.85,75.7 JDIMM4.48 ; C2082.2 46.72,88.95 v1(46.69,88.98) ; JDIMM4.26 137.35,76.06 137.57,76.28 v2(138.35,76.28) 138.35,76.27 138.35,76.26 JDIMM4.30 ; JDIMM4.78 150.35,76.2 v2(150.27,76.28) 151.04,76.28 151.35,75.96 JDIMM4.82 ; C1093.1 C1092.1 174.29,140.47 v2(174.21,140.54) ; v2(132.11,77.55) 132.62,77.55 132.9,77.83 JDIMM2.9 ; v2(132.11,77.55) 131.9,77.76 JDIMM2.5 ; C950.1 154.33,139.12 155.27,139.12 v2(155.74,139.59) ; v2(177.5,150.94) 177.39,151.05 C1062.1 ; C1050.1 174.07,156.84 v2(174.35,157.12) 174.63,156.84 C1049.1 ; v2(179.67,140.85) 179.65,140.87 C1097.1 C1096.1 ; v1(53.17,84.43) 52.99,84.25 C2073.2 ; v2(184.15,158.04) 184.25,157.95 C938.1 ; v1(46.72,87.03) 46.92,87.03 47.23,86.73 C2092.2 47.86,86.73 48.04,86.55 C2111.2 48.81,86.55 C2074.2 48.85,86.33 49.27,85.91 v1(49.27,85.73) ; v1(49.92,85.73) 50.14,85.51 C2097.2 51,85.51 v1(51.22,85.73) ; C1019.2 178.89,138.67 v2(178.6,138.95) 178.99,139.34 C1091.1 C1090.1 ; JDIMM4.72 148.85,75.8 148.38,76.27 v2(148.38,76.28) 148.37,76.28 147.85,75.76 JDIMM4.68 ; C2077.2 53.05,85.21 v1(53.17,85.08) ; v2(180.94,146.89) C1101.1 C1100.1 ; JDIMM2.68 147.65,88.83 147.8,88.98 v2(148.37,88.98) 148.65,88.7 JDIMM2.72 ; JDIMM4.166 174.35,75.77 174.4,75.82 ; C1047.1 176.43,156.84 v2(176.71,157.12) 176.99,156.84 C1048.1 ; R2306.2 208.72,196.21 U2028.3 ; C2127.2 34.26,71.02 v1(34.56,71.33) ; JDIMM4.98 155.35,75.97 v2(155.61,76.23) 156.04,76.23 156.35,75.92 JDIMM4.102 ; C1017.2 181.2,143.2 v2(181.16,143.15) 180.82,142.81 C1136.1 C1137.1 ; JDIMM2.65 146.9,77.1 146.72,76.91 v2(146.21,76.91) 145.96,76.91 145.69,77.18 145.69,77.92 145.9,78.13 JDIMM2.61 ; C1153.1 181.2,152.1 180.73,152.57 v2(180.65,152.57) 180.56,152.48 C1148.1 ; JDIMM4.176 176.85,75.52 176.67,75.7 v2(176.44,75.7) 176.03,75.7 175.85,75.52 JDIMM4.172 ; v3(275.93,166.75) 275.13,166.75 C2510.2 ; v2(174.4,75.87) 174.4,75.82 ; JDIMM2.18 135.15,88.73 134.91,88.98 v2(134.27,88.98) 134.15,88.86 JDIMM2.14 ; C2095.2 47.73,84.43 v1(47.32,84.43) ; JDIMM2.48 142.65,88.6 v2(142.27,88.98) 141.91,88.98 141.65,88.73 JDIMM2.44 ; JDIMM2.181 177.9,77.73 v2(178.09,77.55) 178.59,77.55 178.9,77.86 JDIMM2.185 ; v2(82.14,87.84) 82.52,87.46 C2168.1 ; JDIMM4.18 135.35,76.09 135.54,76.28 v2(136.18,76.28) 136.35,76.11 JDIMM4.22 ; v3(271.93,177.15) 272.03,177.25 C2513.2 ; JDIMM2.239 192.4,77.78 192.17,77.55 v2(191.8,77.55) 191.63,77.55 191.4,77.78 JDIMM2.235 ; C940.1 184.08,154.8 v2(183.8,154.52) 183.52,154.8 C939.1 ; v2(10.38,81.23) 10,81.23 9.34,80.57 JTYPC1.2 ; JDIMM2.227 189.4,77.82 189.14,77.55 v2(188.5,77.55) 188.4,77.65 JDIMM2.223 ; JDIMM2.26 137.15,88.7 136.87,88.98 v2(136.18,88.98) 136.15,88.96 JDIMM2.22 ; JDIMM4.40 140.85,75.8 v2(140.37,76.28) 139.85,75.76 JDIMM4.36 ; 52.61,81.39 52.58,81.36 ; JDIMM2.82 151.15,88.8 150.97,88.98 v2(150.27,88.98) 150.15,88.86 JDIMM2.78 ; JDIMM2.15 134.4,77.68 v2(134.27,77.55) ; v2(132.11,88.98) 133,88.98 133.15,88.83 JDIMM2.10 ; v2(132.11,88.98) 131.54,88.98 131.15,88.59 JDIMM2.2 131.15,85.99 v2(131.1,85.93) ; C1105.1 182.01,149.89 v2(181.71,150.19) 181.45,149.94 C1104.1 ; C1094.1 C1095.1 180.2,140.62 v2(179.78,140.2) 180.25,139.73 C1012.2 ; v2(151.6,151.84) 151.43,151.66 R27.2 ; C928.2 185.8,136.99 186.37,136.41 v2(186.37,136.32) ; v2(172.78,152.57) 172.75,152.55 C985.2 ; JDIMM4.64 146.85,75.64 v2(146.21,76.28) 145.85,75.92 JDIMM4.60 ; JDIMM2.36 139.65,88.67 139.96,88.98 v2(140.37,88.98) 140.65,88.7 JDIMM2.40 ; v2(196.98,76.28) 196.37,76.28 195.85,75.76 JDIMM4.252 ; JDIMM2.47 142.4,77.68 v2(142.27,77.55) 141.64,77.55 141.4,77.78 JDIMM2.43 ; C1043.1 174.86,154.24 v2(175.14,154.52) 175.42,154.24 C1042.1 ; JDIMM4.234 191.35,75.83 v2(191.8,76.28) 192.35,75.73 JDIMM4.238 ; C1018.2 183.13,142.36 v2(183.21,142.44) 183.19,142.46 C986.2 183.19,143.99 C1011.2 ; v2(176.44,77.55) 176.4,77.58 JDIMM2.175 ; PQ1402.1 55.97,8.98 v2(56.1,8.84) ; C2693.1 v2(257.65,58.63) ; v2(193.71,76.28) 193.85,76.14 JDIMM4.244 ; C2084.2 47.56,88.1 v1(47.32,88.33) ; JDIMM4.218 187.35,76.16 187.23,76.28 v2(186.6,76.28) 186.35,76.04 JDIMM4.214 ; C2166.1 82.62,86.08 v2(82.14,86.57) ; JDIMM2.231 190.4,77.8 v2(190.15,77.55) ; C1052.1 174.86,152.29 v2(175.14,152.57) 175.42,152.29 C1051.1 ; v2(188.5,76.28) 188.35,76.13 JDIMM4.222 ; v2(179.74,77.55) 179.9,77.71 JDIMM2.189 ; JDIMM2.180 177.65,88.55 v2(178.09,88.98) 178.4,88.98 178.65,88.73 JDIMM2.184 ; C1098.1 C1099.1 176.5,140.83 v2(175.93,140.26) 175.43,140.75 C1103.1 C1102.1 ; JDIMM2.51 143.4,77.82 143.67,77.55 v2(144.18,77.55) 144.56,77.55 144.9,77.89 JDIMM2.57 ; JDIMM2.166 174.15,88.73 v2(174.4,88.98) 174.65,88.73 JDIMM2.168 ; v3(250.91,164.35) 250.68,164.12 C2495.2 ; JDIMM2.201 182.9,77.94 v2(183.29,77.55) 183.67,77.55 183.9,77.78 JDIMM2.205 ; C1138.1 C1139.1 180,141.8 v2(179.72,141.52) ; C449.2 73.5,86 v2(73.5,86.57) ; JDIMM4.184 178.85,76.03 179.1,76.28 v2(179.74,76.28) ; PC1803.2 251.94,131.36 v3(252.28,131.02) ; C974.2 v2(172.07,148.51) ; v3(250.91,169.95) v3(251.71,169.95) ; v2(157.89,77.5) 157.4,77.99 JDIMM2.107 ; C944.1 184.23,150.83 v2(184.15,150.91) 184.15,150.99 184.55,151.39 C948.1 C947.1 ; JDIMM4.248 194.85,75.77 v2(195.36,76.28) ; JDIMM2.81 150.9,77.8 150.65,77.55 v2(150.27,77.55) 149.9,77.92 JDIMM2.77 ; JDIMM2.39 140.4,77.58 v2(140.37,77.55) 139.73,77.55 139.4,77.88 JDIMM2.35
  TOP w0.356: C2322.2 247.56,102.89 v2(247.36,103.08) ; C2584.2 291.52,132.01 v3(291.43,131.92) ; C2450.2 C2456.2 244.09,177.93 v3(244.07,177.95) ; C2083.2 42.26,91.53 v1(42.26,92.28) ; v3(241.09,140.07) 242.06,140.07 C2323.2 ; R2334.1 299.38,65.87 v2(298.8,65.87) ; PC717.2 v2(219.93,164.29) ; PR431.2 208.3,114.71 v2(208.12,114.89) ; C978.2 174.73,148.94 v2(175.16,148.51) 175.62,148.98 C977.2 ; D23.1 v2(16.59,159.07) ; v3(256.58,126.12) C2345.2 v3(256.58,124.72) ; v3(265.03,95.92) 265.08,95.87 C2644.2 ; R2162.2 222.22,113.11 v2(221.84,113.49) 221.84,113.62 222.22,114 R2163.2 ; PC1536.2 168.62,142.07 v2(168.24,141.68) ; C237.1 v1(40.35,50.88) ; v1(36.42,71.83) 36.38,71.87 C2118.2 ; C2659.2 242.95,98.44 v3(243.47,97.92) ; v3(258.91,165.15) 258.82,165.06 C2499.2 ; C525.1 77.82,65.23 v2(77.95,65.1) ; v3(264.76,143.11) 264.76,142.06 C2408.2 ; v2(291.81,178.26) PC3590.1 PR1458.2 292.83,178.82 PR1460.2 ; v3(288.23,118.69) 288.14,118.6 C2617.2 ; C2151.2 52.38,84.57 v1(52.52,84.43) ; v3(226.16,73.1) 226.26,73 C316.2 226.26,72.42 225.73,71.9 v3(225.52,71.9) ; C2677.2 243.42,94.77 v3(243.47,94.72) ; C981.2 178.43,151.54 v3(178.43,150.96) ; C2505.2 254.25,165.01 v3(254.11,165.15) ; v2(167.63,138.95) 167.89,139.22 167.89,140.16 168.25,140.52 168.91,140.52 PC1632.2 ; C179.1 247.57,47.25 v2(247.36,47.45) ; C666.2 241.12,131.63 v3(241.09,131.67) ; C226.2 237.18,50.5 v3(236.82,50.5) ; C236.1 v1(32.48,48.97) 32.56,48.9 C308.1 ; C2561.2 291.36,153.67 v3(291.3,153.74) ; PR718.2 v2(219.93,163.4) ; C1333.2 v2(302.79,68.61) ; v2(170.37,138.29) 169.92,138.74 C925.2 ; v2(297.78,182.71) 297.66,182.83 PC1432.1 ; R855.1 225.93,59.82 225.8,59.69 ; C871.2 184.07,146.21 v2(184.12,146.16) ; v3(262.11,165.95) 262.11,165.94 C2483.2 ; C2619.2 289.13,121.99 v3(289.03,121.89) ; C934.2 183.73,152.03 C935.2 ; C539.1 67.2,61.37 ; v3(250.88,134.52) C2327.2 v3(250.88,133.12) ; v2(302.1,170.77) 302.43,171.1 PR3586.2 ; v2(60.8,65.1) 60.29,65.61 C573.2 ; C2479.2 248.39,177.89 v2(248.39,178.64) ; C2460.2 240.07,169.15 v3(240.87,169.15) ; R927.2 v3(237.59,119.71) ; C696.2 240.3,120.91 240.63,121.24 241.06,121.24 v3(241.09,121.27) 241.11,121.27 241.65,121.81 241.65,122.25 242.03,122.63 C703.2 ; v3(249.48,133.12) 249.48,133.34 249.01,133.82 C2335.2 248.64,133.82 248.09,133.26 v3(248.09,133.12) ; v2(175.93,151.01) 176.4,151.48 C982.2 ; v3(253.69,130.97) 253.69,130.8 C594.2 ; v3(290.63,139.92) 290.7,139.99 C2570.2 ; LD1.2 5.35,173.76 v2(5.43,173.76) ; R568.2 v2(14.19,125.94) ; C1338.2 293.29,72.98 R809.2 v2(292.25,72.9) ; C669.2 241.09,133.59 v3(241.09,133.77) ; v1(35.38,76.13) 35.43,76.08 R2062.1 ; R2042.2 63.85,92.92 64.1,92.66 v2(64.36,92.66) ; PC1615.2 169.2,146.91 v2(169.36,147.08) ; v3(243.99,119.17) 244.11,119.29 C2210.2 ; C2568.2 287.43,127.76 v3(287.43,128.72) ; v2(75.28,70.69) 74.64,70.06 C497.1 ; v2(73.88,70.69) 73.63,70.44 C528.1 ; v3(250.25,119.12) 250.06,118.93 C2209.2 ; C2387.2 251.07,137.14 v3(250.88,137.32) ; C2625.2 269.74,89.61 v3(269.83,89.52) ; PC3542.2 v2(296.31,190.2) ; R1001.1 301.64,75.47 v2(301.85,75.26) ; v2(288.26,191.85) 288.28,191.82 PR1418.2 PR1419.2 ; 189.71,157.31 189.66,157.25 C933.2 ; C168.2 4.35,170.4 v2(4.39,170.36) ; C2131.1 32.65,74.76 v1(32.25,74.76) ; C2416.2 241.69,130.27 v3(241.79,130.37) ; v3(242.58,146.47) 242.58,145.66 C167.2 243.1,145.77 v3(243.88,145.77) ; C1341.2 210.79,156.16 v2(210.66,156.29) ; v2(169.63,154.52) 169.83,154.72 PC1613.2 ; v3(287.43,121.89) 287.3,122.01 C2618.2 ; R2307.2 207.94,162.36 208.17,162.13 v2(208.61,162.13) ; C2496.2 254.29,169.33 v3(254.11,169.15) ; v3(258.11,173.15) 258.87,172.38 C2491.2 ; v1(35.27,74.4) 35.38,74.3 R2086.1 ; C493.1 76.17,73.87 v2(76.55,73.49) 77.06,73.99 C527.1 ; PC671.2 273.27,58.7 v2(273.91,58.7) ; C2671.2 254.97,96.62 v3(254.87,96.72) ; v1(49.27,90.28) 49.37,90.39 49.37,91.65 49.7,91.98 R2049.2 R2032.2 ; v2(55.21,97.49) 54.96,97.49 54.58,97.87 C2100.2 ; C2128.2 32.15,74.03 v1(32.25,74.13) ; C224.1 229.66,62.89 v3(230.09,63.33) ; C2213.2 244.58,118.45 v3(244.58,117.77) ; v2(242.79,46.69) 243.17,46.31 C401.2 ; v3(266.98,119.77) 266.98,119.65 266.8,119.46 266.8,119.11 C2394.2 265.93,118.24 v3(265.76,118.24) ; v2(79.22,46.05) 79.22,46.18 78.71,46.69 PR647.2 ; C873.2 186.18,142.62 v2(186.37,142.62) ; R328.2 264.56,32.06 v2(264.89,31.73) 264.92,31.7 C364.2 ; PC222.1 81.12,4.07 PC221.1 ; v1(44.8,92.28) 44.93,92.15 R2025.2 ; v3(288.1,148.94) 288.04,149 C2550.2 ; C169.2 v2(6.9,174.35) ; R2193.2 234.4,170.67 v3(234.48,170.75) ; C2689.2 58.71,84.73 v2(59.02,84.41) ; v2(274.29,69.42) 274.54,69.17 PC677.2 ; R506.2 232.1,56.49 v3(231.74,56.85) ; 190.34,156.42 190.29,156.37 C932.2 ; PC190.1 v2(299.74,90.05) ; v2(208.88,117.63) 208.88,117.68 209.2,118 PC437.2 ; C2110.2 46.46,86.59 v1(46.69,86.36) ; 149.02,153.51 149.4,153.89 R30.1 ; C930.2 191.52,156.47 v2(191.11,156.88) ; v1(55.07,85.73) 56.18,85.73 56.92,84.99 C2690.2 ; v2(265.78,74.88) 265.97,74.69 PC1264.2 ; PC108.2 31.29,57.48 v1(30.45,57.48) ; v2(75.66,54.54) 76.58,55.45 PR621.2 ; v3(262.11,167.55) 262.19,167.47 C2477.2 ; C418.1 181.07,195.89 v2(181.07,195.66) ; v3(249.48,132.42) 249.4,132.33 C2388.2 249.4,131.1 v3(249.48,131.02) ; v2(164.88,138.95) 164.38,138.45 ; v2(16.22,28.91) D53.8 D53.3 ; C1009.2 179.23,149.02 v2(178.81,148.6) 178.34,149.07 C1021.2 ; 210.53,166.2 R2304.1 ; C2591.2 289.03,128.02 v3(289.03,128.72) ; v2(289.15,191.85) 289.15,191.19 PR1417.2 PR1416.2 ; R235.1 31.06,54.44 v1(30.96,54.54) ; v3(248.09,131.02) 248.09,130.36 C2390.2 ; C548.2 248,139.5 v3(248.09,139.42) ; C2469.2 237.01,177.28 v3(236.87,177.15) ; C2616.2 288.16,113.95 v3(288.23,113.88) ; R411.2 v3(19.15,159.21) ; v3(270.33,140.32) 270.8,140.78 C2397.2 ; C233.1 v1(36.8,57.36) ; C1044.1 173.12,139.93 v2(173.33,140.14) ; PC626.1 76.09,46.1 v2(76.04,46.05) 76.04,45.22 PC622.2 ; C2462.2 244.73,164.34 v3(244.32,164.75) ; v3(246.69,132.42) 246.69,131.89 C595.2 246.86,131.19 v3(246.69,131.02) ; PC513.2 v2(267.3,43.77) ; v2(64.48,10.27) 64.48,9.4 C1359.1 ; v2(277.21,69.42) 277.21,69.74 C553.2 ; PR3472.2 PR3471.2 PR3470.2 292.73,191.82 v2(292.7,191.85) ; v2(204.16,198.07) 204.16,197.08 C2694.2 204.13,196.57 203.98,196.42 R2305.2 ; v3(262.18,127.52) 262.18,127.25 262.62,126.81 C2336.2 263.49,126.7 263.09,126.3 C2347.2 262.36,125.94 v3(262.18,126.12) ; C1339.2 v2(301.97,73.23) ; C229.1 C228.2 ; v3(257.99,138.72) v3(257.99,139.42) 258.18,139.61 C2393.2 C2332.2 ; v2(168.44,150.96) 169.07,150.33 PC1630.2 ; C988.2 180.14,150.61 v2(179.75,151.01) 179.71,151.04 C980.2 ; R2333.1 82.14,75.72 v2(82.14,75.26) ; v3(238.47,54.05) 238.09,54.05 C227.1 ; C416.1 181.12,193.55 v2(180.82,193.25) ; v3(240.48,123.37) 240.66,123.54 C702.2 ; C2583.2 288.21,131.94 v3(288.23,131.92) ; D56.1 v2(9.06,72.75) ; v3(234.92,54.49) 234.74,54.31 C212.2 ; U51.3 4.03,145.55 v2(4.46,145.55) ; R2092.2 29.92,71 30.96,69.96 v1(30.96,69.93) ; PC206.2 82.07,14.37 v2(81.88,14.56) ; PC1311.1 197.35,193.4 v2(197.33,193.37) 197.28,193.42 PC1313.1 ; v3(269.03,88.72) 268.35,88.04 C2624.2 ; R2015.2 50.96,81.86 v1(50.57,81.86) ; D24.1 v2(16.61,162.02) ; v3(271.13,173.15) 271.12,173.15 C2531.2 ; PR3576.1 v2(297.71,88.67) ; v2(300.07,189.56) PR3468.2 300.02,188.8 PC3572.2 ; PR724.2 219.81,166.96 v2(219.93,166.83) ; v2(107.41,93.04) 107.46,93.09 C426.2 ; R919.2 237.56,120.72 v3(237.56,121.33) ; v2(85.86,3.04) 85.83,3.06 PC217.2 ; C554.2 280.77,70.01 v2(281.07,70.31) ; v1(31.46,48.97) 31.59,49.1 C232.1 ; R2164.2 222.22,115.27 v2(221.84,115.65) 222.35,116.16 R2165.2 ; C694.2 233.65,123.08 v3(233.65,122.76) ; v3(257.99,124.72) C2363.2 v3(257.99,126.12) ; C230.2 31.21,55.32 v1(30.96,55.58) ; C2386.2 249.42,137.25 v3(249.48,137.32) ; v2(292.83,177.12) 292.96,176.99 PR3571.1 ; C2320.2 251.82,102.89 v2(252.02,103.09) ; v2(240.51,46.69) 240.51,46.43 240.3,46.23 C2692.1 ; C2667.2 251.61,94.26 v3(251.67,94.32) ; R428.1 245.32,44.57 Q12.3 ; C2485.2 250.11,175.55 v3(250.91,175.55) ; PC410.2 v2(109.82,94.06) ; C188.2 243.73,49.43 244.11,49.05 ; C1361.1 64.66,7.37 v2(64.61,7.32) C1367.2 ; v2(280,31.07) 280.64,31.07 280.97,31.4 C363.2 ; C2574.2 301.49,129.86 v3(301.03,130.32) ; U2031.5 U2031.7 ; v3(241.09,135.87) 241.09,135.48 241.36,135.21 C656.2 241.5,134.87 241.78,134.6 v3(241.78,134.57) ; R2085.1 32.15,75.97 v1(32.23,75.9) 31.34,75.9 30.99,76.24 C2130.2 C2129.2 ; C2641.2 265.2,93.35 v3(265.03,93.52) ; v2(118.84,195.02) 118.46,195.02 118.03,194.59 PC1157.1 ; C2696.2 205.71,166.2 v2(205.58,166.07) ; v3(244.07,174.75) 244.2,174.87 C2459.2 ; PU1608.3 v2(301.59,86.88) ; 79.91,11.89 PC223.2 ; v2(9.75,76.15) 9.53,75.94 JTYPC1.4 ; v2(111.09,86.06) 110.89,85.86 PR404.2 PC411.2 ; PC3543.2 v2(295.37,190.2)
  TOP w0.381: R324.1 41.93,56.87 41.93,58.25 v1(41.65,58.53) ; C2552.2 294.07,159.78 C908.2 ; PC727.2 284.88,127.21 v2(285.13,127.46) ; v3(273.28,92.52) 273.75,92.99 R2228.1 ; PC316.2 42.49,17.99 v2(42.36,17.86) ; C1369.1 v2(76.8,3.64) ; v3(244.95,54.69) 244.75,54.89 R147.1 ; R149.1 243.21,55.78 243.38,55.96 v3(243.81,55.96) ; C2674.2 255.9,89.89 v3(255.07,90.72) ; PR305.2 v2(42.77,8.08) ; C1365.1 66.64,3.64 v2(66.14,3.13) ; PC1226.2 192.02,127.92 v2(192.88,128.78) ; R912.2 263.05,90.27 263.43,90.65 v3(263.43,91.12) ; v2(13.81,68.02) 13.94,67.9 C495.2 ; v3(271.43,91.92) 271.42,91.93 R857.2 ; v2(128.11,184.23) 128.11,184.31 127.73,184.69 PC1142.1 ; R187.1 v3(225.75,59.64) 225.8,59.69 ; v2(150.94,147.9) 150.88,147.83 R12.1 ; v3(246.87,97.52) 246.93,97.58 C2675.2 ; v2(70.2,4.14) 70.61,4.14 70.66,4.19 R511.1 ; v2(190.47,156.54) 190.34,156.42 ; D55.2 107.41,1.48 107.98,0.91 v2(108.3,0.91) ; v3(247.03,58.75) 247.24,58.96 R130.2 ; C919.2 177.01,135.55 v2(176.77,135.78) ; v2(17.11,164.32) 17.06,164.27 C465.1 ; v2(136.62,147.53) 136.62,147.83 136.98,148.19 C601.1 ; v2(151.59,144.75) 152.09,144.25 R28.1 ; R2050.2 R2121.1 45.61,92.92 R2025.2 ; v3(242.84,52.33) 243.25,51.92 C400.1 ; v3(150.28,151.81) 149.98,151.51 R29.2 C33.2 ; C379.2 288.84,53.11 v2(288.77,53.04) ; v2(42.77,67.39) 43.71,67.39 R280.2 ; v2(295.52,51.01) 294.99,51.54 293.29,51.54 C377.1 ; v2(44.23,58.63) 44.61,58.25 C273.1 ; C1363.1 v3(77.06,6.61) ; v2(16.94,76.94) 17.28,76.94 D58.1 ; C222.2 242.03,60.58 v3(242.03,61.12) ; v2(109.75,64.24) 109.94,64.43 PQ1401.4 ; v2(184.3,148.12) 184.3,148.14 184.16,148.29 183.67,148.29 C937.2 183.66,148.29 C936.2 ; C2623.2 273.11,95.04 v3(273.03,95.12) ; v2(208.71,197.51) 209.11,197.11 R2306.2 ; R471.1 R472.1 v2(283.18,59.39) ; C2183.2 284.47,133.94 v2(284.52,133.99) ; PC1160.1 119.48,195.41 119.09,195.02 v2(118.84,195.02) ; PC105.2 22.02,22.53 v2(21.97,22.48) 22.02,22.43 PC104.2 ; C2176.2 284.94,128.73 v2(284.99,128.68) ; v2(30.91,67.67) 30.91,67.95 30.45,68.41 R2080.2 ; D28.1 v2(13.94,135.72) ; v2(203.93,155.27) 203.87,155.34 PC1315.2 ; v3(269.83,93.52) 269.72,93.41 C2645.2 ; C921.2 172.05,132.03 171.8,131.78 171.36,131.78 v2(171.34,131.76) 170.92,131.76 170.66,132.03 C926.2 ; C917.2 163.01,135.72 v2(163.05,135.77) ; PC317.2 49.07,12.65 49.5,12.22 v2(49.5,12.14) 49.12,11.76 PR314.2 ; v3(299.43,110.69) 299.15,110.41 C2597.2 ; v2(119.6,197.06) 119.65,197.01 PR1152.1 ; v2(46.58,68.79) 46.85,69.06 Y4.2 ; v2(150.94,144.75) 150.92,144.72 R32.1 ; v3(243.67,84.72) 243.67,84.61 243.04,83.98 C2661.2 ; R126.2 234.11,51.97 v3(233.72,52.35) ; C209.1 235.17,51.01 v3(235.05,50.88) 234.41,50.24 R125.2 ; R2040.2 v2(23.59,87.96) ; v3(295.4,121.9) 295.37,121.92 295.19,121.92 C2621.2 294.05,123.06 C1353.2 C2425.2 ; v2(13.94,137.62) 13.68,137.87 R451.2 ; v2(116.68,68.79) 116.68,68.78 117.06,68.4 PQ1404.4 ; PC414.2 PC415.2 100.43,88.67 v2(100.42,88.68) ; v2(105.51,89.87) PC439.1 ; v3(261.63,96.32) 261.56,96.39 C2648.2 ; v2(118.08,191.27) 118.43,190.91 PR1188.1 ; PQ206.3 274.46,38.97 v2(274.95,38.48) ; C249.2 72.61,4.19 v2(73.2,4.78) ; R2044.2 46.11,88.52 46.32,88.31 46.71,88.31 46.74,88.33 46.74,88.33 v1(46.71,88.33) ; PR433.1 102.53,83.52 v2(102.46,83.52) ; v2(287.27,21.97) 286.81,22.43 C2727.2 ; v2(187.82,133.07) 187.71,133.18 C923.2 ; PC1251.2 204.69,153.55 PC1254.2 204.87,154.51 v2(206.01,154.51) ; v2(14.32,128.22) D30.3 D30.8 ; C407.1 20.03,46.05 20.67,45.42 v2(20.67,45.16) 20.53,45.03 Q52.1 ; PC820.2 105.96,94.49 105.76,94.69 v2(105.76,94.72) ; v3(244.47,84.72) 244.5,84.69 C2653.2 ; C2642.2 261.31,98.24 v3(261.63,97.92) ; 29.43,80.72 29.43,80.98 28.98,81.44 v2(28.11,81.44) ; PR220.1 v2(84.8,4.02) ; R146.2 249.07,54.77 v3(248.5,55.33) ; v2(87.47,13.54) 87.67,13.34 PC231.2 ; PR1197.1 119.25,185.02 v2(118.84,184.61) ; v2(280.89,59.39) 280.08,59.39 279.62,59.85 R463.2 ; PR307.2 40.99,8.11 v2(40.96,8.08) ; v2(160.31,135.78) 160.37,135.72 C916.2 ; C509.1 106.39,1.1 v2(106.65,0.84) ; v2(82.26,5.57) 82.62,5.92 PR224.1 ; R372.2 228.31,46.31 v2(228.82,45.8) ; C2188.2 260.01,106.19 v2(259.62,105.79) ; R348.1 v2(277.84,51.9) R345.1 ; PC1255.2 202.97,157.36 v2(203.55,157.94) ; C1364.1 65.75,3.64 v2(65.25,3.13) ; C2682.2 292.45,79.58 v2(292.83,79.96) ; v3(241.57,58.75) 241.57,58.47 C399.2 ; v2(280,44.91) 280,44.17 279.53,43.69 R346.2 ; C927.2 179.55,135.75 v2(179.51,135.78) ; v1(42.89,92.28) 42.89,91.85 R2051.2 ; v2(291.43,46.82) 291.43,46.97 291.21,47.2 291.18,47.2 C380.2 ; v2(163.8,131.79) 163.89,131.79 164.43,132.34 C920.2 ; R460.1 267.48,74.17 v2(267.43,74.12) ; v2(31.97,23.32) 32.3,23.64 PC308.2 32.77,24.98 v2(32.77,25.86) ; PC1305.2 23.65,18.3 v2(23.84,18.11) ; v2(118.82,185.68) 119.04,185.91 PC1153.1 ; C2181.2 255.75,159.34 v2(256.28,159.87) ; PC3603.2 267.23,21.67 PQ207.3 v2(267.32,22.73) ; v2(20.8,66.37) 21.13,66.7 R495.2 ; JTYPC1.3 10.7,78.07 v2(11.02,78.39) ; C625.2 v2(14.32,32.08) ; Q12.3 245.32,46.3 245.41,46.38 v2(245.41,46.69) ; v2(18.26,71.33) 18.32,71.26 U18.5 ; C260.2 49.8,57.66 v2(49.63,57.48) ; C331.2 287.5,26.5 288,25.99 v2(288,25.48) 287.45,25.48 R314.2 ; v2(272,65.74) 272,65.71 272.23,65.48 PR612.2 ; R547.1 235.63,57.18 v3(235.93,57.48) ; D29.1 v2(13.94,136.86) ; C276.2 44.93,68.2 v2(44.93,68.91) ; C350.1 v2(278.35,29.8) ; v2(186.37,144.19) 186.34,144.22 C872.2 ; C345.2 264.33,34.57 v2(264.13,34.37) 264.56,33.94 C340.2 ; PC1163.2 PR1187.1 118.87,188.29 v2(118.79,188.22) ; v2(280.51,33.1) 280.64,32.97 C332.1 ; C361.1 v2(280,31.07) ; C2453.2 232.43,169.96 v3(232.62,170.15) ; R2045.1 44.16,91.72 v1(44.16,92.28) ; C398.1 241.4,57.23 241.9,57.73 v3(242.61,57.73) ; v3(243.67,86.32) 242.83,86.32 C2660.2 ; R148.2 243.38,57.73 v3(243.37,57.73) ; v2(62.07,7.32) 61.77,7.01 R407.2 ; R62.1 247.9,61.19 R177.2 248.81,59.59 v3(248.89,59.52) ; C2180.2 257.02,159.39 v2(257.45,159.82) ; PC1316.2 v2(202.79,150.6) ; v3(273.03,87.93) 274.27,87.93 C2638.2 ; v3(250.72,89.52) 250.58,89.38 C2666.2 ; v2(78.63,6.05) PR226.2 ; R911.2 253.52,90.22 253.27,90.48 v3(253.27,91.12) ; PC1306.2 17.93,13.74 v2(18.13,13.54) ; R347.2 275.3,47.96 v2(275.81,48.47) ; C918.2 178.98,131.72 v2(178.89,131.81) ; v2(57.5,66.88) 57.5,66.5 57.88,66.12 C258.2 ; v3(230.22,58.83) 230.68,58.37 C223.1 ; v2(105.51,86.69) 106.01,86.19 PR406.2 ; v2(284.9,116.38) 284.87,116.41 C2185.2 ; v2(183.28,150.93) 183.26,150.96 183.26,151.56 C935.2 ; PC205.2 78.45,13.38 PR206.2 79.22,12.47 v2(79.27,12.53) 79.91,11.89 ; PC3596.2 279.02,11.15 v2(278.84,11.33) ; v2(274.92,41.23) 275.69,40.46 PC676.2 ; v2(285.01,125.36) 284.96,125.3 PC726.2 ; PR3595.2 v2(288.42,12.12) ; v3(255.12,92.52) 255.12,92.06 255.62,91.55 C2670.2 256.05,91.7 C1373.2 C2439.2 ; C2186.2 284.73,117.68 v2(284.86,117.55) ; C1362.1 75.03,16.03 v2(75.03,16.72) ; PR306.2 v2(48.86,8.89) ; v3(261.83,87.92) 261.08,87.92 260.69,87.53 C2637.2 ; v3(261.63,90.5) 260.8,89.67 C2647.2 260.79,89.6 C2650.2 ; D59.1 v2(18.63,79.95) ; PQ1404.1 v2(118.09,67.4) ; C2178.2 273.16,159.67 v2(273.17,159.68) ; v2(284.45,26.37) 284.58,26.5 C329.1 ; v3(77.87,8.36) 77.87,8.51 78.07,8.72 PC218.1 PC219.1 ; C924.2 164.37,138.44 164.38,138.45 ; C256.1 v2(56.31,65.69) ; C279.1 v2(13.81,116.89) ; D26.8 D26.3 v2(14.32,131.78) ; v2(208.25,153.11) 207.99,153.11 207.44,152.56 PC1227.2 ; R930.1 C1368.2 ; v2(79.6,6.05) 80.16,6.05 PR219.1 ; v2(118.82,189.36) 118.99,189.18 PC1152.1 ; PQ1401.1 108.05,67.38 v2(107.54,67.9) 108.18,68.54 PQ1403.4 ; C476.1 v2(50.39,7.45) ; v3(245.27,91.92) 245.15,92.03 R2201.2 ; v2(133.45,189.31) PR1192.2 PR1189.1 PR1190.2 ; PC216.2 v2(89.16,3.63) ; C475.2 v2(51.28,7.45) ; R97.1 226.28,66.58 v3(226.28,66.25) ; v2(181.44,154.52) 181.48,154.56 C931.2 ; C464.2 v2(17.11,163.4) ; C328.1 v2(285.46,26.37) ; v2(282.75,10.54) 282.6,10.54 PC3595.2 ; PC512.2 265.69,45.86 v2(266.36,46.54) ; C346.2 279.14,33.48 v2(278.76,33.1) ; C2673.2 251.58,97.61 v3(251.67,97.52) ; C2676.2 246.88,93.53 v3(246.87,93.52) ; v3(247.67,89.52) 247.67,89.85 247.27,90.26 C2678.2 ; C2649.2 265.89,89.58 v3(265.83,89.52) ; R430.1 81.21,20.78 v2(82.22,21.8) ; v2(80.55,3.25) 80.23,3.57 PC222.1 ; C2177.2 274.43,159.7 v2(274.5,159.77) ; D2005.3 v2(15.06,79.3) ; v2(148.91,153.41) 149.02,153.51 ; v2(152.24,150.26) 152.44,150.06 R10.1 ; PC3593.2 v2(287.4,11.25) ; v2(9.06,72.75) D57.1 ; D27.1 v2(13.94,134.32) ; PU402.3 103.93,87.78 v2(103.98,87.84) ; C2184.2 284.4,132.67 v2(284.45,132.72) ; C2187.2 263.62,106.19 v2(264.2,105.6) ; C314.2 236.82,64.09 v3(236.06,63.33) ; v2(134.26,192.92) 134.26,193.35 134.03,193.58 PR1191.1 ; C2639.2 273.15,96.6 v3(273.03,96.72) ; v3(241.65,50.88) 241.52,51.01 C405.1 ; PR225.1 v2(87.85,6.18) ; PR303.1 v2(47.21,8.21) ; C2179.2 v2(284.95,123.78) ; v2(189.96,157.56) 189.71,157.31 ; v3(269.83,97.52) 269.69,97.66 C2643.2 ; C557.1 C555.1 v2(284.96,59.39) ; C378.1 293.31,48.42 293.92,48.42 v2(293.97,48.47) ; R477.1 v2(54.15,72.09) ; v2(175.86,138.94) 176.3,138.94 176.6,139.25 C949.2 ; v2(58.77,66.88) 59.02,66.63 C255.2 ; C975.2 177.4,150.84 v2(177.5,150.94) ; v2(187.02,152.85) 186.9,152.73 C945.1 ; PC315.2 v2(46.9,18.88) ; C320.2 v2(77.69,3.64) ; v2(281.91,70.31) 281.65,70.06 C556.1 ; C280.1 v2(2.51,89.49) ; v3(244.19,48.97) 244.11,49.05 ; PC303.1 v2(43.91,8.08) ; R2120.1 59.66,93.75 v2(59.86,93.55) 60.19,93.88 R2118.2 ; C281.1 v2(3.52,89.61) ; C278.1 v2(4.67,116.92) ; U16.4 v2(40.23,2.37) ; v2(187.02,135.53) 186.47,134.98 C922.2
  TOP w0.457: v2(57.82,10.62) PC313.2 ; C221.1 229.08,51.01 v3(229.2,50.88) ; C219.2 238.35,62.11 v3(238.35,62.56) ; v2(190.45,132.52) 190.45,132.25 PC1258.2 ; v2(283.81,70.31) 283.72,70.31 283.43,70.02 R475.1 R476.1
  TOP w0.508: v2(41.4,27.39) 41.5,27.29 PC304.2 ; PC3503.2 300.91,94.11 v2(301.35,94.54) ; PC215.2 93.69,9.22 v2(94.2,8.72) ; PH201.1 99.7,4.7 JBAT1.13 ; PC1539.2 v2(168.37,144.48) ; PC314.2 38.45,5.16 37.81,4.52 v2(37.69,4.52) ; PC220.2 v2(93.44,6.56) 94.14,7.26 PC214.2 ; v2(223.87,121.36) 224,121.49 C693.2 ; R315.1 v2(291.43,24.64) ; v2(31.97,22.18) 31.8,22.01 PC128.2 ; PR108.2 v2(78.25,94.19) ; v2(217.15,169.89) 217.1,169.84 PC719.2 ; C463.2 v2(17.11,165.31) ; v2(222.09,127.84) 222.41,127.52 C687.2 ; C640.2 v2(72.99,22.18)
  GND02 w0.508: H28.1 311,114.5 v2(311.12,114.38)
  IN03 w0.356: 288.89,58.25 289.66,57.48 v2(289.66,55.83) 289.66,54.82
  IN03 w0.381: v2(284.07,44.02) 281.13,44.02 278.76,41.66 278,41.66 277.65,41.31 277.65,40.53 278.1,40.08 280.51,40.08 281.78,41.35 288,41.35 v2(289.15,42.5) 289.97,43.32 289.97,45.67 290.48,46.18 v2(291.43,46.18) ; v2(284.83,44.02) 286.73,44.02 287.69,44.97 287.69,51.45 288.77,52.53 v2(288.77,53.04) 289.66,53.93 289.66,54.82 ; 277.84,53.17 277.84,53.93 v2(278.86,54.94) v2(279.5,55.58) 280.89,56.98 v2(280.89,59.39) 281.78,60.28 288.39,60.28 288.89,59.77 288.89,58.25 ; 277.84,53.17 276.83,53.17 275.81,52.15 v2(275.81,48.47) 275.81,43.54 274.92,42.65 v2(274.92,41.23) 273.5,41.23 273.1,40.83 v2(269.21,40.83) 268.85,40.47 267.94,40.47 267.3,41.1 v2(267.3,43.77) 269.98,43.77 NUT3.1 271.5,45.3 273.4,47.2 273.4,53.15 278.11,57.87 278.11,60.31 280.49,62.69 284.07,62.69 v2(284.32,62.94) ; 277.84,53.17 v2(277.84,51.9)
  IN10 w0.254: 289.94,37.26 289.94,39.25 289.93,39.39 289.93,39.47 290.16,39.7 290.16,39.9
  IN10 w0.381: 286.28,37.29 286.28,40.03 284.83,41.48 277.97,41.48 277.08,40.59 275.56,40.59 v2(274.92,41.23) ; v2(284.07,44.02) v2(284.83,44.02) 287.62,44.02 v2(289.15,42.5) 290.16,41.48 290.16,39.9
  BOTTOM w0.089: U2005.R23 52.28,81.02
  BOTTOM w0.102: G2.P51 262.49,148.42 262.81,148.75 262.81,150.08 v3(261.79,151.1)
  BOTTOM w0.127: G2.T47 261.09,144.66 v3(260.75,144.33) ; v3(242.88,136.27) 242.88,136.27 G2.BC34 ; G2.AU47 G2.AU45 ; v3(268.44,142.26) 268.74,142.57 G2.D43 ; G2.H40 v3(266.98,140.77) ; G2.H40 266.98,140.17 v3(267.01,140.17) ; G2.H40 266.04,140.47 v3(265.88,140.62) ; v3(267.54,132.27) 267.54,132.18 267.42,132.07 G2.H28 ; v3(252.86,117.52) 252.69,117.34 G2.AH6 ; v3(242.88,132.07) 242.88,132.07 G2.BC28 ; v3(263.19,141.87) G2.N43 ; v3(258.99,120.17) G2.W10 ; G2.K19 v3(264.58,125.77) ; G2.AH10 v3(252.69,120.17) ; v3(248.86,145.72) 248.49,146.1 G2.AP49 ; v3(248.59,143.2) 248.49,143.3 G2.AP45 ; G2.AP10 v3(248.49,120.17) ; G2.K34 v3(264.58,136.27) ; G2.BC16 242.88,123.67 v3(242.88,123.67) ; G2.K40 v3(264.58,140.47) ; v3(242.88,127.87) 242.88,127.87 G2.BC22 ; v3(264.58,132.07) G2.K28 266.09,132.07 266.23,132.21 v3(266.23,132.25) ; v3(267.76,133.88) 267.66,133.88 267.37,134.17 G2.H31 ; v3(265.49,115.74) 265.28,115.94 G2.K6 ; v3(252.81,146.19) 252.69,146.07 G2.AH47 ; U2005.W23 54.12,81.02 ; v3(264.58,123.67) G2.K16 ; G2.AL10 v3(250.58,120.17) ; G2.BC31 v3(242.88,134.17) ; G2.T45 G2.T43 v3(261.09,141.87) ; G2.D31 269.09,134.17 v3(268.93,134.32) 268.79,134.17 G2.F31 ; v3(266.23,134.42) 265.98,134.17 G2.K31 v3(264.58,134.17) ; G2.BJ7 237.46,117.37 ; G2.K37 v3(264.58,138.37) ; G2.AH45 252.69,143.16 v3(252.98,142.87) ; v3(242.67,121.39) 242.49,121.57 G2.BC13 ; v3(244.13,148.99) 244.29,148.84 G2.AY51 ; G2.AU10 v3(246.39,120.17) ; v3(248.49,141.87) G2.AP43 ; v3(252.69,141.87) G2.AH43 ; G2.BC19 v3(242.88,125.77) ; G2.AP47 248.49,144.63 248.48,144.63 ; v3(261.09,120.17) G2.T10 ; v3(246.09,145.67) 246.39,145.96 G2.AU49 ; G2.K8 265.28,117.27 v3(264.98,116.97) ; U2005.A6 U2005.B6 ; v3(256.89,120.17) G2.AB10 ; G2.N10 v3(263.19,120.17) ; v3(254.44,118.42) 254.79,118.76 G2.AE10 v3(254.79,120.17) ; v3(250.58,141.87) G2.AL43 ; G2.K25 v3(264.58,129.97) ; v3(264.58,121.57) G2.K13 ; G2.K22 v3(264.58,127.87) ; v3(256.89,141.87) G2.AB43 ; v3(258.99,141.87) G2.W43 ; v3(254.79,141.87) G2.AE43 ; 252.69,115.9 G2.AH4
  BOTTOM w0.13: 256.88,144.73 G2.AB47
  BOTTOM w0.15: G2.W47 258.99,145.42 v3(259.3,145.74) ; v3(252.86,117.52) 252.86,117.89 G2.AH8 ; v3(268.49,146.37) G2.E48 v3(268.49,145.77) ; v3(267.54,132.27) 267.72,132.09 267.96,132.09 267.97,132.08 268.07,132.08 G2.F28 v3(268.39,131.77) 268.56,131.77 269.03,132.23 v3(269.08,132.23) 269.32,132.23 G2.D28 269.59,132.17 270.08,132.17 v3(270.26,131.99) ; v3(244.6,147.12) 244.39,146.9 244.39,146.9 244.29,146.8 G2.AY49 ; v3(246.09,145.67) G2.AU47 v3(246.68,145.67) ; v3(269.79,147.07) G2.D49 v3(269.79,146.47) ; v3(268.55,140.7) 268.31,140.7 G2.F40 v3(268.39,140.17) ; G2.K47 v3(265.58,145.07) 265.47,144.95 v3(265.47,144.45) ; G2.K47 265.53,145.62 v3(265.53,145.83) ; G2.K47 v3(264.98,145.07) ; G2.AL43 v3(250.99,142.97) ; G2.T10 260.88,119.27 v3(260.88,118.97) ; G2.K16 265.49,123.87 v3(265.83,123.87) ; v3(266.18,138.21) 266.52,138.21 G2.H37 ; v3(258.79,118.97) 258.79,119.27 G2.W10 ; v3(252.83,144.93) 252.83,144.72 v3(252.39,144.27) ; G2.K8 265.46,118.24 v3(265.76,118.24) ; v3(267.79,119.77) G2.F10 v3(268.39,119.17) ; G2.AH10 252.83,119.32 v3(252.83,119.02) ; G2.AL49 250.58,146.64 250.4,146.46 v3(250.4,146.22) ; G2.K49 265.23,146.72 265.23,146.42 v3(265.09,146.27) ; G2.AY49 244.22,146.7 244.22,146.1 v3(243.88,145.77) ; G2.AY49 v3(243.99,147.07) v3(243.99,147.87) ; v3(267.18,114.45) 267.18,114.43 267.28,114.33 267.28,113.97 G2.G2 ; v3(254.49,145.67) G2.AE47 v3(255.08,145.67) ; v3(258.82,146.31) 258.9,146.39 258.9,146.68 G2.W49 ; G2.D16 269.82,124 270.22,124 v3(270.45,123.77) ; G2.D37 v3(269.78,138.66) 269.94,138.66 v3(270.39,138.21)
  BOTTOM w0.152: v1(55.21,80.6) 55.2,80.6 55.04,80.76 U2005.AA23 U2005.AA22 55.04,81.81 v1(55.09,81.86) U2005.AB22 U2005.AC22 ; U2005.B22 U2005.A22 ; U2005.L23 U2005.L22 ; v3(225.65,57.48) 226.23,57.48 U2.AM45 ; v3(235.05,50.88) 235.05,51.01 234.92,51.13 U2.BE28 ; v3(230.09,50.88) 230.09,51.11 U2.BE37 ; v3(239.36,50.75) 239.36,51.26 U2.BE18 ; U2005.A18 U2005.B18 ; U2005.AC6 U2005.AB6 ; U2005.T1 U2005.T2 ; U2005.AC8 U2005.AB8 ; v3(241.65,50.88) 241.74,50.97 U2.BE14 ; U2.P45 226.39,66.35 v3(226.28,66.25) ; U2005.A8 U2005.B8 ; U2005.AC10 U2005.AB10 ; U2005.B16 U2005.A16 ; U2005.M1 U2005.M2 ; U2.AH1 248.43,59.9 248.81,59.52 v3(248.89,59.52) ; U2005.AC16 U2005.AB16 ; v3(225.9,62.06) 226.26,62.06 U2.AC45 ; U2.AH45 226.02,59.92 v3(225.75,59.64) ; U2005.U23 U2005.U22 ; U2.A32 232.66,73.25 232.12,73.79 232.12,74.15 231.82,74.45 v3(231.82,74.58) ; v3(268.09,149.52) 268.09,150.1 268.45,150.46 v3(268.45,151.46) v3(268.45,152.35) ; U2005.B14 U2005.A14 ; v3(269.51,152.73) 269.51,152.71 269.59,152.63 269.59,150.32 269.11,149.84 269.11,148.49 v3(269.09,148.47) ; v3(265.53,151.46) 265.65,151.46 266.04,151.08 v3(266.04,150.45) v3(266.04,149.47) ; U2.BE32 v3(232.65,50.88) ; U2005.A12 U2005.B12 ; U2005.AB18 U2005.AC18 ; U2.AU1 v3(248.5,55.33) ; U2005.P1 U2005.P2 ; U2005.J22 U2005.J23 ; v3(236.82,50.5) 237.25,50.92 237.25,51.32 U2.BE23 ; U2005.E23 U2005.E22 ; v3(248.48,62.17) 248.45,62.17 248.44,62.18 U2.AC1 ; 54.12,81.48 U2005.W22 54.12,81.02 ; U2.A18 v3(239.48,73.61) ; U2005.A10 U2005.B10 ; U2005.AC20 U2005.AB20 ; U2005.A20 U2005.B20 ; U2005.H1 U2005.H2 ; 52.28,81.02 U2005.R22 ; U2005.AC12 U2005.AB12 ; U2005.K1 U2005.K2 ; U2005.N22 U2005.N23 ; U2005.G22 U2005.G23
  BOTTOM w0.178: U2005.M2 50.9,90.55 v1(50.65,90.3) ; U2005.R5 U2005.T5 ; U2005.C22 U2005.B22 ; U2005.C22 U2005.C23 ; U2005.C22 46.76,81.82 v1(46.7,81.87) ; U2005.D13 47,85.37 v1(46.71,85.09) ; v1(49.92,90.24) 49.92,90.6 U2005.K2 ; v1(46.71,85.09) 46.66,85.14 U2005.B14 ; v1(46.71,85.09) 47,84.8 U2005.D15 ; U2005.M19 50.9,82.81 v1(50.57,82.48) ; U2005.E11 U2005.E9 U2005.D9 47,87.31 v1(46.72,87.03) ; G2.AF39 254.09,139.61 G2.AF38 ; U2005.Y13 54.8,85.46 v1(55.07,85.73) ; U2005.J8 49.59,88.01 v1(49.27,88.33) U2005.H8 ; U2005.D8 47,88.05 v1(46.71,88.33) ; U2005.D11 47,86.66 v1(46.69,86.36) 46.99,86.06 U2005.D12 ; v1(49.27,90.28) 49.06,90.5 U2005.H2 ; U2005.J22 49.52,81.59 v1(49.27,81.83) ; U2005.G22 48.6,81.85 v1(48.61,81.87) 48.32,82.16 U2005.F20 47.68,81.54 U2005.E22 ; v1(50.57,81.86) 50.44,81.72 U2005.L22 ; U2005.AB8 55.34,87.9 v1(55.12,87.68) ; U2005.T2 52.74,90.5 v1(52.52,90.28) ; v1(47.32,88.33) 47.32,88.34 U2005.D6 ; U2005.AB14 U2005.AC14 ; v1(55.12,84.43) 55.33,84.22 U2005.AB16
  BOTTOM w0.2: v3(267.76,138.68) 267.77,138.68 G2.F37 ; 261.39,147.07 v3(261.48,147.07) 261.18,147.37 v3(261.18,147.67) ; v3(266.99,138.66) 267.39,139.05 G2.G38 ; v3(264.98,116.97) G2.K6 ; G2.BF2 240.2,113.98 v3(240.2,114.63) ; v3(267.79,136.67) 267.55,136.44 v3(267.2,136.44) ; G2.F31 267.79,133.88 v3(267.76,133.88) ; v3(265.58,136.57) 266.35,136.57 v3(266.36,136.58) ; v3(269.09,136.55) 269.04,136.55 268.6,136.11 v3(268.52,136.11) ; v3(264.98,118.37) G2.K8 ; G2.K51 265.28,147.97 265.22,147.91 265.22,147.8 265.12,147.71 v3(265.12,147.7) ; G2.AF38 254.09,138.9 G2.AF37 ; G2.AP45 248.29,144.16 248.29,144.43 248.48,144.63 ; v3(254.93,114.85) 254.93,115.12 G2.AE4 ; G2.B52 v3(271.21,149.19)
  BOTTOM w0.203: U1.AL4 U1.AK4 168.58,132.57 168.82,132.57 U1.AJ3 ; v1(46.69,88.98) 46.53,88.82 U2005.B6 ; G2.AH10 v3(252.28,119.07) ; U1.AD11 v2(174.03,137.69) ; v2(174.03,137.69) 174.31,137.98 U1.AC12 174.63,138.12 175.25,138.12 U1.AA12 ; v2(174.03,137.69) 173.74,137.98 U1.AD12 ; U2005.W6 54.15,88.66 v1(53.82,88.33) ; U1.BN14 151.27,139.63 151.27,139.7 v2(151.59,140.02) ; v1(53.82,88.33) 54.15,88.01 U2005.W8 U2005.W9 ; v1(53.82,88.33) 53.5,88.01 U2005.V8 U2005.V9 ; v1(53.82,88.33) U2005.V6 v1(53.17,88.98) ; U2005.R19 52.2,82.81 v1(52.52,83.13) ; U1.BM18 151.89,142.75 151.29,142.75 U1.BN18 ; U1.BH8 U1.BH7 154.37,134.38 154.23,134.24 154.23,134.11 U1.BH6 ; U2005.H20 48.95,82.16 v1(49.27,81.83) 49.6,82.16 U2005.J20 ; U2005.AB14 55.07,85.14 U2005.Y13 ; U1.D12 188.17,138.11 188.36,137.92 188.36,137.78 U1.C11 188.65,137.43 v2(188.97,137.1) ; v3(229.97,73.49) 230.37,73.09 U2.A37 230.37,72.96 230.31,72.9 230.31,72.44 U2.B37 U2.C37 ; U1.BM29 151.97,151.39 152.52,151.39 U1.BL29 ; v2(188.7,132.11) 188.59,132 U1.C2 ; v2(188.7,132.11) 188.18,132.11 U1.D3 187.85,132.32 187.82,132.32 U1.E4 187.22,132.92 186.84,132.92 U1.F4 ; v2(188.7,132.11) 188.79,132.2 U1.B3 ; v3(226.16,54.94) 226.16,55.11 U2.AU45 ; U2.BE9 244.04,50.86 v3(243.94,50.75) ; U1.AP12 165.51,137.98 v2(165.8,137.69) ; v2(170.37,138.29) 170.19,138.11 170.18,138.11 170.05,137.98 U1.AH12 ; v1(53.17,88.98) U2005.V5 v1(53.82,88.98) U2005.W5 ; v1(53.17,88.98) U2005.T5 ; v3(238.25,72.03) 238.41,72.03 238.85,71.59 U2.D19 ; U2005.A22 45.43,81.06 45.43,80.52 45.23,80.32 44.7,80.32 43.91,79.53 v2(43.91,79.45) ; v2(185.61,133.09) 185.52,133.09 U1.J4 U1.K4 ; v2(185.61,133.09) 185.93,133.42 U1.G5 ; v2(185.61,133.09) 185.93,132.77 U1.G4 186.16,132.92 186.53,132.92 U1.F4 ; U1.K4 184.43,132.84 184.43,133.35 184.36,133.42 ; U1.K4 184.4,132.72 184.4,132.12 U1.K3 ; 54.12,81.48 54.12,81.56 v1(53.82,81.86) ; v2(171.79,130.27) U1.AF1 U1.AF2 ; v2(153.09,153.86) 153.41,153.54 U1.BJ32 ; U2.V45 226.39,64.32 226.03,63.96 v3(225.93,63.96) ; D60.1 14.69,82.44 v2(14.78,82.35) ; U1.G5 186,133.49 186.06,133.54 186.06,134.01 U1.G6 ; U1.G5 186.14,133.56 U1.F5 ; v1(53.82,81.86) 54.12,82.16 U2005.W20 ; v1(53.82,81.86) 53.52,82.16 U2005.V20 ; U1.BM27 152.24,150.19 v2(152.24,150.26) ; U1.C5 188.15,133.07 v2(187.82,133.07) ; U1.BB1 U1.BB2 ; v2(165.8,136.42) v2(165.8,137.05) ; v2(165.8,136.42) 165.54,136.68 U1.AP10 ; v2(165.8,136.42) 165.8,136.42 v2(165.8,135.78) ; v2(165.8,137.05) 165.62,137.05 U1.AP11 ; v2(165.8,137.05) 165.8,137.69 v2(165.8,137.69) ; U1.AG10 170.85,136.68 171.2,137.03 v2(171.29,137.03) ; C208.1 242.54,45.75 242.54,43.92 242.79,43.67 245.31,43.67 245.54,43.89 245.54,45.8 C205.1 ; U2005.L13 v1(49.92,85.08) ; U1.F4 186.79,132.66 U1.F3 186.79,132.11 186.46,131.79 ; v2(186.95,156.47) 186.97,156.5 186.97,157.37 U1.E38 ; v2(166.76,130.27) U1.AM1 U1.AM2 U1.AM3 166.83,132.19 166.83,132.7 U1.AM4 ; U2.AY45 226.21,53.55 v3(225.9,53.55) ; U2005.M20 50.87,82.16 v1(50.57,81.86) 50.27,82.16 U2005.L20 ; v1(46.71,88.33) 46.3,87.92 U2005.B8 ; U1.AJ3 169.15,132.12 v2(168.83,131.79) ; U1.AJ3 169.3,132.09 169.3,131.49 U1.AJ2 U1.AJ1 v2(169.27,130.27) ; v1(52.52,83.13) 52.85,83.46 U2005.T18 ; v1(52.52,83.13) 52.2,83.46 U2005.R18 ; U2005.N9 v1(51.22,87.03) ; v1(51.22,87.03) 51.54,86.71 U2005.N11 ; v1(51.22,87.03) 50.9,86.71 U2005.M11 ; v1(56.48,80.98) 56,81.46 U2005.AC22 ; U1.A10 v2(190.58,136.71) ; v1(46.69,86.36) 46.4,86.06 U2005.B12 ; v1(53.17,85.08) 53.49,84.76 U2005.V15 ; v1(53.17,85.08) 52.85,84.76 U2005.T15 52.85,84.76 v1(52.52,84.43) 52.84,84.11 U2005.T16 52.85,84.11 v1(53.17,84.43) 53.49,84.11 U2005.V16 ; v1(53.17,85.08) U2005.T13 ; v2(165.8,137.69) 166.08,137.98 U1.AN12 166.51,138.24 166.8,138.24 167.06,137.98 167.17,137.98 U1.AM12 167.33,138.14 167.82,138.14 167.98,137.98 U1.AL12 168.43,138.33 v2(168.54,138.33) ; U1.A18 190.49,143.01 v2(190.59,142.91) ; U1.A16 v2(190.58,141.43) ; 153.87,140.42 U1.BJ15 ; v3(256.58,118.47) 256.58,118.37 G2.AB8 ; U2005.J12 49.6,86.06 v1(49.92,85.73) 49.6,85.41 U2005.J13 ; U1.BT4 148.84,132.83 v2(148.71,132.77) ; U1.BF12 156.44,138.22 156.87,138.22 U1.BD12 157.11,137.98 157.28,137.98 v2(157.57,137.69) ; U1.BN4 151.81,132.43 U1.BM3 151.89,132.35 U1.BM2 ; U2005.B16 46.46,84.22 v1(46.67,84.43) 46.99,84.11 U2005.D16 ; U2005.N15 51.54,84.76 v1(51.22,85.08) 51.55,85.41 U2005.N13 ; U1.AF2 171.66,131.47 171.36,131.76 v2(171.34,131.76) ; U1.AF2 171.81,131.49 171.81,132.09 U1.AF3 U1.AF4 172.28,133.26 172.28,133.82 172.54,134.07 U1.AE6 U1.AD6 173.46,134.07 173.85,134.45 v3(174,134.45) 174.01,134.45 174.3,134.15 174.3,134.07 ; v2(179.52,137.05) 179.43,137.05 U1.T10 ; v2(171.28,135.78) 171.23,135.78 U1.AG8 ; U1.F8 186.7,135.2 v2(187.02,135.53) ; v2(184.12,146.16) U1.J22 ; U1.T3 179.2,132.12 v2(178.89,131.81) ; U1.A14 v2(190.58,139.86) ; U2005.J15 49.59,84.76 v1(49.27,85.08) ; U2.AL4 246.61,58.33 v3(247.03,58.75) ; U1.BF6 U1.BG6 ; U2005.M12 v1(51.22,85.73) 51.55,86.06 U2005.N12 ; v1(46.72,82.48) 46.62,82.38 U2005.B20 ; v1(55.12,87.68) 54.8,87.36 U2005.Y9 55.18,86.98 U2005.AB10 ; U2.N41 228.31,67.35 U2.M42 228.32,68.22 U2.L41 228.16,68.52 U2.K42 227.48,68.84 U2.K43 ; v1(49.27,85.73) 48.95,86.06 U2005.H12 ; v1(51.85,81.88) 52.27,81.46 U2005.R22 ; v1(51.85,81.88) 51.57,82.16 U2005.N20 ; v1(51.85,81.88) 52.13,82.16 U2005.R20 52.2,82.16 ; v1(46.72,87.03) 46.67,86.98 U2005.B10 ; U2007.C2 35.25,73.3 v1(35.33,73.38) ; v2(148.68,133.71) 148.77,133.63 U1.BT5 ; U1.A3 190,132.07 v2(190.45,132.52) 190.18,132.79 U1.A4 ; v2(184.13,143.01) U1.J18 ; JDIMM1.9 134.57,86.48 134.27,86.19 v2(134.27,85.8) ; v3(258.73,144.4) 258.73,144.22 G2.W45 259.28,143.68 v3(259.28,143.66) ; U2005.H13 48.95,85.41 v1(49.27,85.08) ; v2(134.47,72.6) 134.47,72.96 134.8,73.28 JDIMM3.9 ; G2.AF45 254.39,144.27 v3(254.48,144.27) G2.AE45 254.96,143.79 v3(254.96,143.52) ; v2(184.37,130.04) 184.4,130.08 184.4,130.77 U1.K1 184.46,130.91 184.46,131.37 U1.K2 ; v3(266.98,130.27) G2.H25 v3(266.39,129.67) ; U1.W5 176.86,133.37 176.86,132.81 U1.W4 U1.W3 ; U2007.E10 34.25,76.62 v1(34.44,76.43) ; U1.BT14 149.42,139.53 149.87,139.53 U1.BR14 150.04,139.55 150.54,139.55 U1.BP14 ; JDIMM1.35 141.07,88.45 141.62,89.01 142.25,89.01 v2(142.27,88.98) ; v3(154.3,150.99) 154.02,151.31 U1.BJ29 ; v2(181.85,130.04) 181.86,130.06 181.86,130.8 U1.N1 ; v2(165.8,135.78) 165.55,136.03 165.34,136.03 U1.AP9 ; v2(165.8,135.78) 165.39,135.38 U1.AP8 165.78,134.94 165.78,134.59 165.92,134.45 U1.AN6 165.87,134.02 U1.AN5 166.2,133.09 v2(166.37,133.09) 166.69,133.42 U1.AM5 ; U2005.F16 U2005.E16 47.64,84.11 v1(47.32,84.43) U2005.E15 ; U1.T2 179.38,131.42 179.38,130.86 U1.T1 179.35,130.8 179.35,130.32 v2(178.88,129.85) ; U2.E13 242.37,71.08 U2.D12 ; U1.BL6 U1.BK6 153.67,133.74 v2(153.77,133.74) ; U1.AR1 U1.AR2 164.12,131.47 v2(163.8,131.79) 163.92,131.79 U1.AR3 U1.AR4 U1.AR5 ; v2(174.03,136.42) U1.AD9 ; U1.AD10 v2(174.03,137.05) ; U2005.F6 U2005.H8 ; U2.D24 236.56,71.59 236.13,72.02 v3(235.98,72.02) ; U1.F9 186.7,135.85 v2(187.02,135.53) ; U2.D17 240.42,72.03 v3(240.53,72.03) 240.67,72.03 241.11,71.59 U2.D15 241.27,71.03 U2.E15 ; U1.C21 188.37,145.65 188.37,145.79 U1.D22 ; U1.BA6 U1.BB6 ; 148.9,155.71 149.67,155.71 U1.BR36 ; U1.A22 v2(190.58,146.16) ; JHDD1.3 v2(293.37,88.3) ; U1.BT26 149.27,149.03 148.62,149.03 v2(148.18,149.47) ; U1.C13 188.65,139 v2(188.97,138.68) ; U1.BJ12 153.54,138.02 v2(153.91,137.65) ; v2(148.71,131.92) 148.83,132.03 149.24,132.03 U1.BT3 ; U2005.W18 54.15,83.46 v1(53.82,83.13) ; U1.E9 187.35,135.85 v2(187.02,135.53) ; v2(184.84,134.47) 185.09,134.47 185.33,134.71 U1.J7 185.62,134.71 U1.G8 ; v2(184.84,134.47) 184.84,134.98 184.47,135.35 184.47,135.38 ; v2(184.84,134.47) 184.64,134.47 184.59,134.53 U1.K7 ; U1.BA12 160.02,137.98 v2(160.31,137.69) ; v2(152.24,148.68) 151.92,149.01 U1.BM26 ; U2005.E4 v1(47.97,89.63) ; v1(47.97,89.63) 47.65,89.31 U2005.E5 ; v1(47.97,89.63) 48.29,89.31 U2005.F5 ; v3(271.84,117.12) 271.55,117.4 270.92,117.4 G2.B7 270.77,117.37 v3(270.48,117.08) ; U1.BJ31 153.42,152.89 v2(153.09,152.56) 153.35,152.31 153.48,152.31 U1.BJ30 ; U2005.W13 v1(53.82,85.73) ; U1.J10 185.32,137.13 185.4,137.21 U1.H11 ; U1.F2 186.79,131.47 186.46,131.79 ; U1.A20 v2(190.58,144.58) ; U1.AU6 161.92,133.42 U1.AW5 U1.AW4 U1.AW3 161.61,132.12 v2(161.29,131.79) ; U1.AC6 174.3,134.07 ; 174.3,134.07 U1.AB6 175.44,134.37 175.55,134.37 175.65,134.48 176.06,134.48 ; U1.D6 188.65,135 U1.C8 188.65,135.2 v2(188.97,135.53) 189.3,135.85 U1.B9 U1.A9 ; v2(51.78,45.8) 52.11,45.48 U22.11 ; v2(186.37,144.19) 186.05,144.52 U1.G20 ; U1.C9 188.6,135.97 188.04,135.97 U1.D9 ; G2.AB8 v3(257.22,117.73) ; G2.AB8 v3(256.58,117.77) ; U2005.AB12 55.4,86.06 v1(55.07,85.73) ; v1(49.27,85.08) 48.95,84.76 U2005.H15 U2005.H16 U2005.J18 49.6,83.46 v1(49.92,83.13) 49.6,82.81 U2005.J19 ; U1.AW1 U1.AW2 ; U2005.E6 v1(47.32,88.33) 47.64,88.01 U2005.E8 U2005.F9 ; v2(153.74,131.79) 153.93,131.6 154.05,131.6 U1.BH2 154.19,131.3 153.93,131.05 U1.BH1 153.93,130.53 v2(154.38,130.08) ; U1.BM23 151.92,146.85 151.67,147.1 151.67,147.1 U1.BN24 ; v2(182.26,137.05) 182.07,137.05 U1.N11 ; v3(268.95,130.17) 269.14,130.17 269.34,129.97 G2.D25 269.49,129.91 v3(269.77,129.62) 269.77,129.56 G2.D24 ; U1.AC5 174.3,133.42 174.3,132.77 U1.AC4 174.18,132.77 v2(173.86,132.44) 174.18,132.12 U1.AC3 U1.AC2 U1.AC1 ; U1.BE5 U1.BE4 U1.BE3 ; U1.T5 179.35,133.4 179.35,132.79 U1.T4 ; v2(187.02,137.1) 186.7,137.43 U1.F11 ; U1.A24 v2(190.58,147.73) ; 187.02,152.06 187.6,152.06 U1.D30 ; v2(186.37,136.32) 186.05,135.99 U1.G9 ; v2(190.85,151.34) 190.4,151.34 U1.A28 ; v2(186.39,131.79) 186.46,131.79 ; U1.A12 v2(190.58,138.28) ; 184.47,135.38 184.53,135.44 184.53,135.96 U1.K9 184.53,136.09 184.53,136.61 U1.K10 184.53,136.74 184.53,137.26 U1.K11 ; 184.47,135.38 U1.K8 ; U1.Y13 176.58,138.36 176.85,138.36 U1.W12 177.46,138.21 177.91,138.21 U1.V12 ; U1.H25 U1.J25 ; v2(176.37,129.89) 176.82,130.33 U1.W1 U1.W2 176.49,131.79 v2(176.37,131.79) ; v1(47.31,89.64) 47,89.32 U2005.D5 ; v3(268.38,142.97) G2.F44 267.79,142.97 v3(267.79,142.87) G2.F43 268.13,142.57 v3(268.44,142.26) ; v3(261.39,145.77) 260.93,146.22 v3(260.88,146.22) 260.88,146.33 261.04,146.49 261.04,146.72 G2.T49 261.39,147.07 ; U2005.B18 46.72,83.72 v1(46.72,83.76) ; v2(13.51,83.75) 13.52,83.74 D61.1 ; v3(148.3,145.55) 148.86,144.99 149.16,144.99 U1.BT21 ; U1.BE1 U1.BE2 ; U1.H12 U1.G12
  BOTTOM w0.25: G2.F17 268.39,124.07 v3(268.39,124.02) 268.39,123.97 G2.F16 ; G2.K49 265.56,147.04 v3(265.56,147.12) 265.63,147.12 G2.J49 ; v3(242.56,149.41) 242.45,149.52 241.78,149.52 v3(241.58,149.32) ; v3(265.09,146.27) 265.09,146.27 v3(265.53,145.83) ; G2.BL10 236.66,119.54 237.03,119.54 237.2,119.71 v3(237.59,119.71) 237.74,119.71 G2.BJ10 ; G2.G51 G2.F52 v3(268.09,149.52) ; G2.AF29 v3(253.79,133.07) G2.AG30 G2.AG31 G2.AG32 253.09,135.17 v3(253.09,135.22) ; G2.AT8 v3(246.69,118.47) ; G2.W49 v3(259.33,147.11) 259.68,146.77 G2.V49 ; G2.H37 266.69,138.37 266.97,138.66 v3(266.99,138.66) ; v3(246.15,117.71) 246.15,117.83 G2.AU8 ; G2.G38 267.76,138.7 v3(267.76,138.68) ; G2.T51 261.09,147.77 v3(261.18,147.67) ; v3(259.28,143.66) 259.28,142.88 v3(259.28,142.87) G2.W43 ; G2.AE43 254.48,142.87 v3(254.48,142.94) ; G2.J52 265.98,149.42 v3(266.04,149.47) ; G2.D30 v3(269.88,133.87) 269.79,133.87 G2.D31 ; v3(261.39,117.07) 261.39,116.97 G2.T6 ; v3(254.5,115.68) 254.37,115.68 G2.AF5 ; v3(267.09,117.06) 267.39,116.76 G2.G6 ; G2.G4 267.42,115.27 267.61,115.08 v3(267.61,114.83) ; G2.AV9 245.87,118.77 246.09,118.54 v3(246.09,118.52) ; v3(252.82,114.28) 253.1,114.28 G2.AG3 253.09,114.87 v3(252.83,114.87) ; G2.BE10 v3(240.48,119.17) ; G2.AW52 v3(244.69,149.17) 244.31,149.17 v3(244.13,148.99) ; G2.F37 268.41,138.05 v3(268.42,138.05) ; G2.AL6 250.29,116.96 v3(250.29,117.05) ; v3(261.48,147.07) G2.R49 ; G2.T8 260.85,117.83 v3(260.85,117.5) 260.52,117.5 G2.U7 ; v3(263.54,116.97) 263.84,116.67 G2.M6 ; v3(269.87,149.31) 269.87,149.19 G2.C52 270.39,149.08 v3(270.39,149.61) ; G2.G49 267.09,147.06 v3(267.09,147.17) ; v3(265.88,140.62) 265.44,140.62 G2.K40 ; G2.V38 259.39,138.77 v3(259.39,138.72) 259.39,138.67 G2.V37 ; v3(252.77,147.53) 252.61,147.38 252.61,146.84 G2.AH49 252.81,146.64 v3(252.81,146.19) ; G2.BE19 v3(240.48,125.47) ; G2.BE30 v3(241.09,133.77) ; G2.R52 v3(261.79,149.33) ; G2.BC4 242.04,115.12 v3(242.04,114.51) ; G2.AF1 v3(254.09,112.69) ; v3(264.98,145.07) 264.98,144.93 v3(265.47,144.45) ; v3(257.19,114.97) G2.AB4 ; v3(239.83,126.02) 239.64,126.02 G2.BG19 ; G2.AH47 252.83,145.22 v3(252.83,144.93) ; v3(243.88,145.77) G2.BA48 ; v3(248.59,143.2) 248.63,143.15 248.63,142.71 G2.AP43 ; G2.BE21 v3(241.09,127.47) ; v3(257.18,147.07) 257.28,147.07 G2.AA49 ; v3(268.47,115.6) 268.49,115.62 268.49,115.67 G2.E5 ; v3(259.39,139.42) 259.39,139.47 G2.V39 ; v3(268.6,117.62) 268.6,117.88 G2.E8 ; G2.BE31 v3(240.48,133.87) ; G2.AY10 v3(243.99,119.17) ; G2.BE18 v3(241.09,125.37) ; G2.AY8 v3(244.58,117.77) ; G2.BG31 v3(239.69,134.47) ; G2.BK1 237.29,112.79 v3(237.21,112.72) ; G2.V52 v3(259.69,149.35) ; v3(266.18,138.21) 265.72,138.67 v3(265.58,138.67) G2.J38 ; G2.BG10 v3(239.69,119.77) ; G2.AA8 v3(257.17,118.49)
  BOTTOM w0.254: U1.J10 185.47,136.86 185.89,136.86 U1.G10 186.05,136.64 v2(186.37,136.32) ; v1(55.12,83.11) 55.31,83.3 U2005.AB18 ; G2.D13 269.79,121.27 v3(269.79,121.17) G2.D12 ; JDIMM1.251 197.07,88.89 v2(196.98,88.98) ; 236.66,69.6 U2.H24 ; v3(263.34,117.52) 263.34,117.92 G2.N8 263.47,118.36 v3(263.47,118.43) ; JDIMM1.51 145.07,88.91 144.37,89.61 v2(144.18,89.61) ; v2(188.97,135.53) 188.97,135.6 U1.C9 188.65,136.06 U1.D10 ; v2(65.63,61.93) v2(65.63,63.45) 65.63,64.6 65.88,64.85 U2014.31 ; U1.AY33 160.9,154.52 ; 160.9,154.52 U1.AY34 ; 160.9,154.52 v2(160.96,154.52) ; JDIMM3.40 142.55,64.65 v2(142.6,64.6) 141.6,64.6 141.55,64.65 JDIMM3.36 ; v3(227.36,67.75) 227.38,67.78 U2.M42 ; U1.BE1 156.71,130.8 156.71,130.3 156.27,129.85 v2(156.26,129.85) ; U1.BA6 160.05,134.53 U1.BA7 ; v3(236.06,52.33) 236.06,52.76 U2.BB25 ; G2.BC13 242.08,121.67 241.49,121.67 v3(241.09,121.27) G2.BE13 ; v2(246.5,198.1) 246.36,198.23 PU1606.5 ; U1.BL13 152.64,138.84 v2(152.96,139.16) ; v3(269.85,117.66) 269.56,117.37 G2.D7 269.45,117.37 269.21,117.13 v3(269.07,117.13) ; U2.A42 227.75,73.29 v3(227.53,73.51) ; v3(234.92,71.45) 234.92,71.83 U2.C28 ; v3(234.92,71.45) 235.29,71.45 U2.D27 ; v3(234.92,71.45) 234.58,71.45 U2.D29 233.78,71.59 U2.D30 ; v3(228.44,63.33) 227.98,63.33 U2.AA42 ; G2.D43 269.58,142.66 270.09,142.66 v3(270.33,142.42) 270.48,142.57 G2.B43 ; U1.C13 188.65,139.21 U1.D14 ; v2(75.91,91.65) 75.8,91.53 U2016.3 ; JDIMM1.89 154.57,88.89 154.65,88.98 v2(155.61,88.98) ; G2.BD29 v3(241.79,132.47) ; 207.64,186.17 208.04,186.56 PU1603.5 ; G2.AP2 248.49,114.2 v3(248.58,114.29) ; JDIMM3.30 140.05,65.15 v2(140.6,64.6) 139.54,64.6 139.05,65.09 JDIMM3.26 ; v2(164.89,139.64) 164.53,139.28 U1.AR14 ; U1.AW1 161.73,130.78 161.31,130.36 v2(161.31,129.78) ; v2(71.6,96.73) R390.1 R391.1 R399.1 R398.1 R397.1 R394.1 R393.1 ; 234.92,54.46 235.15,54.69 235.35,54.69 235.43,54.77 U2.AV27 ; 234.92,54.46 234.92,54.44 234.59,54.11 U2.AW29 ; 234.92,54.46 v3(234.92,54.49) ; U1.BN7 151.27,134.44 151.34,134.37 v2(151.34,134.34) 151.36,134.34 151.72,133.99 U1.BM6 ; G2.BG34 v3(239.69,136.57) ; G2.AK44 251.28,143.27 v3(250.99,142.97) ; U1.G14 186.05,140 U1.F15 ; v3(266.29,121.82) 266.38,121.82 266.64,121.57 G2.H13 266.75,121.57 v3(267.06,121.88) ; v3(252.82,114.28) 252.69,114.15 G2.AH2 ; v2(204.16,198.07) 203.86,198.37 203.76,198.37 203.57,198.56 JEDP1.7 ; JKB1.42 71.09,16.41 v2(70.87,16.64) ; JEDP1.16 199.07,197.78 v2(199.18,197.67) ; U2007.F1 33.75,72.08 v1(33.62,71.94) ; JDIMM3.52 145.55,65.14 145,64.6 v2(144.85,64.6) 144.78,64.6 144.55,64.82 JDIMM3.48 ; v2(146.21,88.98) 146.57,88.62 JDIMM1.57 ; v3(265.99,112.6) 265.98,112.61 G2.J1 ; U2.D10 243.61,71.59 U2.C10 ; G2.B28 270.33,132.07 v3(270.26,131.99) 270.26,132.69 G2.C29 ; U2005.T9 U2005.V8 ; JDIMM3.214 v2(188.05,64.6) 188.6,64.6 189.05,65.04 JDIMM3.218 ; v2(150.94,154.2) 151.27,154.52 U1.BN34 ; v2(150.94,154.2) 150.62,153.87 U1.BP33 ; v2(150.94,154.2) 150.62,154.52 U1.BP34 U1.BR34 ; U1.BK18 U1.BJ18 ; U2.BB16 240.76,52.91 v3(240.76,53.37) ; v1(30.58,72.22) 31.08,72.22 U2007.L1 ; 186.37,147.27 v2(186.37,147.34) ; 186.37,147.27 U1.G23 186.15,146.84 186.15,146.77 v2(186.37,146.55) ; 186.37,147.27 U1.F23 186.7,146.88 v2(186.37,146.55) ; v3(263.36,145.76) 263.36,145.55 G2.N47 ; U1.AU34 163.26,154.52 ; 163.26,154.52 U1.AU33 ; 163.26,154.52 v2(163.33,154.52) ; v3(229.2,50.88) 228.75,51.34 U2.BE40 ; v2(202.28,200.61) 202.07,200.4 JEDP1.10 ; JDIMM1.231 192.07,88.71 v2(191.8,88.98) 191.23,88.98 191.07,88.82 JDIMM1.227 ; v2(301.62,28.38) JIO1.40 ; v2(247.49,44.45) 247.49,45.29 247.7,45.5 U4.3 ; JDIMM3.68 149.55,65.04 v2(149.1,64.6) ; v2(186.37,144.19) 186.37,144.12 U1.F19 186.37,143.47 v2(186.37,143.4) ; U1.D26 188.65,148.66 U1.C25 188.65,148.45 v2(188.32,148.13) ; v2(163.05,135.77) 163,135.77 162.61,135.38 U1.AU8 U1.AU7 ; U1.BM12 152.24,138.38 v2(152.24,138.45) 151.92,138.77 U1.BM13 ; G2.BD32 241.49,134.86 v3(241.78,134.57) ; v3(231.75,52.34) 231.61,52.48 U2.BB34 ; v2(75.58,76.48) 75.58,76.4 75.53,76.35 U2013.31 ; G2.AF35 254.09,137.02 v3(254.39,137.32) 254.09,137.62 G2.AF36 G2.AF37 ; U1.BN30 151.27,152.3 v2(150.94,152.62) 150.94,152.69 U1.BN31 ; 162.99,136.4 162.86,136.4 162.6,136.66 U1.AU10 U1.AU11 U1.AU12 162.37,137.75 161.91,137.75 U1.AW12 U1.AY12 160.6,137.98 v2(160.31,137.69) 160.22,137.69 U1.BA11 ; 162.99,136.4 v2(163.05,136.4) ; 162.99,136.4 162.61,136.03 U1.AU9 ; v2(305.53,94.24) 305.48,94.24 305.02,94.69 PR3412.2 ; G2.AH43 252.69,142.58 v3(252.98,142.87) 253.37,143.27 G2.AG44 ; G2.N10 263.04,119.32 v3(263.04,118.92) ; G2.K25 265.35,129.97 v3(265.66,129.66) ; U1.G16 186.05,141.37 v2(186.37,141.04) ; 157.49,137.05 157.39,137.05 U1.BD11 ; 157.49,137.05 U1.BD10 ; 157.49,137.05 v2(157.57,137.05) ; U1.BL35 152.51,155.49 v3(152.25,155.75) 151.92,155.42 U1.BM35 ; v2(66.29,16.38) 66.8,16.38 67.09,16.09 JKB1.50 ; v2(155.61,88.98) 155.57,88.94 JDIMM1.93 ; v2(155.61,88.98) 156.81,88.98 157.07,88.72 JDIMM1.99 ; G2.BC6 241.88,116.37 v3(241.88,116.32) ; v2(152.43,157.84) 152.77,157.5 U1.BL38 ; 159.1,89.61 v2(160.18,89.61) ; 159.1,89.61 159.07,89.58 JDIMM1.107 ; 159.1,89.61 158.85,89.61 158.46,89.23 158.46,88.93 158.07,88.53 JDIMM1.103 ; 205.36,188.2 205.73,188.57 PU1603.26 ; G2.A32 v3(272.13,134.87) ; v2(200.76,198.07) 200.57,198.26 JEDP1.13 ; 176.55,64.65 176.05,65.15 JDIMM3.166 ; 176.55,64.65 JDIMM3.168 ; 176.55,64.65 v2(176.6,64.6) ; v2(168.54,136.42) 168.47,136.42 U1.AL9 ; Q95.4 279.06,192.79 279.62,192.23 v2(279.62,192.1) ; 172.71,154.52 U1.AE34 ; 172.71,154.52 v2(172.78,154.52) ; 172.71,154.52 U1.AE33 ; JDIMM3.234 193.05,65.19 193.64,64.6 194.02,64.6 ; v2(27.43,4.19) 27.43,5.08 27.76,5.41 JDBUG1.5 ; v2(171.96,140.47) 171.96,139.62 171.74,139.4 U1.AF14 U1.AF13 U1.AF12 171.74,137.95 171.45,137.67 v2(171.28,137.67) 171.19,137.67 170.85,137.33 U1.AG11 ; U1.F17 186.37,142.55 v2(186.37,142.62) ; v2(208.17,119.61) 208.15,119.61 PC3579.2 ; U2.W38 230.09,63.65 v3(230.09,63.33) 230.09,63.15 U2.AB38 ; 162.47,157.12 U1.AV38 ; 162.47,157.12 U1.AV37 ; 162.47,157.12 v2(162.54,157.12) ; v2(283.46,17.53) 282.99,17.05 JSPBL1.10 ; v3(158.54,138.28) 158.84,137.98 U1.BB12 ; v3(250.29,144.3) 250.58,144 G2.AL45 ; PR3572.1 305.66,91.93 v2(305.74,91.85) ; JDIMM1.185 180.57,88.72 180.31,88.98 v2(179.74,88.98) 179.57,88.81 JDIMM1.181 ; v2(150.94,140.02) 150.94,140.02 150.95,140.01 150.95,139.96 U1.BP14 ; v2(157.57,137.69) 157.85,137.98 U1.BC12 U1.BC13 ; v1(55.09,81.86) U2005.Y20 ; v3(267.61,127.7) 267.92,127.7 G2.F22 ; G2.AR9 248.14,119.12 v3(248.2,119.12) ; U1.P37 180.72,157.12 ; 180.72,157.12 U1.P38 ; 180.72,157.12 v2(180.65,157.12) ; 175.13,186.17 175.53,186.56 PU1502.5 ; v2(280.77,77.17) 280.75,77.18 JWLAN1.1 ; U2022.G10 v3(240.87,169.15) 240.87,169.15 U2022.F10 v3(240.87,168.35) ; R1019.2 R2257.2 v2(229.46,125.17) ; U2025.L10 292.63,118.29 v3(292.23,118.69) ; 150.29,142.45 U1.BR18 149.64,142.45 ; 150.29,142.45 U1.BP18 U1.BN18 ; 150.29,142.45 v2(150.29,142.38) ; v3(267.47,112.51) 267.55,112.51 267.93,112.14 267.93,111.69 267.58,111.34 v3(267.47,111.34) 267.29,111.34 266.74,111.9 266.74,113.11 G2.H1 ; v2(44.16,45.8) 43.45,45.08 U26.3 ; G2.BD35 241.49,136.97 v3(241.83,136.63) ; PR3415.2 309.72,96.6 v2(309.85,96.73) ; G2.F13 268.11,121.57 v3(268.42,121.25) ; G2.BE28 v3(240.48,131.77) ; 181.51,154.52 v2(181.44,154.52) ; 181.51,154.52 U1.N33 ; 181.51,154.52 U1.N34 ; v3(241.09,131.67) 240.79,131.37 G2.BE27 ; U1.BR7 149.97,134.97 v2(150.29,135.3) 150.62,134.97 U1.BP7 ; G2.BD26 v3(241.78,130.37) ; JDIMM3.180 179.55,65.15 v2(180.1,64.6) 180.55,65.04 JDIMM3.184 ; v2(179.51,137.69) 179.23,137.98 U1.T12 U1.T13 178.92,138.63 v2(178.6,138.95) 178.92,139.28 U1.T14 ; v2(179.51,137.69) 179.8,137.98 U1.R12 180.1,138.11 180.75,138.11 U1.P12 181.02,138.11 181.67,138.11 U1.N12 181.97,137.98 v2(182.26,137.69) 182.54,137.98 U1.M12 U1.M13 U1.M14 ; v2(179.51,137.69) 179.42,137.69 U1.T11 ; JDIMM3.82 153.05,64.65 v2(153.1,64.6) ; U1.AJ6 169.15,134.07 168.49,134.73 U1.AL7 U1.AL8 168.13,135.38 v2(168.54,135.78) ; U1.AJ6 169.29,134.05 169.29,133.43 U1.AJ5 169.35,133.34 169.35,132.84 U1.AJ4 ; U1.AJ6 U1.AH6 U1.AG6 170.83,134.19 U1.AG7 U1.AG8 ; U1.F36 186.26,155.85 186.13,155.85 U1.H35 185.12,156.14 U1.J36 ; U1.F36 186.88,156.47 v2(186.95,156.47) ; U1.F36 186.89,155.8 v2(186.96,155.8) 187.27,155.49 U1.E35 187.34,154.82 U1.E34 187.28,154.75 187.26,154.75 v2(186.98,154.48) 187.03,154.43 187.63,154.43 188,154.06 U1.D33 ; U1.BM21 151.92,145.07 v2(151.59,144.75) ; JDIMM1.201 184.57,88.6 v2(184.94,88.98) 185.26,88.98 185.57,88.67 JDIMM1.205 ; G2.AB10 v3(256.59,119.17) ; JDIMM1.175 178.07,88.96 v2(178.09,88.98) ; G2.BG28 239.39,132.07 v3(239.69,132.37) ; 150.94,151.77 U1.BP29 150.62,151.48 v3(150.28,151.81) 150.26,151.81 149.97,151.53 U1.BR29 ; 150.94,151.77 150.94,151.76 U1.BN29 ; 150.94,151.77 v2(150.94,151.84) ; 228.5,72 v3(228.54,71.96) ; 228.5,72 U2.B40 ; 228.5,72 228.46,72.04 U2.C42 ; v2(176.37,131.79) 176.54,131.96 176.66,131.96 U1.W3 ; G2.BM2 235.88,113.67 v3(236.13,113.42) 236.58,113.87 G2.BL2 ; v3(244.47,87.92) U2026.E1 v3(243.67,87.92) ; v1(36.42,71.83) 36.39,71.86 36.39,72.24 U2007.A1 ; U1.BB2 158.89,131.79 v2(158.77,131.79) 159.1,132.12 U1.BB3 159.23,132.13 159.23,132.75 U1.BB4 159.23,132.78 159.23,133.4 U1.BB5 159.1,133.42 v2(158.77,133.74) ; R2283.2 R2284.2 59.35,94.06 v2(59.86,93.55) 59.86,92.54 R2057.2 ; v3(268.53,127.62) 268.09,127.17 G2.F21 ; v2(47.5,36.96) 47.03,37.43 U58.3 ; G2.AW5 G2.AW4 244.98,115.27 v3(244.65,114.94) 244.62,114.94 244.29,115.27 G2.AY4 ; PU1606.19 243.12,199.38 PU1606.26 ; v3(270.33,129.82) 270.48,129.97 G2.B25 ; v3(244.4,114.3) 244.29,114.18 G2.AY2 ; G2.B31 270.55,134.17 v3(270.44,134.07) ; PC3435.2 v2(306.55,98.63) ; G2.BL1 236.57,113.17 v3(236.23,112.82) ; v2(301.62,36.2) 301.62,36.37 301.21,36.78 JIO1.19 ; 181.82,197.05 PU1306.7 ; 246.35,62.18 246.63,61.91 U2.AD4 246.53,61.58 U2.AE4 246.53,60.47 U2.AG4 ; G2.N49 262.99,146.96 262.99,147.44 v3(263.22,147.66) 263.19,147.69 G2.N51 ; PC1269.2 220.26,44.71 v2(221.08,43.89) ; U1.G12 186.44,138.68 v2(187.02,138.68) ; v2(183.92,133.74) 184.11,133.74 184.36,133.49 184.36,133.42 U1.K5 ; v2(161.29,131.79) 161.61,131.47 U1.AW2 ; PQ1405.1 208.75,193.38 v2(209.01,193.12) 209.01,194.01 209.38,194.38 PQ1405.4 ; JIO1.46 v2(301.47,25.98) ; U1.T3 179.37,132.15 179.37,132.73 U1.T4 ; U1.G26 185.72,149.63 v2(185.72,149.7) ; JDIMM3.94 156.05,65.1 155.54,64.6 v2(155.16,64.6) 155.05,64.71 JDIMM3.90 ; U2.AV24 236.54,54.78 237.16,55.4 v3(237.16,56.47) ; v2(151.59,144.75) 151.59,144.68 U1.BN20 151.1,144.18 151.1,143.74 U1.BN19 ; v2(151.59,144.75) 151.27,145.07 ; U1.AU7 163.26,134.07 U1.AT6 ; U1.AU7 162.6,134.1 U1.AU6 ; v2(152.18,88.98) 153.34,88.98 153.57,88.75 JDIMM1.85 ; v2(152.18,88.98) 152.57,88.59 JDIMM1.81 ; v2(152.18,88.98) 151.86,88.98 151.57,88.69 JDIMM1.77 ; U2.E13 242.01,70.97 v3(241.78,71.2) ; v1(35.38,76.13) 35.51,76.13 U2007.B8 ; JDIMM3.230 192.05,65.03 191.75,64.73 191.74,64.73 v2(191.6,64.6) ; G2.C5 v3(270.49,115.67) ; v3(268.52,136.11) 268.24,136.11 G2.F34 268.09,136.37 v3(267.79,136.67) G2.F35 ; U2.AC25 236.06,62.55 v3(236.06,62.56) ; v2(181.39,88.98) 181.57,88.8 JDIMM1.189 ; JDIMM3.98 157.05,64.87 v2(157.32,64.6) 157.6,64.6 158.05,65.04 JDIMM3.102 ; v3(240.48,138) 240.48,138.01 240.79,138.32 G2.BE37 ; v2(148.1,64.6) 148.55,65.04 JDIMM3.64 ; v2(144.18,85.17) 143.86,85.17 143.61,85.42 143.61,86.19 144.07,86.65 JDIMM1.47 ; G2.BG37 239.39,138.37 v3(239.68,138.66) ; v2(272.75,80.22) JWLAN1.33 ; v2(152.1,64.6) 152.05,64.65 JDIMM3.78 ; JDIMM1.166 175.82,78.17 v2(176.44,77.55) ; 241.52,62.06 241.57,62.01 U2.AD14 241.68,61.52 242.03,61.17 v3(242.03,61.12) 242.03,60.79 242.33,60.48 U2.AG13 ; U2.AE42 228.61,60.96 v3(228.7,61.04) ; G2.AU45 246.39,143.92 v3(246.69,143.62) ; v2(160.31,136.42) 160.24,136.42 U1.BA9 ; v2(152.24,150.26) 151.92,150.58 U1.BM28 ; v3(190.37,149.69) 189.99,149.31 U1.A26 ; U1.BM29 151.6,151.76 v2(151.6,151.84) ; v3(247.03,58.75) 246.93,58.86 U2.AK4 ; U1.AY14 160.77,139.51 v2(160.37,139.91) ; v3(273.28,92.52) 273.08,92.32 U60.H1 ; U1.V30 U1.V29 177.89,151.49 v3(178.43,150.96) ; R489.2 v2(74.26,79.58) ; JKB1.46 69.09,15.12 v2(68.83,14.86) 68.59,15.1 JKB1.47 ; G2.AP4 248.61,115.15 v3(248.61,114.85) ; D33.3 19.32,55.25 v2(19.48,55.1) ; PU1501.5 164.73,186.56 164.34,186.17 ; U1.T33 179.14,154.52 ; 179.14,154.52 v2(179.07,154.52) ; 179.14,154.52 U1.T34 ; U1.D18 188,143.08 v2(188.32,143.4) 188.65,143.73 U1.C19 188.65,143.93 U1.D20 ; JIO1.22 301.22,35.58 301.62,35.18 v2(301.62,34.8) 301.21,34.38 JIO1.25 ; U1.J25 184.69,148.51 v2(184.3,148.12) ; U61.3 45.45,40.45 45.82,40.08 v2(45.82,39.83) ; v3(263.35,142.97) 263.35,142.73 G2.N43 ; v2(155.74,139.59) 155.59,139.59 U1.BG14 ; U1.BM5 151.82,133.13 v2(152.05,132.89) ; G2.BF6 G2.BG7 239.36,117.37 v3(239.04,117.69) ; v2(281.78,175.09) 281.91,175.09 282.3,174.7 Q82.1 ; JDIMM1.235 193.07,88.66 193.39,88.98 v2(193.71,88.98) 194.07,88.62 JDIMM1.239 ; U2.F44 226.96,70.63 227.3,70.29 227.3,70.18 v3(227.36,70.12) 227.5,70.12 U2.G42 ; U2.K27 234.87,68.83 v3(234.79,68.91) ; U2.AV33 232.58,54.56 v3(232.63,54.56) 232.83,54.56 U2.AV31 ; PU1602.19 184.01,187.71 PU1602.26 ; JDIMM3.2 133.05,64.65 v2(133.1,64.6) ; U1.H18 U1.G18 ; v2(16.61,162.02) 16.59,162.03 R409.2 ; v2(233.14,115.9) 233.01,115.78 226.21,115.78 225.7,116.28 R2252.2 225.01,117.3 v2(224.89,117.17) 224.89,116.41 224.07,115.6 223.54,115.6 223.03,116.11 C1400.2 ; JDIMM3.85 153.8,76.06 154.02,76.28 155.56,76.28 v2(155.61,76.23) ; U1.BA10 160.23,137.05 v2(160.32,137.05) ; U2.AV17 240.21,54.77 v3(240.76,55.32) ; JDIMM1.65 148.57,88.78 v2(148.37,88.98) 147.67,88.98 147.57,88.88 JDIMM1.61 ; v2(182.1,64.6) 182.55,65.04 JDIMM3.192 ; U2.AU35 231.13,55.43 v3(230.98,55.58) ; JDIMM1.247 196.07,88.71 195.8,88.98 v2(195.36,88.98) 195.07,88.69 JDIMM1.243 ; v2(258.69,198.07) 258.53,198.23 PU901.5 ; JDIMM3.60 147.55,65.04 v2(147.1,64.6) 146.55,65.15 JDIMM3.56 ; PC3434.2 v2(306.55,97.49) ; G2.AU4 246.5,115.15 v3(246.5,114.85) ; G2.BE34 240.78,136.27 v3(240.48,135.97) ; G2.B34 270.51,136.27 v3(270.36,136.12) ; JDIMM3.44 143.55,64.65 v2(143.6,64.6) ; v3(238.55,52.35) 238.43,52.47 U2.BB21 ; G2.AN8 v3(248.88,118.37) ; G2.B19 270.48,125.77 v3(270.33,125.62) ; D2006.3 v2(11.02,78.39) ; G2.H22 v3(266.39,128.17) ; U1.BT35 149.32,155.34 v2(148.92,155.73) ; v2(71.85,51.64) 71.47,51.26 JEC1.27 ; v3(270.33,121.4) 270.5,121.57 G2.B13 ; v3(230.98,55.58) 230.69,55.87 U2.AT36 ; v3(230.98,55.58) 230.65,55.25 U2.AU36 ; JDIMM1.256 198.32,80.45 198.72,80.85 v2(198.85,80.85) 199.32,80.38 JDIMM1.260 ; U1.BC33 158.53,154.52 ; 158.53,154.52 U1.BC34 ; 158.53,154.52 v2(158.6,154.52) ; v2(73.5,87.71) 74.21,87.71 R2315.1 ; v2(76.93,77.68) 76.98,77.73 R2239.1 R2238.1 ; v2(176.77,136.42) 176.7,136.42 ; 176.7,136.42 U1.Y9 ; 176.7,136.42 176.57,136.42 U1.Y10 ; v2(84.04,83.65) 83.89,83.8 U2019.12 ; v2(148.92,155.73) 148.9,155.71 ; v2(148.92,155.73) 148.92,155.87 149.17,156.13 U1.BT36 ; JDIMM3.6 134.05,64.88 134.33,64.6 v2(134.6,64.6) 135.05,65.04 JDIMM3.10 ; U1.T2 178.99,131.81 v2(178.89,131.81) ; U1.BG14 U1.BG13 155.32,138.63 155.77,138.18 155.99,138.18 U1.BF12 ; U1.BG14 U1.BH14 ; G2.AD44 255.49,143.25 v3(255.16,142.93) ; U1.D28 188.65,150.23 U1.C27 188.67,150.09 188.96,149.81 v2(188.96,149.72) ; U1.D30 188.32,152.13 188.32,151.99 U1.C29 188.65,151.67 189.07,152.1 190.47,152.1 190.85,151.72 v2(190.85,151.34) ; U1.F27 187.02,149.77 v2(187.02,149.7) ; v3(239.74,128.24) 239.74,128.22 G2.BG22 ; U1.P6 181.33,133.74 v2(181.4,133.74) ; G2.W4 v3(259.29,114.97) ; JDIMM3.206 186.05,64.65 186.1,64.6 v2(187.1,64.6) 187.05,64.65 JDIMM3.210 ; U1.BT26 149.37,149.03 149.92,149.03 U1.BR26 150.02,149.03 150.57,149.03 U1.BP26 ; JDIMM3.172 177.55,64.63 v2(177.51,64.6) 177.9,64.6 178.55,65.25 JDIMM3.176 ; G2.BE36 v3(241.09,137.97) ; G2.A50 v3(272.04,147.47) ; v2(158.77,129.85) 158.78,129.85 159.23,130.3 159.23,130.8 U1.BB1 ; JDIMM3.202 185.05,64.65 v2(185.1,64.6) ; v3(240.53,72.03) U2.D16 240.53,71.05 v3(240.76,70.82) 241.08,70.82 U2.E15 ; v2(184.1,64.6) 183.55,65.15 JDIMM3.196 ; U1.BN9 151.59,136.8 v2(151.59,136.87) 151.92,136.55 U1.BM9 151.79,136.35 151.79,135.82 U1.BM8 151.83,135.6 151.83,134.99 U1.BM7 ; G2.BG13 v3(239.69,121.87) ; U1.W5 177.22,133.82 177.4,133.82 U1.V6 U1.U6 179.06,134.63 U1.T7 U1.T8 179.46,135.78 v2(179.51,135.78) ; 153.87,140.42 154,140.42 v2(154.43,140.85) ; v3(252.83,114.87) 252.83,115.12 G2.AH4 ; v2(67.02,59.39) 67.38,59.04 U2014.3 ; PU901.19 255.31,199.38 PU901.26 ; U1.BD37 157.49,156.79 v2(157.82,157.12) 157.75,157.12 U1.BD38 ; v3(229.71,54.56) 229.89,54.56 U2.AW37 ; v3(229.71,54.56) 229.56,54.41 U2.AY38 ; v3(229.71,54.56) 229.23,55.04 U2.AU39 ; G2.B37 270.55,138.37 v3(270.39,138.21) ; G2.M52 v3(263.89,149.35) ; v3(243.67,86.32) U2026.C1 v3(244.47,87.12) ; G2.AB51 256.89,147.84 257.18,147.54 v3(257.18,147.07) 256.89,146.77 G2.AB49 ; G2.AB6 v3(256.58,116.37) ; v1(49.92,85.08) 50.24,84.76 U2005.L15 ; v3(270.33,140.32) 270.48,140.47 G2.B40 ; G2.AL4 250.44,115.12 250.03,115.12 G2.AM4 G2.AN4 G2.AN5 ; 162.05,188.2 162.42,188.57 PU1501.26 ; v2(26.13,46.56) 26.89,45.8 C245.1 ; v2(301.62,32.63) 301.62,32.8 301.25,33.18 JIO1.28 ; v2(148.95,136.05) 149.32,136.42 U1.BT9 ; U1.BG38 155.38,157.12 ; 155.38,157.12 U1.BG37 ; 155.38,157.12 v2(155.45,157.12) ; U1.BJ15 U1.BK15 U1.BK14 153.22,139.42 v2(152.96,139.16) ; v2(166.37,133.09) 166.53,132.92 166.57,132.92 166.73,132.77 U1.AM4 ; v1(55.11,82.45) 55.19,82.38 U2005.AB20 ; R408.2 10.89,160.3 v2(11.65,160.3) 12.42,160.3 R807.2 ; v3(265.66,121.28) 265.66,121.2 G2.J12 ; U1.BE2 156.58,131.47 v2(156.26,131.79) 156.58,132.12 U1.BE3 ; v2(76.55,70.69) 76.55,69.65 77.03,69.17 U2013.3 ; v1(55.12,88.98) 55.29,88.82 U2005.AB6 ; v2(60.8,65.1) 61.23,64.68 U2014.24 ; v2(301.62,30.78) JIO1.34 ; G2.AT4 G2.AR4 v3(248.16,115.64) ; G2.AT4 G2.AT5 ; G2.AT4 246.67,114.85 v3(246.5,114.85) ; G2.AB43 257.07,142.76 v3(257.07,143.14) ; v3(241.58,149.32) 241.49,149.23 G2.BD52 241.77,148.58 v3(242.42,148.58) ; U2013.18 v2(72.86,71.84) ; v2(75.03,93.93) 75.42,94.32 Q6.1 ; v3(246.5,114.85) 246.1,114.85 G2.AV4 ; G2.D22 269.62,128 270.05,128 v3(270.33,127.72) 270.48,127.87 G2.B22 ; v3(270.36,136.12) 270.36,135.74 G2.C33 ; v3(270.36,136.12) 270.08,136.4 269.62,136.4 G2.D34 269.2,136.55 v3(269.09,136.55) ; G2.AM9 249.9,118.77 v3(250.25,119.12) ; G2.AP8 v3(248.78,117.77) ; JDIMM3.238 194.05,64.62 194.02,64.6 ; G2.AU2 246.39,114.17 v3(246.5,114.29) ; G2.AP47 248.51,145.37 v3(248.86,145.72) ; C599.1 v2(78.02,98.89) ; G2.B16 270.56,123.67 v3(270.45,123.77) ; v2(63.6,54.82) 63.6,55.38 R942.2 R2105.2 ; U1.K2 184.04,131.79 v2(183.92,131.79) 184.11,131.98 184.23,131.98 U1.K3 ; v2(277.21,69.42) 276.5,70.13 JWLAN1.18 ; U1.BK13 153.22,138.9 v2(152.96,139.16) ; v2(174.03,135.78) 173.62,135.38 U1.AD8 U1.AD7 ; U2007.H6 32.62,74.76 v1(32.25,74.76) ; U2.H17 239.93,69.27 v3(239.47,69.27) 239.3,69.27 U2.H19 ; v2(305.79,109.8) PQ1409.4 305.24,108.49 PR416.2 ; JDIMM3.14 136.05,65.15 v2(136.6,64.6) ; v3(242.04,114.51) 242.04,114.38 242.19,114.23 G2.BC2 ; U1.BN24 151.27,147.57 v2(150.94,147.9) 150.62,147.57 U1.BP24 150.47,147.65 150.12,147.65 U1.BR24 149.92,147.55 149.37,147.55 U1.BT24 ; v3(292.9,156.94) U2023.K14 v3(292.9,156.14) U2023.K13 ; 167.2,157.12 U1.AM38 ; 167.2,157.12 U1.AM37 ; 167.2,157.12 v2(167.26,157.12) ; 185.31,153.87 v2(185.37,153.87) 185.7,153.54 U1.H32 ; 185.31,153.87 U1.J32 ; 185.31,153.87 U1.J33 ; U1.G24 186.37,148.06 v2(186.37,148.13) 186.7,148.45 U1.F25 ; v3(240.46,127.49) 240.48,127.52 240.48,127.57 240.78,127.87 G2.BE22 ; PU902.5 270.7,198.23 v2(270.86,198.07) ; U1.L30 U1.L29 183.28,151.42 v2(183.28,150.93) ; U2019.6 v2(84.15,86.8) ; v3(263.54,116.97) 263.49,116.97 G2.N6 262.87,116.35 v3(262.87,116.25) ; JDIMM3.73 150.8,75.75 v2(150.27,76.28) 149.8,75.81 JDIMM3.69 ; v3(272.09,130.72) 272.04,130.67 G2.A26 ; v2(41.8,41.99) 41.42,42.37 R555.2 ; 207.89,108.79 207.7,108.6 207.27,108.6 207.09,108.78 U25.6 ; U1.BH11 154.64,137.05 v2(154.83,137.05) ; JSSD2.57 104.83,79.54 v2(104.62,79.33) ; v2(174.3,130.27) U1.AC1 ; v3(247.78,149.39) 247.79,149.39 G2.AR52 ; U2.AR34 231.65,56.76 v3(231.74,56.85) 232.16,56.43 U2.AR33 ; v2(234.31,198.1) 234.17,198.23 PU1002.5 ; JDIMM1.167 176.07,88.61 v2(176.44,88.98) 176.75,88.98 177.07,88.66 JDIMM1.171 ; Q83.1 v2(302.24,124.91) ; JDIMM3.22 138.05,65.04 v2(137.6,64.6) 137.05,65.15 JDIMM3.18 ; U1.N10 182.06,136.42 v2(182.26,136.42) 181.87,136.03 U1.N9 U1.N8 U1.N7 181.8,134.11 U1.N6 ; U1.BH12 154.65,137.69 v2(154.82,137.69) 154.99,137.69 U1.BG12 ; 169.69,154.52 v2(169.63,154.52) ; 169.69,154.52 U1.AH34 ; 169.69,154.52 U1.AH33 ; v3(267.79,142.87) 267.67,142.75 v3(267.14,142.75) 266.87,142.75 G2.H43 ; PU1602.5 185.98,186.56 185.97,186.57 ; U2013.24 71.01,74.84 70.83,75.01 ; v2(76.55,89.23) 76.93,89.61 R2140.1 ; U1.D38 187.85,157.64 187.8,157.69 187.8,158.19 v2(187.04,158.96) ; v3(270.49,111.04) 270.57,111.04 270.99,111.46 270.99,112.37 v3(270.49,112.87) G2.C1 ; U1.D24 188,147.7 188.65,147.05 U1.C23 188.65,146.88 v2(188.32,146.55) ; U2.BB11 242.98,52.46 v3(242.84,52.33) ; R595.1 R437.1 v2(67.66,54.82) 68.29,54.18 69.06,54.18 69.44,54.56 C537.1 ; U1.T9 179.45,136.42 v2(179.51,136.42) ; v2(63.85,70.06) 64.48,69.42 R438.2 ; 165.62,154.52 U1.AP33 ; 165.62,154.52 v2(165.69,154.52) ; 165.62,154.52 U1.AP34 ; v3(227.37,58.83) 227.73,58.83 U2.AK42 ; v2(222.12,198.12) 222,198.23 PU1001.5 ; U1.BM2 151.89,131.4 v2(151.78,131.29) 151.48,131.29 U1.BN2 ; JDIMM1.217 188.57,88.91 v2(188.5,88.98) 187.67,88.98 187.57,88.87 JDIMM1.213 ; G2.K2 265.28,114.51 v3(265.37,114.6) 265.37,115.18 G2.K4 265.49,115.47 v3(265.49,115.74) ; G2.K45 265.47,144.15 v3(265.47,144.45) ; C1399.2 224.1,113.41 225.44,114.76 232.25,114.76 232.4,114.61 234.89,114.61 v3(235.41,114.09) 235.88,114.57 G2.BM3 ; v2(77.44,96.47) 77.18,96.21 Q6.4 ; U2.D45 225.77,71.64 v3(225.52,71.9) ; G2.AL2 v3(250.58,114.32) ; U2019.30 v2(79.34,85.3) ; JIO1.43 302.08,27.18 v2(302.23,27.33) ; G2.BH5 v3(238.39,115.67) ; v3(270.56,148.54) G2.C51 v3(269.86,147.84) ; U1.M6 U1.N6 ; U1.N6 181.73,134.07 v2(181.4,133.74) ; v2(181.1,64.6) 181.55,65.04 JDIMM3.188 ; v2(67.02,69.55) 67.15,69.42 C2688.1 ; U2.A25 U2.B25 v3(235.98,72.02) U2.D25 ; v2(154.1,64.6) 154.05,64.65 JDIMM3.86 ; v2(188.32,144.98) 188.65,145.3 U1.C21 ; v3(239.69,123.97) 239.39,123.67 G2.BG16 ; 164.83,157.12 v2(164.9,157.12) ; 164.83,157.12 U1.AR38 ; 164.83,157.12 U1.AR37 ; G2.AJ2 G2.AK1 v3(251.28,112.62) ; v3(270.34,144.52) 270.12,144.73 269.55,144.73 G2.D46 ; U2014.18 62.96,61.68 v2(63.21,61.93) ; v2(151.1,64.6) 150.55,65.15 JDIMM3.72 ; G2.F25 268.35,129.7 v3(268.48,129.7) ; U1.BF34 155.92,154.84 v2(156.24,154.52) 155.92,154.19 U1.BF33 ; D65.1 v2(4.98,78.63) ; JSSD2.51 v2(104.6,78.04) ; G2.AG34 G2.AG33 253.39,135.52 v3(253.09,135.22) ; D64.1 v2(4.98,76.22) ; G2.N4 263.41,115.49 v3(263.41,115.61) ; U1.A6 v2(190.51,134.36) ; U1.BG6 U1.BH6 154.09,134.07 v2(153.77,133.74) 154.09,133.42 U1.BH5 154.2,133.41 154.2,132.78 U1.BH4 154.22,132.74 154.22,132.15 U1.BH3 154.01,131.95 153.89,131.95 v2(153.74,131.79) ; 151.27,145.07 v2(150.94,144.75) 150.62,145.07 U1.BP21 150.47,144.99 150.12,144.99 U1.BR21 149.81,144.99 149.47,144.99 U1.BT21 ; 151.27,145.07 U1.BN21 ; U1.BM11 151.92,137.29 151.59,137.62 v2(151.59,137.66) 151.27,137.98 U1.BN12 151.14,138.18 150.75,138.18 U1.BP12 150.49,137.93 150.1,137.93 U1.BR12 U1.BT12 148.85,138.05 v2(148.72,138.18) ; JDIMM3.252 197.55,64.82 v2(197.33,64.6) 197.2,64.6 196.55,65.25 JDIMM3.248 ; 172.85,188.2 173.22,188.57 PU1502.26 ; G2.BE33 v3(241.09,135.87) ; JEC1.28 56.07,49.91 v2(56.64,49.91) ; R2138.1 v2(86.33,89.87) ; G2.BE16 240.78,123.67 v3(240.48,123.37) 240.79,123.07 G2.BE15 ; G2.K13 v3(265.58,121.87) ; U1.BH8 154.42,135.38 v2(154.82,135.78) 154.61,135.78 U1.BH9 ; R455.2 R940.2 v2(74.26,65.1) ; v2(190.15,88.98) 190.07,88.9 JDIMM1.223 ; v3(234.79,68.91) 234.79,68.96 U2.H27 ; v3(234.79,68.91) 234.25,69.45 U2.H29 ; JDIMM1.209 186.57,88.95 v2(186.6,88.98) ; U1.C17 188.65,142.16 v2(188.31,141.83) 188,141.51 U1.D16 188.62,140.81 188.62,140.67 U1.C15 ; v2(188.97,152.86) 188.65,153.18 U1.C31 ; PC3509.2 v2(218.92,98.5) ; U1.BT18 149.64,142.45 ; 149.64,142.45 v2(149.64,142.38) ; PR3423.2 PC3424.2 304.21,101.86 v2(304.13,101.93) ; v2(157.1,133.74) 156.77,134.07 U1.BE6 U1.BF6 ; v2(157.1,133.74) 156.77,133.42 U1.BE5 ; v2(157.1,133.74) 157.42,134.07 U1.BD6 U1.BC6 158.45,134.07 v2(158.77,133.74) ; PU1001.26 218.74,199.38 PU1001.19 ; v3(269.12,114.95) 268.8,115.27 G2.E4 ; PQ1409.1 v2(306.79,107.15) ; v2(157.57,136.42) 157.5,136.42 U1.BD9 157.36,135.78 v2(157.57,135.78) 157.16,135.38 U1.BD8 U1.BD7 ; v2(154.41,146.21) 154.33,146.21 154.05,145.93 U1.BJ22 U1.BK22 ; v3(238.47,54.05) 238.52,54.01 U2.AW19 ; U1.BA8 159.91,135.38 v2(160.31,135.78) ; U1.A34 189.95,155.37 189.66,155.66 v2(189.66,155.69) ; v2(64.23,95.71) 64.23,95.33 65.12,94.44 R392.1 ; JDIMM1.69 149.57,88.85 149.7,88.98 v2(150.27,88.98) 150.57,88.68 JDIMM1.73 ; G2.AT51 G2.AT52 246.96,148.99 v3(246.96,149.41) ; G2.AV45 v3(246.11,143.55) v3(246.62,143.03) ; G2.AP51 248.44,148.12 v3(248.44,147.72) 248.33,147.61 v3(248.33,147.18) 248.33,146.92 G2.AP49 ; U60.H2 v3(271.43,91.92) ; G2.D4 v3(269.79,115.57) ; PU1601.5 194.78,186.56 PU1601.19 194.81,187.71 PU1601.26 ; JDIMM3.222 190.05,64.89 190.34,64.6 v2(190.6,64.6) 191.05,65.04 JDIMM3.226 ; U1.AL10 168.46,137.05 v2(168.55,137.05) ; G2.BH2 v3(238.39,113.57) ; U2007.H5 32.62,74.25 32.37,74.25 v1(32.25,74.13) 32.5,73.88 U2007.H4 ; v2(176.78,137.05) 176.59,137.05 U1.Y11 ; U2.AR42 228.06,56.59 v3(228.7,56.59) 229.2,57.1 U2.AN39 ; U1.N1 181.89,130.86 181.89,131.42 U1.N2 181.68,131.63 181.57,131.63 v2(181.4,131.79) 181.47,131.79 181.79,132.12 U1.N3 181.89,132.16 181.89,132.72 U1.N4 181.89,132.81 181.89,133.37 U1.N5 181.52,133.74 v2(181.4,133.74) ; v2(186.37,146.55) 186.37,146.48 U1.G22 186.05,146.09 v2(186.37,145.76) 186.37,145.69 186.69,145.37 U1.F21 186.7,145.3 v2(186.37,144.98) ; G2.A3 272.18,114.57 v3(272.18,114.57) ; R2237.1 R2236.1 85.52,81.94 v2(85.82,82.25) ; JWLAN1.7 279.25,77.69 279.24,77.68 279.24,77.55 279.37,77.42 v2(279.37,77.17) ; U1.J22 U1.H22 ; v3(243.38,61.12) 243.09,61.4 U2.AD11 243.09,61.98 243.17,62.06 ; JDIMM1.192 182.32,77.85 182.02,77.55 v2(181.39,77.55) 181.32,77.62 JDIMM1.188 ; U2.U38 230.22,65.46 v3(230.22,65.61) ; v3(244.7,60.91) 244.62,60.99 U2.AD8 ; PU1002.19 230.93,199.38 PU1002.26 ; U1.BH10 154.63,136.42 v2(154.82,136.42) ; JDIMM1.197 183.57,88.7 v2(183.29,88.98) 182.72,88.98 182.57,88.83 JDIMM1.193 ; R541.1 v2(76.04,65.1) ; 194.02,64.6 v2(194.6,64.6) 194.99,64.6 195.55,65.16 JDIMM3.244 ; R488.2 v2(64.99,54.82) ; v2(158.77,133.74) 159.1,134.07 U1.BB6 ; PR3418.2 v2(302.99,91.9) ; 187.02,152.06 186.7,151.74 U1.F29 186.7,151.6 v2(187.02,151.28) ; v2(157.58,139.78) 158.03,139.33 U1.BC14 ; v2(176.77,135.78) 176.72,135.78 U1.Y8 U1.Y7 176.06,134.48 ; JDIMM3.256 198.55,67.98 v2(199.23,68.66) ; G2.N45 263.14,143.97 v3(262.86,144.25) ; v2(77.95,65.1) 77.82,65.23 C525.1 ; JIO1.37 302.45,29.58 v2(303.37,30.51) ; v2(159.1,64.6) 159.1,64.85 159.05,64.9 JDIMM3.106 ; U1.Y13 176.18,138.63 v2(175.86,138.94) 176.2,139.28 U1.Y14 ; v3(230.22,58.83) 230.55,59.16 U2.AJ36 ; U2022.A12 v3(242.48,164.35) ; G2.K22 v3(265.58,128.17) ; v2(188.82,200.99) 188.82,200.61 189.07,200.36 JEDP1.36 ; U1.BL29 153,151.44 U1.BK29 ; v2(301.62,31.98) JIO1.31 ; v3(233.72,52.35) 233.88,52.51 U2.BB30 ; R389.1 v2(67.69,83.19) R2314.1 ; U2.AW13 242.28,54.19 v3(241.9,54.56) 241.78,54.69 241.78,55.08 U2.AT15 ; U2.T42 227.99,65.61 v3(228.57,65.61) ; JSSD2.45 104.62,76.54 ; v2(50.26,47.2) 50.13,47.2 49.24,46.3 Q53.1 ; G2.A29 v3(272.06,132.77) ; PR3416.1 v2(306.55,96.6) ; U1.BA37 159.85,156.79 v2(160.18,157.12) 160.11,157.12 U1.BA38 ; U2023.U12 v3(287.3,155.34) ; C1340.2 v2(204.06,130.64) ; G2.BL5 236.58,115.97 v3(236.29,115.67) ; G2.B10 v3(271.18,119.17) ; PC704.2 v2(302.1,101.93) ; U1.F31 186.7,153.18 v2(187.02,152.85) ; v3(267.2,136.44) 266.86,136.44 G2.H34 266.68,136.27 v3(266.36,136.58) ; v2(152.24,148.68) U1.BM25 ; D22.1 v2(11.65,162.09) ; U2026.N1 v3(243.47,94.72) ; G2.E2 v3(269.09,113.57) ; PU902.26 267.5,199.38 PU902.19 ; G2.B5 v3(271.18,115.67) ; U2.D21 v3(238.25,72.03) ; R2104.2 v2(73.37,65.1) ; PR803.2 v2(301.59,182.83) ; 226.87,72.74 U2.B44 226.6,72.51 226.47,72.64 U2.B45 226.38,72.64 226.16,72.87 v3(226.16,73.1) 226.64,73.1 U2.A44 226.75,72.87 226.87,72.74
  BOTTOM w0.3: G2.AE2 254.79,114.23 v3(254.63,114.39) ; G2.B51 v3(271.34,148.62) ; G2.H16 266.93,123.92 v3(267.09,123.92) ; G2.BF4 240.2,115.16 v3(240.2,114.63) ; G2.U9 260.58,118.97 v3(260.88,118.97) ; v3(256.79,114.28) 256.89,114.18 G2.AB2 ; v3(250.45,147.7) 250.58,147.83 G2.AL51 ; G2.AE8 254.48,118.37 v3(254.44,118.42) ; G2.AE51 254.79,147.77 v3(254.93,147.62) 254.67,147.35 254.67,146.89 G2.AE49 ; G2.B46 270.49,144.67 v3(270.34,144.52) ; G2.H10 v3(266.98,119.77) ; v3(265.68,126.04) 265.68,126.16 G2.J20 ; G2.AH45 v3(252.39,144.27) ; G2.W8 v3(259.28,117.77) ; G2.AH51 252.69,147.62 v3(252.77,147.53) ; G2.D40 269.62,140.6 270.05,140.6 v3(270.33,140.32) ; G2.D10 269.58,119.57 v3(270.14,119.57) ; v3(250.91,145.72) 250.89,145.7 250.89,145.67 G2.AL47 ; v3(266.36,143.87) 265.91,143.41 265.91,142.88 v3(266.09,142.69) ; v3(261.39,145.77) 261.39,145.67 G2.T47 ; v3(267.14,116.22) 267.14,116.42 G2.G6 ; v3(270.33,125.62) 270.05,125.9 269.62,125.9 G2.D19 ; G2.AU51 246.39,147.62 v3(246.46,147.54) 246.25,147.33 246.25,146.9 G2.AU49 ; v3(268.51,125.52) 268.33,125.52 G2.F19 ; G2.AY51 v3(243.99,147.87) ; G2.N2 263.19,114.22 v3(263.09,114.32) ; v3(266.23,134.42) 266.44,134.42 G2.H31 ; G2.T2 261.09,114.17 v3(260.93,114.32) 261.27,114.65 261.27,115.08 G2.T4 ; v3(267.79,117.07) G2.F7 ; G2.W51 258.99,147.83 v3(259.15,147.66) ; v3(258.69,116.27) 258.69,116.37 G2.W6 ; G2.B48 v3(271.19,146.37) ; G2.T45 260.75,144.3 v3(260.75,144.33) ; G2.T6 260.75,116.33 v3(260.75,116.31) ; v3(258.79,118.97) 258.48,118.97 G2.Y9 ; G2.G51 267.39,147.92 v3(267.58,147.72) ; v3(252.28,119.07) G2.AJ9 ; v3(271.49,112.72) 271.33,112.72 G2.B1 ; G2.H19 v3(266.98,126.07) ; G2.AL8 v3(250.88,118.37) ; G2.A51 v3(271.94,148.52) ; G2.J17 265.83,124.22 v3(265.83,123.87) ; G2.B2 v3(271.26,113.49) ; v3(272.14,113.32) G2.A2 ; G2.AE6 v3(255.12,117.02) ; v3(269.09,148.47) G2.E51 ; G2.W2 v3(258.99,114.47) ; G2.AK47 v3(250.99,145.07)
  BOTTOM w0.305: JDIMM1.210 186.82,77.77 v2(186.6,77.55) ; JWLAN1.75 v2(262.25,80.21) ; v2(152.43,157.84) 152.06,157.47 U1.BM38 ; v3(262.63,95.92) 262.23,96.32 U60.C14 262.23,96.32 v3(261.63,96.32) ; U48.N12 252.91,167.95 v3(252.51,168.35) ; JDIMM1.180 179.32,77.97 v2(179.74,77.55) 180.32,78.13 JDIMM1.184 ; U2024.G10 292.23,131.92 v3(292.23,131.92) U2024.F10 v3(291.43,131.92) ; U2025.P10 v3(289.83,118.69) U2025.R11 v3(289.03,119.49) U2025.R12 289.43,119.89 v3(289.83,120.29) ; JDIMM3.175 178.3,76.07 v2(178.09,76.28) ; v3(262.63,95.12) U60.E14 v3(261.63,94.72) ; U1.AB34 174.81,154.84 v2(175.14,154.52) 174.81,154.19 U1.AB33 ; v3(300.9,154.54) U2023.A12 300.5,154.94 v3(300.1,155.34) ; U2024.N12 v3(297.83,130.32) ; U2.D12 242.88,71.59 U2.D10 ; JDIMM1.172 177.32,78.32 v2(178.09,77.55) 178.32,77.78 JDIMM1.176 ; v3(264.76,143.11) 265.05,143.11 265.4,143.46 265.4,143.85 G2.K45 ; JDIMM1.39 142.07,88.54 142.27,88.74 v2(142.27,88.98) 142.72,88.98 143.07,88.63 JDIMM1.43 ; U48.U14 251.31,164.75 v3(250.91,164.35) ; v3(250.91,165.95) 251.31,166.35 U48.R14 v3(251.71,165.95) ; v3(300.23,129.52) U2024.U14 300.63,129.12 v3(301.03,128.72) ; U2024.H13 v3(293.03,129.52) U2024.H14 v3(293.03,128.72) ; JWLAN1.63 v2(265.25,80.21) ; PC428.2 213.86,113.72 v3(214.47,113.72) 214.47,112.6 214.73,112.35 PR3581.1 ; JDIMM3.227 191.3,75.78 v2(191.8,76.28) 192.3,75.78 JDIMM3.231 ; U55.T5 271.53,176.75 v3(271.93,177.15) ; v3(243.38,61.12) 243.38,60.7 U2.AG11 ; U1.AC38 174.03,157.44 v2(174.35,157.12) 174.03,156.79 U1.AC37 ; 260.8,90.5 261.62,90.5 v3(261.63,90.5) 261.85,90.72 U60.K14 U60.K13 263.03,90.72 v3(263.43,91.12) ; U48.M5 v3(258.91,169.15) U48.L5 ; v3(244.27,167.95) 244.27,167.95 U2022.E14 v3(243.27,167.55) ; v3(268.73,165.15) U55.A1 v3(267.93,164.35) ; v2(190.15,76.28) 190.3,76.13 JDIMM3.223 ; v3(263.43,87.92) 263.83,88.32 U60.N12 ; v3(300.1,149.74) 299.7,149.34 U2023.B5 v3(299.3,148.94) U2023.C4 ; U2022.C12 v3(241.67,165.95) ; v2(154.36,143.03) 154.1,142.78 U1.BJ18 ; U60.U14 v3(261.83,84.72) ; v2(183.29,77.55) 183.32,77.58 JDIMM1.196 ; U48.N3 260.11,167.95 v3(260.51,167.55) ; JDIMM1.202 184.82,77.68 v2(184.94,77.55) 185.58,77.55 185.82,77.79 JDIMM1.206 ; JDIMM1.10 134.82,78.1 v2(134.27,77.55) 133.82,78 JDIMM1.6 ; JWLAN1.45 v2(269.75,80.21) ; JDIMM3.189 181.8,75.87 v2(181.39,76.28) 180.8,75.69 JDIMM3.185 ; U2025.U3 287.82,112.68 v3(287.43,112.29) ; U48.T10 v3(254.11,165.15) ; U48.T5 v3(258.91,165.15) ; v3(299.43,128.72) 299.03,129.12 U2024.R14 ; v3(254.07,96.72) U2026.R14 v3(254.87,96.72) ; v2(107.26,43.01) 107.1,43.17 JSSD1.9 ; JDIMM3.39 142.3,76.25 v2(142.27,76.28) 141.89,76.28 141.3,75.69 JDIMM3.35 ; JSSD1.3 107.33,41.67 v2(107.39,41.61) 107.39,41.49 107.07,41.17 JSSD1.1 ; JDIMM3.103 158.3,75.82 v2(157.89,76.23) 157.3,75.64 JDIMM3.99 ; v3(261.31,165.15) U48.U1 261.71,164.75 v3(262.11,164.35) ; v2(142.27,77.55) 142.32,77.6 JDIMM1.40 ; v3(289.83,112.29) 289.43,112.68 U2025.R3 289.03,113.09 v3(289.03,113.09) 289.03,113.09 U2025.R4 ; U55.B10 v3(275.93,165.15) ; JDIMM1.26 138.82,78.03 138.35,77.56 v2(138.35,77.55) 138.34,77.55 137.82,78.07 JDIMM1.22 ; JDIMM1.68 149.32,77.74 149.51,77.55 v2(150.27,77.55) 150.32,77.6 JDIMM1.72 ; 177.43,154.52 U1.W34 ; 177.43,154.52 v2(177.5,154.52) ; 177.43,154.52 U1.W33 ; v2(152.18,76.91) 153.19,76.91 153.82,77.54 JDIMM1.86 ; JDIMM1.82 152.82,78.19 v2(152.18,77.55) 151.82,77.91 JDIMM1.78 ; U2025.K14 293.43,121.49 v3(293.03,121.89) ; Q53.4 47.22,45.3 v2(47.21,45.29) ; JDIMM1.52 145.32,77.3 145.7,76.91 v2(146.21,76.91) 146.59,76.91 146.84,77.17 146.84,77.8 146.32,78.33 JDIMM1.56 ; U55.C12 v3(276.73,165.95) U55.C11 276.33,166.35 v3(275.93,166.75) U55.D10 ; U2024.R12 v3(299.43,130.32) ; U2024.E3 v3(291.43,138.32) ; U60.G10 265.43,93.12 v3(265.03,93.52) 265.03,93.52 U60.F10 ; U55.E1 268.33,167.95 v3(267.93,167.55) ; v3(261.83,86.32) U60.R14 v3(262.63,86.32) ; U2025.E3 297.43,112.69 v3(297.82,113.09) ; JDIMM3.197 183.8,75.77 v2(183.29,76.28) 182.8,75.79 JDIMM3.193 ; U1.BK25 U1.BJ25 153.97,148.39 155.01,148.39 v2(155.08,148.46) ; U48.C3 259.71,176.35 v3(259.71,176.35) U48.C4 v3(258.91,176.35) U48.B5 v3(258.11,177.15) ; v2(83.03,93.04) 83.15,92.92 R2126.1 R2125.1 R2142.1 R2141.1 R2139.1 ; U1.F13 186.7,139 v2(187.02,138.68) ; JDIMM1.31 140.07,88.68 v2(140.37,88.98) ; JDIMM1.15 136.07,88.87 v2(136.18,88.98) 136.87,88.98 137.07,88.79 JDIMM1.19 ; 167.33,154.51 U1.AL34 ; 167.33,154.51 167.34,154.51 U1.AL33 ; 167.33,154.51 v2(167.26,154.51) ; v3(288.1,153.74) 288.5,153.34 U2023.T10 ; v2(190.65,152.81) 190.57,152.73 190.02,152.73 U1.A30 ; 260.83,92.48 261.62,92.48 v3(261.63,92.47) 261.78,92.32 U60.H14 v3(262.63,92.72) U60.H13 ; v2(157.89,77.5) 157.82,77.57 JDIMM1.102 ; v2(157.89,77.5) 157.18,77.5 156.82,77.86 JDIMM1.98 ; v2(157.89,77.5) 158.6,77.5 158.82,77.71 JDIMM1.106 ; U1.AR13 164.75,138.95 ; 164.75,138.95 v2(164.88,138.95) ; 164.75,138.95 U1.AR14 ; v3(289.83,130.32) U2024.C12 v3(289.03,131.12) U2024.C11 v3(289.83,131.92) U2024.D10 ; JDIMM3.213 187.8,75.96 188.12,76.28 v2(188.5,76.28) 188.8,75.98 JDIMM3.217 ; U60.C11 v3(265.03,95.92) 265.43,95.52 U60.D10 ; JDIMM3.235 193.3,75.87 v2(193.71,76.28) 194.3,75.69 JDIMM3.239 ; U1.U37 179.01,157.12 v2(179.07,157.12) 178.75,157.44 U1.U38 ; JDIMM1.9 134.57,88.68 v2(134.27,88.98) 133.76,88.98 133.57,88.79 JDIMM1.5 ; JDIMM1.252 197.32,77.88 v2(196.98,77.55) ; JDIMM3.23 138.3,76.23 v2(138.35,76.28) 137.7,76.28 137.3,75.88 JDIMM3.19 ; U2023.G5 295.7,149.41 v3(296.1,149.81) 296.5,149.41 U2023.F5 v3(296.9,148.94) ; JDIMM3.15 136.3,76.16 v2(136.18,76.28) ; U2025.T10 288.63,118.29 v3(288.23,118.69) ; v3(300.23,131.92) U2024.T10 ; U2024.T10 v3(300.23,132.72) ; U2024.T10 v3(299.43,131.92) U2024.R11 ; U55.A3 v3(269.53,164.35) ; JDIMM1.2 132.82,78.26 v2(132.11,77.55) ; PR3553.1 v2(296.13,200.58) ; JDIMM3.61 147.8,76.09 147.99,76.28 v2(148.38,76.28) 148.38,76.27 148.8,75.85 JDIMM3.65 ; JDIMM1.44 143.32,77.77 143.54,77.55 v2(144.18,77.55) 144.32,77.69 JDIMM1.48 ; U2023.T5 v3(288.1,148.94) ; U1.AJ38 U1.AJ37 169.16,156.79 v2(168.84,156.47) ; JDIMM3.57 146.8,76.07 146.59,76.28 v2(146.21,76.28) 145.7,76.28 145.3,75.88 JDIMM3.51 ; JDIMM1.18 136.82,78.19 v2(136.18,77.55) 135.82,77.91 JDIMM1.14 ; JDIMM3.243 195.3,76.22 v2(195.36,76.28) 195.99,76.28 196.3,75.97 JDIMM3.247 ; v3(287.43,121.89) 287.83,121.49 U2025.U14 ; JDIMM1.30 139.82,78.1 v2(140.37,77.55) 141,77.55 141.32,77.87 JDIMM1.36 ; JDIMM3.43 143.3,76.67 143.54,76.91 v2(144.18,76.91) 144.69,76.91 144.81,76.79 144.81,75.9 144.3,75.39 JDIMM3.47 ; v3(251.71,175.55) U48.C14 v3(250.91,175.55) ; U48.F5 v3(258.11,173.15) U48.G5 ; U2024.L10 v3(296.23,132.72) U2024.M10 v3(297.03,131.92) ; v3(290.63,120.29) U2025.N12 291.03,119.89 v3(291.43,120.29) ; v3(253.27,97.52) U2026.U12 v3(253.27,98.32) ; v2(134.27,76.91) 133.89,76.91 133.58,76.61 133.58,75.82 133.8,75.61 JDIMM3.5 ; U2022.H2 234.08,170.35 v3(234.48,170.75) ; v3(289.03,121.89) 289.03,121.88 U2025.R14 289.43,121.48 v3(289.03,121.09) ; v3(260.51,164.35) 260.11,164.75 U48.U3 ; JDIMM1.94 155.82,77.71 v2(155.61,77.5) 155.15,77.5 154.82,77.83 JDIMM1.90 ; v2(176.44,77.55) 176.44,78.18 176.32,78.3 JDIMM1.168 ; JDIMM1.1 132.57,88.52 v2(132.11,88.98) ; U2025.U1 v3(287.43,110.68) ; JDIMM1.244 195.32,77.59 v2(195.36,77.55) 195.99,77.55 196.32,77.88 JDIMM1.248 ; v3(290.63,129.52) U2024.E14 v3(290.63,128.72) ; JDIMM1.230 191.82,77.57 v2(191.8,77.55) ; v2(184.15,158.04) 184.19,158 U1.K38 ; v3(289.03,110.68) U2025.R1 289.43,111.09 v3(289.03,111.49) ; U48.M10 254.11,169.15 v3(254.11,169.15) 254.51,169.55 U48.L10 ; U2026.U14 v3(254.87,98.32) ; JDIMM1.23 138.07,88.71 v2(138.34,88.98) 138.91,88.98 139.07,88.82 JDIMM1.27 ; U48.N1 v3(262.11,167.55) ; v3(293.03,121.09) 293.03,121.09 ; v3(254.07,87.92) U2026.E14 v3(254.87,87.92) ; v3(262.26,170.2) 262.11,170.35 U48.K1 ; v3(297.7,148.14) 297.3,147.74 U2023.E3 v3(297.7,147.34) ; v2(107.26,53.93) 107,53.67 JSSD1.51 ; U48.P10 v3(254.11,166.75) 254.11,166.75 U48.R11 v3(253.31,165.95) U48.R12 v3(252.51,166.75) ; v3(291.3,153.74) U2023.M10 291.7,153.34 v3(292.1,153.74) 292.5,153.34 U2023.L10 ; v3(300.23,121.08) U2025.A14 v3(300.23,121.88) ; v3(252.51,164.35) 252.9,164.75 U48.U12 ; JDIMM3.181 179.8,76.22 v2(179.74,76.28) ; PU5.3 303.44,198.6 v2(303.11,198.93) ; JDIMM1.238 193.82,77.66 v2(193.71,77.55) 193.07,77.55 192.82,77.8 JDIMM1.234 ; U2026.M10 v3(251.67,94.32) ; v3(297.82,121.08) 297.43,121.48 U2025.E14 297.42,121.48 v3(297.02,121.08) ; v3(243.28,174.75) U2022.N14 v3(244.07,174.75) ; v2(107.26,51.9) 106.99,52.17 JSSD1.45 ; JDIMM1.226 190.82,77.84 190.53,77.55 v2(190.15,77.55) 189.82,77.88 JDIMM1.222 ; v3(234.48,176.35) U2022.R3 v3(235.27,176.35) U2022.R4 235.67,175.95 v3(236.07,176.35) U2022.T5 v3(236.87,177.15) ; v3(271.43,87.92) 271.03,88.32 U60.N3 v3(270.63,87.92) ; JDIMM3.31 140.3,76.21 v2(140.37,76.28) 139.73,76.28 139.3,75.85 JDIMM3.27 ; U2022.E1 v3(232.87,167.55) ; v3(263.43,95.12) 263.83,94.72 U60.E12 ; v3(262.11,165.95) 261.71,166.35 U48.R1 261.71,166.35 v3(261.31,166.75) ; C572.1 v2(47.97,41.99) ; v3(267.93,165.95) 268.33,166.35 U55.C1 v3(268.73,166.75) ; v2(186.6,76.28) 186.8,76.08 JDIMM3.209 ; JDIMM3.171 177.3,75.38 176.98,75.7 v2(176.44,75.7) 176.3,75.56 JDIMM3.167 ; JSSD1.57 v2(107.26,55.17) ; 256.01,86.95 255.5,86.95 v3(254.87,86.32) U2026.C14 v3(254.07,86.32) ; U1.L33 183.73,154.52 ; 183.73,154.52 v2(183.8,154.52) ; 183.73,154.52 U1.L34 ; v2(132.11,76.28) 132.8,75.59 JDIMM3.1 ; U2022.C4 v3(235.27,166.75) U2022.C3 v3(234.48,166.75) ; JWLAN1.57 v2(266.75,80.21) ; U55.F5 v3(271.13,169.15) U55.G5 ; JDIMM3.77 151.8,75.9 v2(152.18,76.28) 152.8,75.66 JDIMM3.81 ; U2022.R14 v3(244.07,176.35) ; v3(242.48,167.55) 242.07,167.95 U2022.E12 ; JSSD1.21 107.02,46.17 v2(107.26,45.93) ; JKB1.43 70.59,15.13 v2(70.87,14.86) 71.25,14.86 71.59,15.21 JKB1.41 ; v3(237,134.11) 236.94,134.17 G2.BL31 ; U55.B5 v3(271.13,165.15) ; U48.K13 v3(251.71,169.95) U48.K14 ; U2026.N12 v3(253.27,94.32) ; 154.78,76.28 154.8,76.26 JDIMM3.89 ; U2022.D10 v3(240.87,166.75) U2022.C11 ; JDIMM1.60 147.32,77.96 147.73,77.55 v2(148.38,77.55) 148.32,77.61 JDIMM1.64 ; v2(60.67,88.9) 60.67,89.44 R2027.2 ; U48.K2 v3(260.51,170.75) ; U2024.P10 v3(297.83,132.72) ; U1.F15 186.37,140.97 v2(186.37,141.04) ; JSSD1.27 107.09,47.67 v2(107.26,47.84) ; JDIMM3.107 159.3,75.91 159.62,76.23 v2(160.18,76.23) ; v3(291.3,155.34) U2023.N12 v3(290.5,155.34) ; U60.A12 v3(263.43,98.32) ; U2025.M10 291.83,118.29 v3(291.43,118.69) ; U2026.L10 v3(251.67,93.52) ; JDIMM1.214 187.82,77.72 187.99,77.55 v2(188.5,77.55) 188.82,77.87 JDIMM1.218 ; v2(196.98,76.28) 197.3,75.96 JDIMM3.251 ; JSSD1.15 107.01,44.67 v2(107.26,44.91) ; U1.Y37 176.39,156.79 v2(176.71,157.12) 176.39,157.44 U1.Y38 ; v3(290.63,121.89) 291.03,121.49 U2025.N14 ; JDIMM3.201 184.8,76.13 v2(184.94,76.28) 185.58,76.28 185.8,76.06 JDIMM3.205 ; G2.F46 267.81,144.94 v3(267.69,144.94) 267.69,145.06 G2.G47 ; v2(155.61,76.23) 155.8,76.04 JDIMM3.93 ; U55.C4 v3(271.13,166.75) ; v3(250.81,171.95) 251.31,171.95 U48.H14 U48.H13 252.11,171.95 v3(252.51,171.55) ; 217.09,109.81 217.09,108.92 ; v2(186.37,150.49) 186.37,150.56 U1.G28 ; v2(107.54,67.9) 107.18,67.54 JSSD2.9 ; v3(298.63,139.12) 298.63,139.12 U2024.R1 v3(299.43,139.92) ; U2024.B10 v3(288.23,131.92) ; U2024.U12 v3(301.03,130.32) ; JWLAN1.69 v2(263.75,80.21) ; v3(263.43,96.72) 263.83,96.32 U60.C12 ; JWLAN1.51 v2(268.25,80.21) ; U2026.U3 v3(245.27,98.32) ; U2024.E1 v3(290.63,139.92) ; v2(167.63,138.95) 167.95,139.28 U1.AL14 ; U2022.B10 v3(240.87,165.15) ; U2.R38 229.89,66.3 v3(230.35,66.75) ; U48.A12 v3(253.31,177.15) ; U2025.G5 295.83,114.41 v3(296.23,114.81) 296.63,114.41 U2025.F5 v3(297.03,113.88) ; v3(262.63,97.52) 262.23,97.92 U60.A14 v3(261.63,97.92) ; U2025.T5 v3(288.23,113.88) ; v3(270.33,166.75) U55.C3 v3(269.53,165.95) ; v3(275.93,168.35) U55.F10 275.53,168.75 v3(275.93,169.15) U55.G10 ; U2023.P10 289.7,153.74 v3(289.7,153.74) U2023.R11 288.9,154.54 v3(288.9,154.54) U2023.R12 v3(289.7,155.34) ; JWLAN1.77 v2(261.15,80.22) ; JSSD1.39 107.05,50.67 v2(107.26,50.88) ; JWLAN1.39 v2(271.25,80.21) ; U1.J18 U1.H18 ; JSSD1.33 107.07,49.17 v2(107.26,48.98) ; U2024.A14 v3(287.43,128.72) ; v3(294.5,155.34) U2023.H13 U2023.H14 294.9,156.54 v3(294.9,157.04) ; C699.2 v2(44.55,39.7) ; R2138.1 R2123.1 ; U55.E3 v3(269.53,168.35)
  BOTTOM w0.33: 152.82,197.93 152.56,198.19 PU1303.A2
  BOTTOM w0.356: PC1273.2 v2(127.35,145.37) ; v2(175.14,152.57) 175.15,152.57 U1.AA30 U1.AA29 175.53,151.4 v2(175.93,151.01) ; v2(170.81,150.98) U1.AG29 U1.AG30 170.82,152.19 v2(171.2,152.57) ; v2(49.75,94.95) 49.24,94.44 U2012.4 ; v1(29.69,46.69) 29.81,46.82 C239.1 ; R123.1 247.69,44.25 v2(247.49,44.45) ; PC3507.2 210.03,98.63 209.65,99.01 v2(209.65,99.27) 209.9,99.52 PR3440.1 ; v2(168.05,152.57) 168.43,152.19 U1.AK30 U1.AK29 v2(168.44,150.96) ; v3(250.81,171.95) 250.61,172.14 248.96,172.14 C2502.2 ; C2715.1 73.43,93.25 73.12,93.55 v2(72.87,93.55) ; PR2261.2 278.51,191.47 278.73,191.69 v2(278.73,192.1) ; C2217.2 v2(234.52,111.95) ; v2(172.78,152.57) 172.79,152.57 U1.AD30 U1.AD29 173.17,151.44 v2(173.61,151.01) ; v2(212.8,100.66) 211.83,101.63 PR3448.2 ; PC1542.2 v2(270.66,196.6) ; U2022.R12 242.08,175.95 v3(242.48,175.55) ; v2(286.1,70.31) 286.35,70.06 R473.1 ; D2004.2 v2(12.59,75.87) ; v1(35.66,68.88) 35.66,68.89 35.99,69.22 C2124.2 R2060.1 ; Y2.2 248.63,78.83 v2(248.89,78.57) ; C1395.2 v2(227.17,127.84) ; 302.1,129.87 301.47,129.87 v3(301.03,130.32) ; 263.18,83.65 263.18,84.46 v3(263.43,84.72) ; PC1082.2 v2(234.03,196.6) ; R374.2 200.63,197.95 v2(200.76,198.07) ; PC9.1 v2(306.79,196.26) ; PU1609.3 215.42,107.83 215.79,108.21 PC192.1 216.94,108.21 217.09,108.36 217.09,108.92 ; v2(233.14,111.33) 232.89,111.59 C2220.2 ; R486.1 92.68,54.69 v2(93.06,55.07) ; v3(244.32,166.35) 244.42,166.24 245.29,166.24 ; v3(297.82,120.28) 297.43,119.89 U2025.E12 ; PC1072.2 222.6,195.74 PC1074.1 223.23,195.66 v2(223.36,195.79) ; U1.BR38 149.91,158.07 v2(149.9,158.06) ; C2204.2 224.02,121.51 v2(223.87,121.36) ; PR1173.1 183.48,162.51 v2(183.99,162) ; v2(165.96,150.99) 165.96,151.41 U1.AN29 U1.AN30 166.07,152.19 v2(165.69,152.57) ; C1372.2 65.81,19 v2(66.39,19) ; v2(161.75,152.57) 161.37,152.19 U1.AW30 U1.AW29 160.83,151.01 v2(160.72,151.01) ; 249.91,164.09 250.65,164.09 v3(250.91,164.35) ; C623.1 v2(41.8,41.99) ; v2(10,140.67) 9.55,141.12 PU1.1 ; v3(242.47,177.95) 242.62,178.1 242.62,178.83 ; C2728.1 162.27,195.11 v2(162.27,195.81) ; 270.64,83.93 v3(271.43,84.72) ; 302.09,154.99 301.35,154.99 v3(300.9,154.54) ; U2021.4 v2(284.83,87.71) ; v2(187.09,197.76) 187.65,197.76 PC1328.1 ; PR3554.1 v2(298.8,204.54) ; v2(156.32,151.04) 156.63,151.35 U1.BE29 U1.BE30 156.68,152.19 v3(157.03,152.54) ; R2122.1 80.21,78.08 v2(80.49,77.8) ; R269.2 144.37,151.26 v2(144.37,151.46) ; v2(208.12,109.05) 208.12,109.02 207.89,108.79 ; PR3541.2 208.38,93.93 v2(208.76,93.55) 209.26,94.06 PC3518.2 ; C2444.2 v2(222.09,127.84) ; C2136.2 v2(31.43,81.98) ; PR34.2 v2(304.51,193.6) ; PR3590.1 v2(300.32,184.61) ; v2(287.62,72.6) 288.07,73.04 C603.2 ; PC3541.2 v2(123.03,131.82) ; C303.1 285.26,26.57 v2(285.46,26.37) ; PC801.2 v2(293.47,185.5) ; R924.2 R925.2 229.64,118.42 230.3,119.08 v3(231.62,119.08) ; PC3570.2 v2(209.9,97.49) ; U1.AT30 U1.AT29 v2(163.72,150.98) ; PC3556.1 v2(247.49,195.66) ; C1394.2 229.69,124.94 v2(229.46,125.17) 229.22,124.94 C2443.2 ; R1020.2 233.01,125.79 231.74,124.52 v3(231.74,122.76) ; v2(212.19,158.58) 212.19,159.04 211.96,159.26 PC720.2 ; v2(283.81,70.31) 283.69,70.18 R474.1 R464.2 ; PR503.1 260.37,48.47 v2(260.06,48.77) ; v3(297.82,118.69) 297.83,118.69 U2025.D10 ; R2065.1 v1(33.8,81.18) R2084.1 ; v2(86.33,78.18) 86,77.85 R2340.1 83.95,77.85 Q106.3 ; U1.BB29 U1.BB30 158.62,152.57 v2(158.6,152.57) ; U2022.A14 v3(244.32,164.75) ; v2(176.88,196.14) 177.16,196.42 PC1312.2 ; PC3505.2 214.22,93.91 214.42,93.7 v2(214.42,93.45) 213.81,93.45 213.33,93.93 PR3454.1 ; v3(289.03,128.72) U2024.C14 v3(289.03,129.52) ; 257.25,87.16 257.04,86.95 C2657.2 256.01,86.95 ; C676.2 v2(225.39,128.98) ; PC3510.2 211.3,93.81 v2(211.04,93.55) ; C1399.2 221.91,113.41 v2(221.84,113.49) 221.41,113.91 Y6.4 220.73,113.15 220.29,112.7 218.31,112.7 217.9,113.11 v2(217.9,113.24) 217.9,114.98 Y6.2 219.03,116.79 219.3,117.06 v2(219.3,117.2) 221.63,117.2 v2(221.66,117.17) 221.71,117.17 222.6,116.28 C1400.2 222.29,116.11 v2(221.84,115.65) ; v2(179.75,151.01) 180.26,151.52 U1.R29 U1.R30 180.27,152.19 v2(180.65,152.57) ; U2022.N12 v3(242.48,174.75) ; C1402.2 v2(280.77,88.47) ; PR3555.1 v2(309.72,198.8) ; C2126.1 14.45,75.95 v2(14.4,75.9) ; U2023.N1 v3(290.5,145.74) ; v2(13.3,143.84) 13.18,143.72 C541.1 ; v2(291.81,178.26) 291.87,178.31 PR1459.2 ; v2(44.93,68.91) 45.37,68.47 C251.2 46.26,68.47 v2(46.58,68.79) ; PR3446.2 214.34,103.66 v2(214.34,104.19) 214.42,104.27 PR3573.1 ; v2(208.12,114.89) 208.28,115.04 PR439.1 ; C1401.2 v2(281.78,88.47) ; PC3539.2 v2(123.86,139.01) ; U2024.K13 v3(294.63,130.32) ; v3(269.03,89.52) 269.43,89.92 U60.L5 v3(269.83,89.52) U60.M5 v3(269.03,88.72) ; C677.2 v2(226.16,128.98) ; C2117.2 32.82,68.49 R2064.1 ; PR724.2 219.81,166.96 v2(219.93,166.83) ; U2022.T10 v3(240.88,176.35) ; v2(290.93,185.5) 291.13,185.7 PR1420.2 ; PC3558.2 v2(246.27,196.6) ; C180.2 249.27,45.04 v2(249.52,44.78) ; U59.3 136.87,147.77 v2(136.62,147.53) 136.62,147.07 C248.1 ; v3(300.9,148.14) 301.74,148.14 ; 302.09,109.57 302.09,109.62 v3(301.03,110.69) ; U2024.E12 v3(290.63,130.32) ; C1407.2 v2(225.5,124.67)
  BOTTOM w0.381: U48.E14 v3(251.71,174.75) ; v2(211.6,186.9) 211.53,186.9 210.89,186.26 PC1647.2 ; C187.2 242.77,46.71 v2(242.79,46.69) 242.72,46.61 C208.1 ; v3(271.43,86.32) 271.03,86.72 U60.R3 v3(270.63,86.32) 270.63,86.32 U60.R4 270.23,86.72 v3(269.83,86.32) U60.T5 v3(269.03,85.52) ; C616.2 v2(95.3,71.84) ; U2025.A1 v3(301.03,110.69) ; U2025.A1 300.63,111.1 v3(301.02,111.49) 301.04,111.47 ; U2025.A1 300.63,111.08 v3(300.22,111.49) ; v3(297.7,155.34) U2023.E12 v3(296.9,155.34) ; v3(254.87,84.72) 254.83,84.68 C2655.2 ; v3(254.87,84.72) U2026.A14 ; v3(254.87,84.72) 254.97,84.62 255.85,84.62 ; U2.U8 v3(245,65.52) ; v3(232.88,177.95) U2022.U1 ; C622.1 50.29,37.57 v2(50.42,37.44) ; U2026.C3 v3(245.27,86.32) ; U55.R1 v3(268.73,176.35) ; U55.R1 v3(268.73,175.55) ; U55.R1 v3(267.93,176.35) ; v2(297.18,97.16) 297.23,97.21 PC3426.2 ; v2(282.8,38.56) C337.2 C336.2 C335.2 C334.2 ; R336.2 231.16,45.62 v2(230.98,45.8) ; v3(263.43,84.72) U60.U12 v3(263.43,85.52) ; v3(298.23,117.73) U2025.D10 298.23,118.29 v3(298.62,118.69) 298.63,118.69 U2025.C11 ; U2023.K1 293.3,145.74 v3(293.15,145.59) ; U2025.A12 300.63,119.89 v3(301.02,120.29) ; U2025.A12 300.62,119.88 v3(300.22,119.49) ; U2025.A12 v3(301.03,119.48) ; v3(289.03,139.92) U2024.C1 289.43,139.51 v3(289.03,139.11) ; U55.P10 v3(275.13,174.75) ; U2026.N3 v3(245.27,95.12) ; v3(297.83,110.69) U2025.E1 297.43,111.09 v3(297.82,111.49) ; U2024.J10 294.23,132.82 v3(294.18,132.87) ; v2(266.8,51.51) 266.74,51.51 266.64,51.62 PR507.2 PC511.2 ; v3(244.47,85.52) U2026.A1 ; U2026.A1 v3(243.67,84.72) ; U2026.A1 v3(244.47,84.72) ; v3(297.83,137.52) U2024.N3 v3(297.83,138.32) ; v2(162.27,195.81) 162.27,196.8 162.51,197.04 JCAM1.5 ; U2025.G10 296.38,117.73 v3(296.63,117.73) U2025.F10 296.63,118.29 v3(297.02,118.69) ; v3(230.22,178.26) 230.54,178.58 C2457.2 231.51,178.58 232.21,177.88 ; v3(274.98,171.1) 275.03,171.15 U55.J10 ; v3(240.88,173.95) U2022.M10 240.07,173.15 v3(240.07,173.15) U2022.L10 ; U2022.R1 v3(232.79,176.44) 232.62,176.27 231.94,176.27 231.73,176.05 C2464.2 ; v2(118.79,188.22) 118.89,188.32 PR1181.1 ; v2(274.29,25.48) 273.85,25.04 JTP1.4 ; U2023.N14 v3(290.5,156.94) ; v2(25.19,68.33) 25.01,68.51 R2071.1 ; U2026.L5 v3(246.87,93.52) U2026.M5 ; v3(300.1,152.91) 299.7,153.31 U2023.B10 299.3,153.74 v3(299.3,153.74) U2023.C11 ; v2(127.48,200.1) 127.4,200.18 PC1161.1 ; v2(217.15,169.89) 217.39,169.65 PC718.2 ; v3(242.48,177.15) 242.07,177.55 U2022.U12 v3(242.47,177.95) ; U2026.J10 250.77,91.52 v3(250.72,91.57) ; v3(243.67,87.92) 243.59,87.84 241.86,87.84 C2668.2 ; v3(250.91,169.95) 250.91,169.95 ; v3(262.26,172.05) 262.16,171.95 U48.H1 U48.H2 ; v3(273.03,98.32) 272.63,97.92 U60.A1 ; v2(218.46,59.64) 218.23,59.87 C178.1 ; v2(218.46,59.64) 218.23,59.41 C177.2 ; v2(218.46,59.64) 218.97,60.15 TP18.1 ; R56.2 42.72,38.61 v2(42.77,38.56) ; PC1648.1 208.83,184.66 v2(208.76,184.74) ; C71.2 v2(29.69,44.15) ; v3(269.53,176.35) 269.93,175.95 U55.R3 v3(270.33,176.35) 270.33,176.35 U55.R4 ; U2025.N1 v3(290.63,110.69) ; U2023.A1 v3(300.9,145.74) 301.97,144.67 301.97,144.62 ; U2022.J10 239.97,171.15 v3(239.92,171.1) ; v2(197.83,184.74) 197.91,184.66 PC1610.1 ; U55.K2 U55.K1 267.73,171.95 v3(267.68,172) ; C633.1 47.09,45.16 v2(47.21,45.29) ; U55.N14 v3(279.13,174.75) 279.49,175.11 280.81,175.11 C2527.2 ; v3(232.62,172) 232.67,171.95 U2022.K1 U2022.K2 ; v3(298.62,112.29) 299.02,112.68 U2025.C3 v3(299.43,112.29) ; U2025.C12 v3(299.43,119.48) 299.03,119.09 U2025.C11 ; U2023.C3 v3(299.3,147.34) ; PC1082.2 234.79,195.71 PC1081.1 v2(235.55,195.66) ; v2(306.04,59.52) 305.26,58.74 TP78.1 ; PH1105.2 149.75,176.43 v2(149.19,176.99) ; v3(235.27,174.75) U2022.N3 v3(234.48,174.75) ; 298.26,141.15 298.26,140.35 v3(297.83,139.92) U2024.N1 ; v3(298.5,155.34) U2023.C12 v3(299.3,154.54) U2023.C11 ; v2(126.21,136.55) 126.19,136.53 PC3532.2 126.12,135.65 PR3457.1 ; JFAN2.4 v2(94.23,98.22) ; v3(244.32,172.2) 244.07,171.95 U2022.K14 U2022.K13 v3(242.48,171.55) 242.48,171.55 ; U55.T10 v3(275.13,177.15) ; U55.T10 v3(275.93,176.35) U55.R11 ; U55.T10 v3(275.13,176.35) ; U55.T10 v3(275.93,177.15) ; C2508.2 281.01,166.51 279.48,166.51 v3(279.33,166.35) U55.C14 ; C310.2 v2(27.02,59.52) ; v2(107.13,39.83) 106.9,40.07 JSSD1.76 ; v2(96.44,71.84) 96.49,71.79 C580.1 ; v3(294.05,152.79) 294.1,152.84 U2023.J10 ; PC973.1 v2(271.44,195.94) ; C250.2 42.96,67.58 v2(42.77,67.39) ; v3(288.9,156.94) U2023.R14 v3(288.9,156.14) ; U2024.H1 293.43,139.77 v3(293.23,140.17) ; v3(252.47,87.93) 252.48,87.93 U2026.E12 ; U60.R11 v3(265.03,86.32) 265.43,85.92 U60.T10 ; 293.14,158.96 C910.2 293.14,157.17 v3(292.9,156.94) ; v3(301.02,113.09) 300.63,112.7 U2025.A3 ; U2024.U3 v3(301.03,138.32) ; U2024.A1 v3(287.43,139.92) ; R2052.2 42.82,88.47 42.01,88.47 v2(41.5,87.96) ; v2(162.15,182.71) 162.58,183.14 PC1512.1 ; U55.N12 v3(277.53,174.75) ; v3(275.93,173.95) U55.M10 v3(275.13,173.15) U55.L10 ; U2026.A3 v3(246.07,84.72) ; U2024.B5 v3(288.23,136.72) ; U2026.F5 v3(247.67,89.52) U2026.G5 ; v2(35.02,98.71) 35.86,99.55 D7.2 ; v3(262.11,176.35) U48.C1 261.71,175.95 v3(261.31,176.35) ; PR1202.1 137.13,154.99 137.66,155.53 v2(137.89,155.53) ; v3(273.28,90.67) 273.23,90.72 U60.K1 U60.K2 ; U2026.R1 v3(243.47,96.32) ; v3(295.13,110.53) 295.03,110.63 U2025.H1 U2025.H2 ; U2024.A12 v3(287.43,130.32) ; U2026.K2 v3(245.27,91.92) ; PR3461.2 126.3,132 v2(126.91,131.39) ; C247.2 26.97,55.15 v2(27.02,55.2) C244.2 ; U2026.P10 v3(251.67,95.92) U2026.R11 ; U2024.N14 v3(297.83,128.72) ; U2025.C11 v3(299.43,118.69) ; 260.94,87.92 260.69,87.67 C2627.2 ; v2(192.88,128.78) 192.07,127.97 R4.1 ; v3(293.7,147.34) 293.3,146.94 U2023.K2 ; v3(261.63,96.32) 260.75,96.32 260.75,96.32 ; Y2001.4 45.32,77.41 v1(44.93,77.8) ; C612.2 v2(93.95,39.3) ; U48.R4 v3(259.71,165.95) U48.R3 ; U60.G5 v3(269.83,93.52) U60.F5 ; D6.2 35.78,93.55 v2(35.02,92.79) ; v2(187.04,184.74) 187.12,184.66 PC1629.1 ; U2025.K1 293.43,110.68 v3(293.28,110.53) ; U2026.U1 v3(243.47,97.92) ; v2(168.37,162.64) 168.42,162.59 PR1163.1 ; U2023.M5 v3(292.1,148.94) U2023.L5 ; D37.1 v2(68.29,19) ; v2(276.57,181.05) 277.03,180.6 PR3529.1 ; U55.H1 267.93,170.35 v3(267.78,170.2) ; Y2.4 246.84,77.47 247.02,77.3 v3(247.24,77.3) ; v2(284.19,38.31) 284.52,38.64 C338.1 ; v2(149.32,199.47) 149.44,199.35 PC1323.2 ; v3(287.43,120.29) 287.83,119.89 U2025.U12 ; v2(118.08,191.27) 118.93,191.27 PC1156.1 ; v2(7.8,135.25) 7.67,135.25 7.16,135.77 C543.1 ; U48.J10 255.01,171.15 v3(255.06,171.1) ; JCAM1.4 v2(161.91,198.22) ; U2022.L5 v3(236.87,173.15) ; U60.N1 272.64,88.32 v3(273.03,87.93) 273.73,87.23 274.82,87.23 C2628.2 ; 295.25,128.4 v3(295.23,128.42) 295.03,128.62 U2024.K14 U2024.K13 ; v3(272.23,87.12) U60.R1 v3(273.03,86.32) ; v2(144.37,149.69) 144.37,149.05 145.05,148.36 R22.1 v2(144.37,147.91) ; PC433.2 v2(107.41,93.04) ; U2026.E3 v3(245.27,88.72) ; U2026.E3 v3(246.07,87.92) ; U2026.E3 v3(245.27,87.92) ; v2(40.86,67.26) 40.86,66.68 C270.1 ; PC1609.2 200.25,186.26 v2(200.37,186.13) ; R479.1 v2(93.06,55.07) ; v2(267.68,47.2) PR511.1 ; C2549.2 298.59,158.8 298.59,157.03 v3(298.5,156.94) U2023.C14 v3(299.3,156.14) ; PC101.2 v2(81.38,25.1) ; v3(244.27,170.2) 244.12,170.35 U2022.H14 v3(243.27,169.95) U2022.H13 ; v2(30.91,67.67) 31.21,67.97 R2079.2 ; v3(278.33,176.35) U55.R14 278.73,175.95 v3(279.13,176.35) ; v3(243.29,92.44) 243.41,92.32 U2026.K1 ; U55.A12 v3(277.53,164.35) ; 260.16,97.92 v3(261.63,97.92) ; v3(234.48,165.15) U2022.A3 v3(234.48,164.35) ; C2123.2 v2(13.56,75.9) ; C2123.2 C2126.1 ; C2123.2 13.53,76.74 D2004.2 ; v2(67.41,22.81) 68.28,22.81 D48.1 ; U2023.H2 U2023.H1 294.9,145.69 v3(295,145.59) ; 255.76,96.72 256.66,96.72 C2663.2 ; v3(233.67,165.95) U2022.C1 v3(232.87,165.95) ; U55.E14 v3(279.33,167.95) ; U50.5 U50.7 ; C506.1 v2(58.13,41.99) ; U2024.A3 v3(288.23,138.32) ; v3(254.91,177.15) U48.B10 v3(254.11,176.35) 253.71,175.95 U48.C11 ; v2(119.6,139.02) 120.09,139.51 PC3531.2 ; C579.1 v2(96.44,84.92) ; v3(245.27,95.92) U2026.R3 v3(246.07,96.72) U2026.R4 ; PC102.1 v2(81.38,24.21) ; R21.1 145.76,127.97 v2(145.26,128.48) ; U2.A4 246.66,73.55 v3(246.86,73.74) ; v3(233.67,173.95) U2022.N1 v3(232.87,174.75) 232.57,174.44 231.15,174.44 C2463.2 C2476.2 ; U2023.E1 v3(297.7,145.74) ; U2023.E14 v3(296.9,156.14) ; R63.1 252.14,61.97 v3(251.94,62.17) ; v3(295.08,140.22) 295.03,140.17 U2024.K1 U2024.K2 ; v3(253.27,91.12) U2026.H13 U2026.H14 v3(255.07,90.72) 255.78,90.72 255.9,90.6 ; v3(261.31,177.95) U48.A1 v3(262.11,177.95) ; v3(277.53,171.55) U55.K13 U55.K14 279.13,171.95 v3(279.38,172.2) 279.38,172.21 281.01,172.21 C2528.2 ; v2(159.1,199.85) 159.16,199.79 JCAM1.9 ; U3.4 v2(213.84,48.47) ; v3(299.43,138.32) U2024.R3 v3(299.43,137.52) U2024.R4 v3(299.43,136.72) U2024.T5 299.83,136.29 v3(300.23,135.89) ; v3(271.43,94.32) 271.03,94.72 U60.E3 ; U2023.U3 v3(287.3,147.34) ; U60.T10 v3(265.03,85.52) ; U60.T10 v3(265.83,85.52) ; R480.1 v2(93.44,49.99) ; U2022.G5 v3(236.07,169.15) U2022.F5 ; U2026.R12 v3(253.27,95.92) ; U2023.A14 v3(300.1,156.94) ; U2022.B5 v3(236.07,165.15) ; C246.1 v2(37.18,43.39) ; C613.2 94.39,84.47 v2(94.33,84.41) ; v3(300.22,114.69) 299.83,114.29 U2025.B5 299.43,113.89 v3(299.42,113.89) 299.03,113.49 U2025.C4 ; U48.A3 v3(259.71,177.95) ; v2(47.47,67.14) 48.15,67.14 C252.2 ; v3(293.82,112.29) 293.43,111.89 U2025.K2 ; U2025.J10 294.23,117.78 v3(294.18,117.73) ; C544.1 v2(5.81,135.08) ; PR1313.2 186.23,197.76 v2(187.09,197.76) ; v3(232.62,170.15) 232.82,170.35 U2022.H1 ; PC103.2 94,22.51 v2(93.57,22.94) ; U48.C11 v3(253.31,176.35) 253.31,176.35 U48.C12 ; U48.C11 254.11,175.55 v3(254.11,175.55) 254.51,175.15 U48.D10 ; U2025.B10 v3(300.23,117.88) 300.96,117.15 v2(301.14,117.15) ; U2022.R11 v3(240.88,176.35) ; R2038.2 v2(54.71,94.44) ; v3(294.9,157.04) 295.02,157.16 C2548.2 ; U55.R12 v3(277.53,175.55) ; v2(221.71,60.4) 221.84,60.28 R188.1 ; C577.1 v2(95.09,39.32) ; v2(40.2,65.48) C268.2 ; C238.2 C239.1 ; U2023.C11 v3(298.5,153.74) U2023.D10 v3(298.1,152.71) ; U2026.T10 v3(251.67,97.52) ; 300.96,139.99 v3(301.03,139.92) U2024.U1 ; U60.P10 v3(265.83,87.92) ; v3(251.71,177.15) U48.A14 v3(250.91,177.15) ; v3(288.9,146.54) U2023.R1 v3(288.9,145.74) ; C2048.2 46.15,78.06 46.53,77.68 46.7,77.68 v2(46.83,77.55) 46.83,76.41 45.79,75.37 v2(45.18,75.37) 45.16,75.39 44.93,75.39 44.27,76.04 Y2001.2 43.78,76.27 43.45,76.6 C2046.2 43.45,79 v2(43.91,79.45) ; v3(299.43,110.69) U2025.C1 299.03,111.1 v3(299.42,111.49) ; U2.U11 v3(243.48,65.52) ; C888.2 v2(211.84,199.92) ; v2(264.89,30.94) 265.4,30.43 C349.1 ; v2(26.13,50.24) C243.2 R261.1 ; v3(296.9,153.74) U2023.F10 296.5,153.16 v3(296.1,152.76) 295.7,153.16 U2023.G10 ; v3(265.98,91.57) 265.93,91.52 U60.J10 ; 257.02,92.43 R908.2 255.9,92.43 255.81,92.52 v3(255.12,92.52) 254.92,92.32 U2026.K14 v3(254.07,92.72) U2026.K13 ; U2.U10 v3(244.24,65.52) ; PC1317.1 149.44,197.19 v2(149.96,196.68) ; v3(271.43,98.32) U60.A3 271.03,97.92 v3(271.43,97.52) ; v3(268.73,177.95) U55.U1 v3(267.93,177.95) ; U2022.U14 v3(244.07,177.95) ; v3(244.32,166.35) U2022.C14 v3(243.27,165.95) ; U2024.H2 v3(293.83,138.32) ; U2022.E3 v3(234.48,168.35) ; 208.76,79.07 v2(208.76,78.82) ; U2024.G5 v3(292.23,136.72) U2024.F5 ; U48.D10 v3(255.06,175.15) ; U48.D10 v3(254.11,174.75) ; v3(247.85,73.71) 247.85,74.86 248.58,75.59 C207.2 248.58,76.99 v3(248.89,77.3) v2(248.89,78.57) ; U2.W8 v3(245,64.34) ; C576.1 95.55,46.64 v2(95.85,46.94) ; U2023.A3 v3(300.9,148.14) ; 255.76,95.12 257.23,95.12 257.75,95.64 C2662.2 ; U2023.R4 v3(288.9,148.14) U2023.R3 v3(289.7,147.34) ; U60.C4 v3(270.63,95.92) U60.C3 271.03,96.32 v3(271.43,95.92) ; v3(243.42,90.47) 243.67,90.72 U2026.H1 U2026.H2 ; U60.B5 v3(269.83,97.52) ; v3(273.03,96.72) 272.63,96.32 U60.C1 v3(272.23,96.72) ; U55.H2 v3(269.53,170.75) ; v3(287.3,156.94) U2023.U14 ; C505.2 v2(58.13,41.1) ; Y2.2 247.89,79.34 247.69,79.53 246.07,79.53 245.36,78.82 245.36,77.52 245.89,76.99 C206.2 v3(245.89,76) 244.57,74.68 244.57,74.14 244.51,74.08 244.52,74.08 v3(244.53,74.08) ; v2(148.91,153.41) 149.24,153.74 U1.BT32 ; U2023.C1 v3(299.3,145.74) 299.35,145.69 299.35,144.45 ; C575.1 v2(95.9,61.62) ; U55.U3 v3(269.53,177.95) ; C2509.2 280.97,164.42 279.65,164.42 v3(279.33,164.75) U55.A14 ; U2022.M5 v3(236.87,173.95) ; JDBUG1.7 24.75,6.49 v2(24.51,6.73) ; v2(118.84,195.02) 118.95,195.02 119.48,194.5 PC1159.1 ; U60.L10 v3(265.83,89.52) U60.M10 v3(265.03,88.72) ; v3(254.87,95.12) U2026.N14 ; U2022.P10 v3(240.07,174.75) ; C2122.2 C2125.2 15.16,81.44 v2(15.34,81.61) ; v3(289.83,138.32) U2024.C3 v3(289.83,137.52) U2024.C4 ; U2026.F10 v3(251.67,88.72) ; C542.2 v2(4.67,134.45) ; v3(261.83,87.92) U60.N14 ; C642.1 C641.2 279.19,24.82 v2(279.11,24.74) ; v2(31.97,23.32) 32.4,23.75 PD101.2 ; U60.B10 v3(265.03,97.52) ; C205.1 v2(245.41,46.69) ; U2022.U3 v3(234.48,177.95) ; U2025.N3 v3(290.63,112.29) ; v2(184.54,127.34) 184.88,127 R6.1 R5.1 ; R2348.1 v2(43,49.23) ; U2026.T5 v3(246.87,97.52) ; C611.2 93.07,46.88 v2(92.93,47.01) ; U2023.N3 v3(290.5,147.34) ; U60.U3 v3(271.43,84.72) ; v2(99.66,92.66) 99.28,93.04 C639.2 ; v3(270.33,174.75) U55.N3 v3(269.53,174.75) ; U2025.M5 v3(292.23,113.88) U2025.L5 ; U60.R12 v3(263.43,87.12) ; U48.E12 v3(252.51,174.75) ; U60.E1 v3(273.03,95.12) ; R485.1 v2(93.44,51.77) ; PC1532.1 v2(175.99,183.34) ; C406.1 v2(16.35,44.78) ; v3(277.53,177.95) U55.U12 ; C2117.2 32.1,68 v2(32.38,67.72) ; v2(108.3,0.91) SWPWR2.2 ; U55.E12 v3(277.53,167.55) ; U2022.A1 v3(232.87,164.35) ; U2023.U1 v3(287.3,145.74)
  BOTTOM w0.457: PC1319.2 153.4,197.72 v2(153.2,197.93) ; PC917.2 v2(267.05,205.69) ; PC909.2 v2(254.98,205.69)
  BOTTOM w0.508: PC416.2 273.98,58.78 v2(273.91,58.7) ; C2113.2 37.74,77.61 v1(37.43,77.3) ; C2720.2 v2(11.91,40.21) ; C637.2 288.99,76.58 v2(288.9,76.67) ; SWPWR2.4 103.66,0.91 v2(103.47,1.1) ; v2(302.22,142.21) 302.23,142.19 ; PC972.1 259.68,195.66 v2(260.06,195.28) ; R317.1 v2(293.5,24.13) ; v2(93.31,90.12) 92.68,90.76 JFAN2.5 ; JFAN2.6 92.68,100.66 94.2,99.14 v2(94.2,99.01) ; PC3538.2 118.46,125.8 v2(118.46,125.05) ; C604.2 v2(288.07,75.71) ; v2(268.48,22.73) 268.48,21.46 JTP1.8 269.49,21.38 v2(269.49,22.73) ; v2(96.49,55.96) 96.11,56.34 C574.1 ; PC1307.2 151.52,200.95 v2(151.55,200.98) ; 152.82,197.93 v2(153.2,197.93) ; JKB1.51 91.9,12.02 v2(91.69,11.81) ; C610.2 v2(94.96,55.96) ; v2(287.27,21.97) JPUMP1.2 v2(287.27,24.77) ; JRTC1.2 82.03,21.99 v2(82.22,21.8) ; v2(38.04,73.23) 38.07,73.23 38.32,73.49 C2119.2 ; PC907.2 v2(258.46,196.6) ; PC412.2 v2(119.55,90.17) ; JRTC1.3 v2(74.44,24.54) ; v2(280.77,77.17) 281.63,77.17 281.85,77.39 JWLAN1.76
  vias: v1(19.91,32.21) v1(26.38,73.74) v1(26.38,73.1) v1(26.64,76.53) v1(27.15,74.88) v1(31.25,53.08) v1(32.97,28.45) v1(33.12,95.46) v1(33.24,53.19) v1(33.24,52.3) v1(34.39,36.15) v1(35.27,74.93) v1(40.99,92.28) v1(41.62,92.28) v1(43.53,92.28) v1(45.69,79.07) v1(51.28,78.31) v1(51.91,90.26) v1(53.16,81.88) v1(53.82,82.48) v1(56.36,91.27) v1(60.42,22.81) v1(89.88,20.02) v1(100.81,4.02) v1(109.44,56.09) v1(118.71,37.67) v1(119.98,30.31) v1(120.75,96.35) v1(121.13,116.54) v1(128.75,188.93) v1(130.91,165.56) v1(130.96,142.95) v1(132.23,151.18) v1(136.37,136.99) v1(147.92,171.28) v1(153.26,183.47) v1(185.9,43.39) v1(189.45,193.25) v1(191.87,40.85) v1(199.99,42.5) v1(222.22,200.36) v1(234.16,200.23) v1(265.91,32.59) v1(267.3,83.26) v1(270.1,28.91) v1(280.64,53.55) v1(290.54,54.94) v1(302.74,126.95) v1(302.99,12.91) v1(304.01,122.76) v2(8.63,120.6) v2(10.89,43.26) v2(10.89,41.99) v2(14.7,19.89) v2(14.7,19) v2(15.08,146.26) v2(15.34,68.91) v2(15.72,33.48) v2(15.92,55.99) v2(16.61,136.22) v2(16.86,33.48) v2(16.86,32.46) v2(17.11,19.89) v2(17.11,19) v2(17.36,124.8) v2(17.88,135.46) v2(17.88,69.17) v2(18,19.89) v2(18,19) v2(18.38,61.55) v2(18.89,69.17) v2(19.45,80.04) v2(19.48,78.59) v2(19.91,133.68) v2(20.29,134.98) v2(20.29,126.22) v2(20.42,131.75) v2(20.42,129.87) v2(20.39,128.02) v2(20.59,133.63) v2(20.64,28.63) v2(20.64,27.28) v2(20.67,34.5) v2(20.67,33.61) v2(20.67,32.21) v2(20.77,132.9) v2(20.8,65.61) v2(20.8,64.98) v2(20.8,64.34) v2(20.8,62.18) v2(21.03,131.3) v2(21.3,130.25) v2(21.3,40.47) v2(21.56,34.37) v2(21.56,33.61) v2(21.81,129.24) v2(21.94,32.21) v2(21.97,31.19) v2(21.97,28.78) v2(22.32,128.22) v2(22.32,40.47) v2(22.32,39.45) v2(22.32,35.13) v2(22.32,34.37) v2(22.32,33.61) v2(22.7,127.21) v2(23.21,125.94) v2(23.59,35.11) v2(23.59,33.86) v2(23.59,32.85) v2(23.59,31.83) v2(23.84,124.67) v2(24.25,58.4) v2(24.25,57) v2(24.48,123.52) v2(24.48,68.15) v2(24.61,41.35) v2(24.73,1.6) v2(24.73,0.84) v2(24.86,35.13) v2(24.86,33.86) v2(25.11,122.38) v2(25.24,67.64) v2(25.88,121.24) v2(26,1.6) v2(26,0.84) v2(26.28,60.56) v2(26.28,59.16) v2(26.64,120.09) v2(27.17,67.59) v2(27.27,40.47) v2(27.27,39.58) v2(27.27,38.56) v2(27.27,36.02) v2(27.27,35) v2(27.27,33.86) v2(27.4,118.82) v2(27.91,67.62) v2(28.16,117.81) v2(28.16,1.6) v2(28.16,0.84) v2(28.8,116.79) v2(29.43,1.6) v2(29.43,0.84) v2(29.69,115.78) v2(30.7,114.51) v2(30.86,14.1) v2(31.59,1.6) v2(31.59,0.84) v2(31.85,113.24) v2(31.85,61.67) v2(31.88,14.1) v2(32.73,102.44) v2(32.73,100.41) v2(32.73,98.76) v2(32.73,97.11) v2(32.73,96.09) v2(32.73,94.19) v2(32.73,92.92) v2(32.89,14.1) v2(32.86,1.6) v2(32.86,0.84) v2(33.36,112.09) v2(33.75,102.44) v2(34.04,17.91) v2(34.04,17.02) v2(34.04,16.13) v2(34.64,110.93) v2(34.8,17.91) v2(34.8,17.02) v2(34.8,16.13) v2(35.02,100.57) v2(35.02,94.57) v2(35.5,82.12) v2(35.56,17.91) v2(35.56,17.02) v2(35.56,16.13) v2(35.78,109.93) v2(36.14,82.12) v2(36.32,17.91) v2(36.32,17.02) v2(36.32,16.13) v2(37.05,108.99) v2(37.08,17.91) v2(37.08,17.02) v2(37.85,17.91) v2(37.85,17.02) v2(38.07,108.16) v2(38.61,17.91) v2(38.61,17.02) v2(39.21,107.47) v2(39.37,17.02) v2(39.8,85.02) v2(39.8,83.86) v2(40.13,17.02) v2(40.74,63.83) v2(40.89,17.02) v2(41.95,61.34) v2(42.64,65.92) v2(42.64,64.21) v2(42.77,86.69) v2(42.77,85.42) v2(42.92,83.11) v2(42.89,81.92) v2(43.28,59.77) v2(44.04,14.56) v2(44.04,13.54) v2(45.05,14.56) v2(45.05,13.54) v2(45.69,63.96) v2(45.69,62.69) v2(45.69,61.42) v2(46.2,71.2) v2(46.23,12.19) v2(46.32,72.98) v2(46.83,74.76) v2(46.86,22.48) v2(46.86,21.59) v2(46.96,63.96) v2(46.96,62.69) v2(47.75,23.37) v2(47.75,22.48) v2(47.75,21.59) v2(48.23,63.96) v2(48.23,62.69) v2(48.23,61.42) v2(48.74,77.55) v2(49.12,75.9) v2(49.5,102.44) v2(49.53,22.35) v2(49.53,21.59) v2(50.29,75.9) v2(50.49,23.37) v2(50.49,22.48) v2(50.49,21.59) v2(51.02,71.07) v2(51.43,23.37) v2(51.43,22.48) v2(51.43,21.59) v2(51.66,75.52) v2(51.66,53.34) v2(51.66,51.02) v2(52.32,23.37) v2(52.32,22.48) v2(52.32,21.59) v2(52.42,71.07) v2(53.21,23.37) v2(53.21,22.48) v2(53.21,21.59) v2(53.31,75.52) v2(53.92,77.42) v2(54.1,23.37) v2(54.1,22.48) v2(54.1,21.59) v2(54.58,101.04) v2(55.24,60.96) v2(55.72,77.42) v2(55.72,24.59) v2(55.98,100.79) v2(56.23,99.65) v2(56.36,77.42) v2(58.11,77.45) v2(58.31,73.23) v2(59.48,73.23) v2(59.91,11.89) v2(59.91,11) v2(61.94,88.47) v2(63.72,44.02) v2(64.1,63.45) v2(64.1,61.93) v2(64.1,60.53) v2(64.1,44.66) v2(64.23,38.71) v2(64.23,37.8) v2(64.23,22.94) v2(64.23,21.92) v2(64.36,91.39) v2(64.43,89.87) v2(64.48,88.22) v2(64.48,86.95) v2(64.48,44.02) v2(64.48,11.03) v2(64.99,38.69) v2(64.99,37.8) v2(65.25,44.02) v2(65.25,22.94) v2(65.25,21.92) v2(65.25,11.03) v2(65.25,10.27) v2(65.63,60.53) v2(65.63,44.66) v2(66.01,44.02) v2(66.39,18.11) v2(66.39,17.22) v2(67.02,63.45) v2(67.02,60.53) v2(67.41,19) v2(67.41,18.11) v2(67.41,17.22) v2(67.66,91.39) v2(67.66,89.87) v2(67.66,88.6) v2(67.66,87.33) v2(68.17,45.29) v2(68.29,18.11) v2(68.68,92.92) v2(68.68,91.39) v2(68.68,89.87) v2(68.68,88.6) v2(68.68,87.33) v2(69.31,75.01) v2(70.2,75.64) v2(70.33,45.29) v2(70.93,52.4) v2(71.72,79.58) v2(72.36,45.16) v2(73.37,91.65) v2(73.37,54.54) v2(73.37,45.16) v2(73.5,90.12) v2(73.5,89.49) v2(73.5,88.34) v2(73.88,72.09) v2(74.14,54.54) v2(74.26,63.83) v2(74.26,45.16) v2(74.39,25.23) v2(74.68,17.97) v2(74.77,83.54) v2(74.9,54.54) v2(75.28,73.49) v2(75.28,72.09) v2(75.28,57.1) v2(75.53,99.14) v2(75.79,82.38) v2(75.91,96.98) v2(75.91,17.99) v2(75.86,17.07) v2(76.04,87.33) v2(76.04,83.77) v2(75.99,52.43) v2(75.99,50.6) v2(77.01,90.76) v2(77.98,16.64) v2(78.33,51.51) v2(78.74,16.64) v2(78.91,90.76) v2(79.09,52.02) v2(79.47,100.41) v2(79.47,66.63) v2(79.47,65.23) v2(80.56,50.57) v2(81.38,86.57) v2(81.38,85.3) v2(81.38,83.01) v2(81.5,63.73) v2(81.5,57.99) v2(81.5,56.59) v2(81.63,65.23) v2(81.88,49.69) v2(82.01,101.68) v2(82.14,85.3) v2(82.14,84.15) v2(82.14,83.01) v2(82.14,73.74) v2(82.14,71.83) v2(82.14,70.06) v2(82.9,57.99) v2(83.41,68.71) v2(83.53,102.31) v2(83.53,65.87) v2(83.53,64.6) v2(83.66,49.86) v2(84.3,10.49) v2(84.3,8.72) v2(84.8,102.82) v2(85.19,9.6) v2(85.57,49.86) v2(85.82,86.69) v2(85.82,85.3) v2(85.82,83.65) v2(86.07,103.58) v2(86.14,75.96) v2(86.14,75.07) v2(86.07,10.49) v2(86.07,8.72) v2(86.96,104.09) v2(86.96,49.86) v2(87.34,88.47) v2(87.34,86.57) v2(87.34,85.3) v2(87.34,83.52) v2(88.23,104.85) v2(89.12,105.36) v2(90.27,106.12) v2(90.9,19) v2(90.9,17.78) v2(91.28,106.89) v2(92.3,107.52) v2(92.5,17.78) v2(92.5,16.89) v2(92.5,15.95) v2(92.51,15.21) v2(93.31,108.41) v2(93.95,62.91) v2(94.92,78.82) v2(95.3,63.33) v2(95.68,78.82) v2(96.44,78.82) v2(96.49,63.33) v2(96.77,99.77) v2(96.77,98.89) v2(98.93,13.59) v2(98.93,12.83) v2(98.93,12.06) v2(98.93,11.3) v2(98.93,10.54) v2(98.93,9.78) v2(99.69,13.59) v2(99.69,12.83) v2(99.69,12.06) v2(99.69,11.3) v2(99.69,10.54) v2(99.69,9.78) v2(100.46,12.06) v2(100.46,11.3) v2(100.46,10.54) v2(100.46,9.78) v2(100.81,29.42) v2(100.81,28.65) v2(101.57,29.42) v2(101.57,28.65) v2(101.82,5.92) v2(101.82,5.16) v2(102.46,82.76) v2(102.46,82.12) v2(102.71,6.68) v2(102.71,5.92) v2(102.71,5.16) v2(102.87,59.49) v2(103.09,29.42) v2(103.09,28.65) v2(103.6,121.11) v2(103.63,59.49) v2(103.6,58.75) v2(103.83,48.72) v2(103.83,47.45) v2(103.85,29.42) v2(103.85,28.65) v2(104.11,122.25) v2(104.08,50.76) v2(104.08,49.99) v2(104.49,66.5) v2(104.62,75.11) v2(104.62,72.09) v2(104.59,70.54) v2(104.74,123.14) v2(104.72,46.01) v2(104.72,44.79) v2(105.38,124.16) v2(105.38,29.42) v2(105.38,28.65) v2(105.76,125.05) v2(106.01,125.94) v2(106.14,29.42) v2(106.14,28.65) v2(106.15,5.3) v2(106.52,126.95) v2(106.9,127.97) v2(107,64.44) v2(107.28,129.11) v2(107.54,29.42) v2(107.54,28.65) v2(107.79,130.76) v2(108.17,132.16) v2(108.3,29.42) v2(108.3,28.65) v2(108.55,133.43) v2(108.76,5.24) v2(109.06,135.08) v2(109.32,136.99) v2(109.57,138.38) v2(109.7,29.42) v2(109.7,28.65) v2(109.82,170.51) v2(109.82,169.5) v2(109.82,168.23) v2(109.82,166.96) v2(109.82,165.69) v2(109.82,164.42) v2(109.82,163.15) v2(109.82,161.88) v2(109.82,160.61) v2(109.82,159.34) v2(109.82,158.07) v2(109.82,156.67) v2(109.82,155.27) v2(109.82,153.88) v2(109.82,152.61) v2(109.82,151.34) v2(109.8,150.07) v2(109.82,148.29) v2(109.82,146.76) v2(109.82,145.62) v2(109.82,143.72) v2(109.85,141.18) v2(109.82,139.91) v2(109.87,142.45) v2(109.95,201.12) v2(109.95,199.85) v2(109.95,198.58) v2(109.95,197.31) v2(109.95,196.04) v2(109.95,194.77) v2(109.95,193.5) v2(109.95,192.23) v2(109.95,190.96) v2(109.95,189.69) v2(109.95,188.42) v2(109.95,187.15) v2(109.95,185.88) v2(109.95,184.61) v2(109.95,90) v2(109.95,88.98) v2(110.08,183.47) v2(110.08,58.88) v2(110.05,51.26) v2(110.2,205.57) v2(110.46,29.42) v2(110.46,28.65) v2(110.74,53.17) v2(110.74,51.9) v2(110.74,50.63) v2(110.74,49.48) v2(110.69,47.58) v2(110.69,46.18) v2(110.84,171.4) v2(110.84,170.51) v2(110.84,169.5) v2(110.84,44.91) v2(110.96,64.24) v2(111.09,85.3) v2(111.09,84.53) v2(111.09,83.77) v2(111.09,83.01) v2(111.09,82.25) v2(111.09,81.49) v2(111.32,79.44) v2(111.47,205.64) v2(111.86,85.3) v2(111.86,84.53) v2(111.86,83.77) v2(111.86,83.01) v2(111.86,82.25) v2(111.86,81.49) v2(111.95,79.44) v2(111.98,75.01) v2(112.09,64.47) v2(112.62,85.3) v2(112.62,84.53) v2(112.62,83.77) v2(112.62,83.01) v2(112.59,79.44) v2(112.62,75.01) v2(113,205.64) v2(113.35,79.44) v2(113.35,75.01) v2(113.4,64.47) v2(113.76,95.96) v2(114.14,205.64) v2(114.4,24.84) v2(114.4,23.57) v2(114.4,22.3) v2(114.4,21.03) v2(114.4,19.76) v2(114.4,18.49) v2(114.4,17.22) v2(114.4,15.95) v2(114.4,14.68) v2(114.4,13.41) v2(114.4,12.14) v2(114.4,10.87) v2(114.4,9.6) v2(114.4,8.33) v2(114.4,7.06) v2(114.4,5.79) v2(114.48,26.31) v2(115.03,95.96) v2(115.03,27.41) v2(115.05,64.47) v2(115.41,205.64) v2(115.67,52.53) v2(115.79,71.2) v2(116.17,95.96) v2(116.33,50.88) v2(116.55,205.64) v2(116.68,59.77) v2(116.81,54.31) v2(116.94,98.63) v2(116.94,97.36) v2(116.94,27.54) v2(117.32,59.77) v2(117.44,94.69) v2(117.7,205.64) v2(117.95,98.63) v2(117.95,97.36) v2(118.08,59.77) v2(118.46,117.94) v2(118.46,94.69) v2(118.46,54.31) v2(118.59,133.3) v2(118.59,132.54) v2(118.59,131.78) v2(118.84,27.54) v2(118.97,205.64) v2(119.22,117.94) v2(119.35,133.3) v2(119.35,132.54) v2(119.35,131.78) v2(119.6,94.69) v2(120.11,133.05) v2(120.11,132.16) v2(120.24,117.94) v2(120.36,205.64) v2(120.75,27.54) v2(121,117.94) v2(120.95,54.43) v2(121.25,94.69) v2(121.51,205.64) v2(122.02,117.94) v2(122.78,205.64) v2(122.78,117.94) v2(122.84,36.27) v2(122.84,35.64) v2(122.84,34.62) v2(122.84,33.73) v2(122.84,32.85) v2(122.84,31.45) v2(122.84,30.18) v2(122.84,28.91) v2(122.76,27.61) v2(122.9,94.69) v2(123.54,140.92) v2(123.74,117.93) v2(123.79,54.56) v2(124.17,205.64) v2(124.3,193.63) v2(124.3,192.36) v2(124.3,191.09) v2(124.3,189.69) v2(124.5,117.93) v2(125.06,142.19) v2(125.06,141.3) v2(125.32,205.64) v2(125.57,54.56) v2(125.7,117.94) v2(126.21,193.63) v2(126.21,192.36) v2(126.21,191.09) v2(126.21,189.69) v2(126.33,117.94) v2(126.59,205.64) v2(126.71,142.7) v2(126.71,141.81) v2(126.71,140.92) v2(126.84,143.59) v2(127.1,37.46) v2(127.48,140.41) v2(127.6,143.59) v2(127.98,193.63) v2(127.98,192.36) v2(127.98,191.09) v2(127.98,189.69) v2(128.34,58.5) v2(128.37,57.23) v2(128.75,37.46) v2(128.8,153.72) v2(128.8,152.96) v2(128.8,152.2) v2(129.41,92.15) v2(130.02,37.46) v2(130.98,153.72) v2(130.98,152.96) v2(130.98,152.2) v2(130.97,82.12) v2(131.17,68.91) v2(131.3,72.72) v2(131.29,37.46) v2(132.11,92.54) v2(132.18,202.72) v2(132.25,153.72) v2(132.25,152.96) v2(132.25,152.2) v2(132.3,138.64) v2(132.3,137.87) v2(132.58,160.61) v2(132.56,159.85) v2(132.56,37.46) v2(133.06,138.64) v2(133.06,137.87) v2(133.45,202.72) v2(133.37,160.68) v2(133.52,153.72) v2(133.52,152.96) v2(133.52,152.2) v2(133.7,201.12) v2(133.7,199.85) v2(133.83,198.71) v2(133.83,138.64) v2(133.83,137.87) v2(133.83,37.46) v2(134.21,197.44) v2(134.27,92.79) v2(134.27,85.17) v2(134.27,83.26) v2(134.27,81.99) v2(134.47,71.96) v2(134.47,70.06) v2(134.47,68.79) v2(134.59,138.64) v2(134.59,137.87) v2(134.72,196.42) v2(135.1,37.46) v2(135.22,60.66) v2(135.35,138.64) v2(135.35,137.87) v2(135.6,195.53) v2(136.11,138.64) v2(136.11,137.87) v2(136.18,92.79) v2(136.18,84.53) v2(136.18,83.26) v2(136.18,81.99) v2(136.37,72.6) v2(136.37,71.33) v2(136.37,70.06) v2(136.37,68.79) v2(136.37,37.46) v2(136.49,194.77) v2(136.49,60.66) v2(136.87,138.64) v2(136.87,137.87) v2(137.64,138.64) v2(137.64,137.87) v2(137.64,37.46) v2(137.89,194.26) v2(138.34,92.79) v2(138.34,84.53) v2(138.34,83.26) v2(138.34,81.99) v2(138.27,60.66) v2(138.4,138.64) v2(138.4,137.87) v2(138.54,72.6) v2(138.54,71.33) v2(138.54,70.06) v2(138.54,68.79) v2(138.91,37.46) v2(139.16,149.81) v2(139.54,60.66) v2(139.92,149.81) v2(140.18,37.46) v2(140.37,92.79) v2(140.37,83.26) v2(140.37,81.99) v2(140.57,72.6) v2(140.57,70.06) v2(140.68,149.81) v2(141.07,194.24) v2(141.32,60.66) v2(141.45,149.81) v2(141.45,37.46) v2(142.27,92.79) v2(142.27,85.8) v2(142.27,84.53) v2(142.27,83.26) v2(142.27,81.99) v2(142.48,72.6) v2(142.48,71.33) v2(142.48,70.06) v2(142.48,68.79) v2(142.59,60.66) v2(142.72,170.13) v2(142.72,169.5) v2(142.72,37.46) v2(143.2,195.02) v2(143.48,170.13) v2(143.48,169.5) v2(143.86,195.91) v2(143.99,37.46) v2(144.18,92.79) v2(144.18,83.9) v2(144.18,81.99) v2(144.38,71.96) v2(144.38,70.69) v2(144.38,68.79) v2(144.37,60.66) v2(144.75,197.31) v2(144.88,193.75) v2(144.88,193.12) v2(144.88,170.39) v2(144.88,169.62) v2(145.26,199.34) v2(145.26,37.46) v2(145.38,202.64) v2(145.38,200.99) v2(145.64,170.39) v2(145.64,169.62) v2(145.64,138.08) v2(145.64,60.66) v2(145.74,131.4) v2(146.21,92.79) v2(146.21,84.92) v2(146.21,84.28) v2(146.21,81.74) v2(146.4,202.64) v2(146.4,71.45) v2(146.4,69.55) v2(146.53,37.46) v2(146.78,170.39) v2(146.78,169.62) v2(147.09,132.75) v2(147.21,131.55) v2(147.16,130.38) v2(147.42,194.77) v2(147.42,193.88) v2(147.42,193.12) v2(147.42,170.39) v2(147.42,169.62) v2(147.42,60.66) v2(147.67,202.64) v2(147.8,37.46) v2(148.25,127.09) v2(148.37,92.79) v2(148.37,85.55) v2(148.37,84.28) v2(148.37,83.01) v2(148.57,72.34) v2(148.57,71.07) v2(148.57,69.17) v2(148.71,170.39) v2(148.71,169.62) v2(148.69,60.66) v2(149.07,37.46) v2(149.35,170.39) v2(149.35,169.62) v2(149.6,128.44) v2(150.33,126.04) v2(150.27,92.79) v2(150.27,84.92) v2(150.27,83.01) v2(150.34,37.46) v2(150.48,71.71) v2(150.48,69.8) v2(150.46,60.66) v2(150.78,155.95) v2(150.95,129.78) v2(151.35,168.23) v2(151.35,167.34) v2(151.61,171.78) v2(151.61,37.46) v2(151.68,127.39) v2(151.73,60.66) v2(151.86,175.34) v2(151.86,174.07) v2(151.99,169.88) v2(152.11,168.23) v2(152.11,167.34) v2(152.24,142.38) v2(152.24,139.24) v2(152.18,92.79) v2(152.18,84.92) v2(152.18,83.65) v2(152.18,82.38) v2(152.38,71.71) v2(152.38,70.44) v2(152.38,69.17) v2(152.88,37.46) v2(153.03,128.74) v2(153.26,167.34) v2(153.51,60.66) v2(154.02,167.34) v2(154.01,126.97) v2(154.41,142.27) v2(154.4,37.46) v2(154.46,145.37) v2(154.46,144.53) v2(154.65,193.63) v2(154.72,70.94) v2(154.72,69.01) v2(154.78,60.66) v2(154.91,167.34) v2(155.29,187.15) v2(155.26,144.86) v2(155.26,143.64) v2(155.42,194.77) v2(155.42,193.63) v2(155.36,128.32) v2(155.45,150.96) v2(155.6,126.87) v2(155.61,92.79) v2(155.61,84.86) v2(155.61,83.59) v2(155.61,82.32) v2(155.67,167.34) v2(155.67,37.46) v2(156.05,187.91) v2(156.05,187.18) v2(156.18,194.77) v2(156.18,193.63) v2(156.37,71.66) v2(156.37,70.39) v2(156.37,69.12) v2(156.56,200.49) v2(156.56,167.34) v2(156.56,60.66) v2(156.81,187.91) v2(156.86,187.23) v2(156.94,37.46) v2(156.97,186.26) v2(157.15,151.04) v2(157.42,185.7) v2(157.45,167.34) v2(157.58,187.96) v2(157.6,187.18) v2(157.7,200.49) v2(157.83,186.29) v2(157.82,154.51) v2(157.82,153.22) v2(157.84,151.01) v2(157.75,124.14) v2(157.77,92.79) v2(157.83,60.66) v2(157.89,82.32) v2(158.21,185.73) v2(158.21,37.46) v2(158.34,193.25) v2(158.59,188.19) v2(158.59,187.2) v2(158.62,186.26) v2(158.72,125.05) v2(158.66,70.86) v2(158.66,68.96) v2(159.23,193.25) v2(159.39,157.12) v2(159.48,37.46) v2(159.61,60.66) v2(159.75,188.14) v2(159.75,187.12) v2(159.75,186.11) v2(160.12,193.25) v2(160.18,92.79) v2(160.18,84.23) v2(160.18,82.32) v2(160.51,188.14) v2(160.51,187.12) v2(160.51,186.11) v2(160.75,37.46) v2(160.94,70.64) v2(160.94,69.37) v2(160.88,60.66) v2(160.96,157.12) v2(161.13,193.25) v2(161.28,188.14) v2(161.28,187.12) v2(161.28,186.11) v2(161.39,53.42) v2(161.89,193.25) v2(162.04,188.14) v2(162.04,187.12) v2(162.04,186.11) v2(162.02,37.46) v2(162.36,128.37) v2(162.63,193.22) v2(162.72,92.79) v2(162.72,84.23) v2(162.72,82.96) v2(162.72,81.69) v2(162.72,71.02) v2(162.72,69.12) v2(162.66,60.66) v2(162.66,55.96) v2(162.8,188.14) v2(162.8,187.12) v2(162.91,53.42) v2(163.04,175.59) v2(162.99,124.72) v2(162.99,122.82) v2(163.29,171.78) v2(163.29,170.01) v2(163.29,37.46) v2(163.56,188.14) v2(163.56,187.12) v2(163.56,186.11) v2(163.67,193.22) v2(163.93,175.59) v2(163.93,174.45) v2(163.93,173.56) v2(163.93,60.66) v2(164.22,125.47) v2(164.18,55.96) v2(164.32,188.14) v2(164.32,187.12) v2(164.32,186.11) v2(164.26,127.45) v2(164.43,53.42) v2(164.5,71.66) v2(164.5,70.39) v2(164.5,68.48) v2(164.56,37.46) v2(164.75,92.79) v2(164.75,84.86) v2(164.75,82.96) v2(165.11,53.42) v2(165.2,55.96) v2(165.32,200.1) v2(165.65,70.51) v2(165.65,68.61) v2(165.7,60.66) v2(165.79,53.42) v2(165.83,37.46) v2(166.47,55.96) v2(166.47,53.42) v2(166.66,92.79) v2(166.66,84.99) v2(166.66,81.82) v2(166.85,187.15) v2(166.85,186.13) v2(166.76,128.36) v2(166.76,126.46) v2(166.76,124.55) v2(166.76,122.65) v2(166.97,60.66) v2(167.1,37.46) v2(167.48,189.06) v2(167.48,188.17) v2(167.61,187.15) v2(167.61,186.13) v2(167.8,72.16) v2(167.8,70.26) v2(167.99,191.47) v2(168.12,189.06) v2(168.37,37.46) v2(168.5,188.17) v2(168.5,187.15) v2(168.5,186.13) v2(168.56,92.79) v2(168.56,85.37) v2(168.56,83.47) v2(169.13,193.25) v2(169.27,129) v2(169.26,127.09) v2(169.4,188.14) v2(169.4,187.12) v2(169.4,186.11) v2(169.36,125.2) v2(169.36,123.35) v2(169.45,71.33) v2(169.45,69.42) v2(169.64,37.46) v2(170.02,193.25) v2(170.55,188.14) v2(170.55,187.12) v2(170.55,186.11) v2(170.59,92.79) v2(170.59,84.53) v2(170.59,82.63) v2(170.91,193.25) v2(170.91,37.46) v2(171.1,71.96) v2(171.1,70.69) v2(171.1,68.79) v2(171.31,188.14) v2(171.31,187.12) v2(171.31,186.11) v2(171.28,139.59) v2(171.59,150.94) v2(171.8,195.41) v2(171.79,127.09) v2(171.79,125.19) v2(171.79,123.2) v2(171.8,60.66) v2(171.93,193.25) v2(172.07,188.14) v2(172.07,187.12) v2(172.07,186.11) v2(172.18,37.46) v2(172.43,195.41) v2(172.5,92.79) v2(172.5,84.53) v2(172.5,82.63) v2(172.69,193.25) v2(172.83,188.14) v2(172.83,187.12) v2(172.83,186.11) v2(173.07,195.41) v2(173.07,60.66) v2(173.23,71.33) v2(173.23,69.42) v2(173.45,37.46) v2(173.59,188.14) v2(173.59,187.12) v2(174.09,198.45) v2(174.3,128.36) v2(174.36,188.14) v2(174.36,187.12) v2(174.36,186.11) v2(174.4,84.53) v2(174.4,82.63) v2(174.72,37.46) v2(174.85,60.66) v2(175.12,188.14) v2(175.12,187.12) v2(175.12,186.11) v2(175.1,176.1) v2(175.13,69.42) v2(175.2,126.83) v2(175.99,176.1) v2(175.99,175.34) v2(175.99,174.45) v2(175.99,173.43) v2(175.99,37.46) v2(176.1,125.3) v2(176.12,60.66) v2(176.44,92.79) v2(176.44,84.41) v2(176.44,83.14) v2(176.82,128.17) v2(177.26,37.46) v2(177.72,187.07) v2(177.69,186.01) v2(177.9,60.66) v2(178.09,92.79) v2(178.09,82.71) v2(178.09,70.95) v2(178.17,126.82) v2(178.53,191.6) v2(178.53,190.83) v2(178.51,189.08) v2(178.51,188.12) v2(178.51,187.1) v2(178.48,186.06) v2(178.53,37.46) v2(178.91,185.58) v2(179.29,188.12) v2(179.29,187.1) v2(179.29,186.08) v2(179.72,185.58) v2(179.72,125.33) v2(179.74,92.79) v2(179.74,84.66) v2(179.74,82.76) v2(179.74,71.33) v2(179.74,69.42) v2(179.67,60.66) v2(179.8,37.46) v2(179.93,193.25) v2(180.18,188.14) v2(180.18,187.13) v2(180.18,186.11) v2(180.23,128.51) v2(180.82,197.44) v2(180.94,60.66) v2(181.07,59.13) v2(181.07,37.46) v2(181.34,188.14) v2(181.34,187.12) v2(181.34,186.11) v2(181.39,92.79) v2(181.39,84.26) v2(181.39,83.01) v2(181.39,70.95) v2(181.39,69.68) v2(181.57,127.15) v2(181.71,193.25) v2(181.83,197.44) v2(181.83,195.66) v2(182.1,188.14) v2(182.1,187.12) v2(182.1,186.11) v2(182.21,60.66) v2(182.34,37.46) v2(182.72,193.25) v2(182.87,188.14) v2(182.87,187.12) v2(182.87,186.11) v2(182.93,125.81) v2(183.19,128.69) v2(183.29,92.79) v2(183.29,84.28) v2(183.29,83.01) v2(183.29,70.95) v2(183.29,69.68) v2(183.48,193.25) v2(183.63,188.14) v2(183.63,187.12) v2(183.63,186.11) v2(183.61,37.46) v2(183.99,60.66) v2(184.39,188.14) v2(184.39,187.12) v2(184.94,92.79) v2(184.94,84.53) v2(184.94,82.63) v2(184.94,71.2) v2(184.94,69.29) v2(184.88,37.46) v2(185.15,188.14) v2(185.15,187.12) v2(185.15,186.11) v2(185.26,60.66) v2(185.72,128.69) v2(185.91,188.14) v2(185.91,187.12) v2(185.91,186.11) v2(186.15,37.46) v2(186.6,92.79) v2(186.6,84.28) v2(186.6,83.01) v2(186.6,70.95) v2(186.6,69.68) v2(186.79,175.34) v2(186.79,174.07) v2(186.79,172.8) v2(186.79,171.53) v2(186.79,170.26) v2(187.04,140.25) v2(187.04,60.66) v2(187.17,194.77) v2(187.42,37.46) v2(187.88,186.24) v2(188.31,60.66) v2(188.5,92.79) v2(188.5,84.28) v2(188.5,83.01) v2(188.5,70.95) v2(188.5,69.68) v2(188.69,37.46) v2(188.77,189) v2(188.79,188.24) v2(188.79,187.23) v2(188.79,186.21) v2(189.12,185.63) v2(189.4,189) v2(189.45,191.47) v2(189.45,190.71) v2(189.48,188.24) v2(189.48,187.23) v2(189.48,186.21) v2(189.86,185.63) v2(189.96,37.46) v2(190.14,188.14) v2(190.09,60.66) v2(190.16,187.23) v2(190.16,186.21) v2(190.15,92.79) v2(190.15,84.53) v2(190.15,82.63) v2(190.15,76.91) v2(190.15,71.33) v2(190.15,69.42) v2(190.42,193.25) v2(190.6,185.6) v2(190.72,157.56) v2(191,188.22) v2(191,187.2) v2(191,186.19) v2(191.23,37.46) v2(191.36,60.66) v2(191.74,193.25) v2(191.8,92.79) v2(191.8,84.28) v2(191.8,83.01) v2(191.8,76.91) v2(191.8,70.95) v2(191.8,69.68) v2(191.89,153.52) v2(192.14,188.14) v2(192.14,187.12) v2(192.14,186.11) v2(192.37,193.25) v2(192.5,37.46) v2(192.63,134.36) v2(192.63,132.54) v2(192.9,188.14) v2(192.9,187.12) v2(192.9,186.11) v2(193.39,196.29) v2(193.66,188.14) v2(193.66,187.12) v2(193.66,186.11) v2(193.71,92.79) v2(193.71,84.28) v2(193.71,83.01) v2(193.71,70.95) v2(193.71,69.68) v2(193.77,193.25) v2(193.77,37.46) v2(194.02,196.29) v2(194.41,193.25) v2(194.42,188.14) v2(194.42,187.12) v2(194.42,186.11) v2(194.66,196.29) v2(194.79,134.45) v2(194.79,132.54) v2(195.04,37.46) v2(195.18,188.14) v2(195.18,187.12) v2(195.29,196.29) v2(195.29,60.66) v2(195.36,84.28) v2(195.36,82.38) v2(195.36,76.91) v2(195.36,70.95) v2(195.36,69.04) v2(195.95,188.14) v2(195.95,187.12) v2(195.95,186.11) v2(196.31,37.46) v2(196.71,188.14) v2(196.71,187.12) v2(196.71,186.11) v2(197.58,37.46) v2(197.83,185.5) v2(197.83,98.25) v2(198.85,37.46) v2(198.98,175.34) v2(198.98,174.58) v2(198.98,173.69) v2(199,170.77) v2(199,169.75) v2(199,168.86) v2(199.49,152) v2(199.99,165.18) v2(199.99,164.54) v2(199.99,163.91) v2(199.99,163.27) v2(200.12,37.46) v2(200.37,98.25) v2(201.11,187.38) v2(201.39,37.46) v2(201.95,187.4) v2(201.92,97.36) v2(201.97,188.17) v2(202.28,114) v2(202.28,112.47) v2(202.66,37.46) v2(202.91,194.64) v2(202.91,193.25) v2(203.06,188.14) v2(203.06,187.12) v2(203.06,186.11) v2(203.68,193.25) v2(203.82,188.14) v2(203.82,187.12) v2(203.82,186.11) v2(203.93,37.46) v2(204.44,193.25) v2(204.58,188.14) v2(204.58,187.12) v2(204.58,186.11) v2(204.69,195.28) v2(204.69,194.64) v2(205.2,37.46) v2(205.34,188.14) v2(205.34,187.12) v2(205.34,186.11) v2(205.33,158.07) v2(206.11,188.14) v2(206.11,187.12) v2(206.22,158.07) v2(206.87,188.14) v2(206.87,187.12) v2(206.87,186.11) v2(207.63,188.14) v2(207.63,187.12) v2(207.63,186.11) v2(207.87,158.83) v2(207.87,158.07) v2(208.12,108.16) v2(208.71,81.36) v2(208.76,185.5) v2(208.76,82.38) v2(208.76,77.55) v2(208.76,76.28) v2(208.76,75.01) v2(208.76,72.47) v2(208.76,71.2) v2(208.76,69.93) v2(208.76,68.66) v2(209.39,126.06) v2(209.65,174.83) v2(209.65,174.2) v2(209.65,173.56) v2(209.77,171.15) v2(209.77,170.51) v2(209.8,169.75) v2(209.8,168.86) v2(210.03,126.06) v2(210.66,153.37) v2(210.66,126.06) v2(211.3,126.06) v2(211.42,204.93) v2(211.42,201.5) v2(212.06,204.93) v2(212.06,201.5) v2(212.31,205.69) v2(212.29,181.44) v2(212.31,180.42) v2(212.29,179.78) v2(212.29,179.15) v2(212.29,178.51) v2(212.29,177.88) v2(212.29,177.24) v2(212.29,176.61) v2(212.69,204.93) v2(212.69,201.5) v2(212.82,120.73) v2(212.95,205.69) v2(213.07,199.85) v2(213.07,198.96) v2(213.46,198.2) v2(213.58,99.14) v2(213.58,97.87) v2(213.71,205.69) v2(213.84,199.85) v2(213.84,198.96) v2(214.09,120.73) v2(214.22,198.2) v2(214.22,98.5) v2(214.34,37.46) v2(214.47,205.69) v2(214.6,199.85) v2(214.6,198.96) v2(214.85,99.14) v2(214.85,97.87) v2(214.98,198.2) v2(215.23,205.69) v2(215.36,120.73) v2(215.61,37.46) v2(215.92,199.72) v2(215.92,198.83) v2(215.92,197.95) v2(216,205.69) v2(216.5,120.73) v2(216.68,199.72) v2(216.68,198.83) v2(216.68,197.95) v2(216.76,205.69) v2(216.88,37.46) v2(217.14,124.92) v2(217.44,199.72) v2(217.44,198.83) v2(217.44,197.95) v2(217.52,205.69) v2(217.77,124.92) v2(218.21,199.72) v2(218.21,198.83) v2(218.21,197.95) v2(218.15,37.46) v2(218.41,205.69) v2(218.41,124.92) v2(218.92,132.62) v2(218.97,199.72) v2(218.97,198.83) v2(219.04,124.92) v2(219.3,205.69) v2(219.42,37.46) v2(219.55,151.59) v2(219.55,150.96) v2(219.55,132.62) v2(219.68,124.92) v2(219.78,199.72) v2(219.78,198.83) v2(219.78,197.95) v2(219.96,94.11) v2(219.96,93.34) v2(219.96,92.58) v2(220.06,205.69) v2(220.19,132.62) v2(220.31,124.92) v2(220.49,199.72) v2(220.49,198.83) v2(220.49,197.95) v2(220.57,109.93) v2(220.69,157.69) v2(220.69,156.92) v2(220.69,156.16) v2(220.69,155.4) v2(220.73,94.11) v2(220.73,93.34) v2(220.73,92.58) v2(220.69,37.46) v2(220.82,205.69) v2(221.33,157.69) v2(221.33,156.92) v2(221.33,156.16) v2(221.33,155.4) v2(221.49,94.11) v2(221.49,93.34) v2(221.49,92.58) v2(221.58,205.69) v2(221.84,109.91) v2(221.96,37.46) v2(222.25,94.11) v2(222.25,93.34) v2(222.25,92.58) v2(222.35,205.69) v2(222.6,109.91) v2(223.01,93.34) v2(223.01,92.58) v2(223.11,205.69) v2(223.23,204.93) v2(223.23,37.46) v2(223.36,109.91) v2(223.62,182.58) v2(223.62,181.82) v2(223.62,181.05) v2(223.62,180.29) v2(223.62,179.53) v2(223.62,178.77) v2(223.62,178.01) v2(223.62,177.24) v2(223.62,176.48) v2(223.77,93.34) v2(223.77,92.58) v2(223.87,205.69) v2(223.87,204.93) v2(224.38,182.58) v2(224.38,181.82) v2(224.38,181.05) v2(224.38,180.29) v2(224.38,179.53) v2(224.38,178.77) v2(224.38,178.01) v2(224.38,177.24) v2(224.38,176.48) v2(224.44,84.6) v2(224.5,204.93) v2(224.5,109.81) v2(224.5,109.05) v2(224.54,93.34) v2(224.54,92.58) v2(224.5,37.46) v2(224.89,49.61) v2(224.89,48.34) v2(225.14,205.69) v2(225.14,204.93) v2(225.14,202.39) v2(225.14,201.76) v2(225.3,93.34) v2(225.3,92.58) v2(225.65,199.85) v2(225.65,198.96) v2(225.77,198.07) v2(225.77,37.46) v2(225.9,205.69) v2(226.06,92.58) v2(226.06,91.82) v2(226.41,199.85) v2(226.41,198.96) v2(226.54,198.07) v2(226.66,205.69) v2(226.69,84.61) v2(226.82,92.58) v2(226.82,91.82) v2(227.04,37.46) v2(227.17,199.85) v2(227.17,198.96) v2(227.17,198.07) v2(227.43,205.69) v2(227.58,92.58) v2(227.58,91.82) v2(228.11,199.72) v2(228.11,198.83) v2(228.11,197.95) v2(228.19,205.69) v2(228.35,94.87) v2(228.35,94.11) v2(228.35,93.34) v2(228.35,92.58) v2(228.35,91.82) v2(228.31,37.46) v2(228.87,199.72) v2(228.87,198.83) v2(228.87,197.95) v2(228.95,205.69) v2(229.11,94.87) v2(229.11,94.11) v2(229.11,93.34) v2(229.11,92.58) v2(229.11,91.82) v2(229.64,199.72) v2(229.64,198.83) v2(229.64,197.95) v2(229.58,37.46) v2(229.71,205.69) v2(229.87,94.87) v2(229.87,94.11) v2(229.87,93.34) v2(229.87,92.58) v2(229.87,91.82) v2(230.4,199.72) v2(230.4,198.83) v2(230.4,197.95) v2(230.47,205.69) v2(230.63,94.87) v2(230.63,94.11) v2(230.63,93.34) v2(230.63,92.58) v2(230.63,91.82) v2(230.85,37.46) v2(231.16,199.72) v2(231.16,198.83) v2(231.36,205.69) v2(231.39,94.11) v2(231.39,93.34) v2(231.39,92.58) v2(231.97,199.72) v2(231.97,198.83) v2(231.97,197.95) v2(232.12,205.69) v2(232.12,37.46) v2(232.16,94.11) v2(232.16,93.34) v2(232.16,92.58) v2(232.68,199.72) v2(232.68,198.83) v2(232.68,197.95) v2(232.89,205.69) v2(232.92,94.11) v2(232.92,93.34) v2(232.92,92.58) v2(232.91,77.12) v2(232.94,75.57) v2(233.01,74.2) v2(233.14,110.57) v2(233.39,37.46) v2(233.65,205.69) v2(233.68,94.11) v2(233.68,93.34) v2(233.68,92.58) v2(234.21,78.13) v2(234.23,75.64) v2(234.41,205.69) v2(234.44,94.11) v2(234.44,93.34) v2(234.44,92.58) v2(234.66,37.46) v2(235.05,110.57) v2(235.17,205.69) v2(235.2,93.34) v2(235.2,92.58) v2(235.55,204.93) v2(235.68,182.45) v2(235.68,181.82) v2(235.68,181.18) v2(235.68,180.42) v2(235.68,179.78) v2(235.68,179.15) v2(235.68,160.61) v2(235.68,78.13) v2(235.9,159.84) v2(235.93,37.46) v2(235.97,93.34) v2(235.97,92.58) v2(236.19,204.93) v2(236.32,205.69) v2(236.44,182.45) v2(236.44,181.82) v2(236.44,181.18) v2(236.44,180.42) v2(236.44,179.78) v2(236.44,179.15) v2(236.73,94.11) v2(236.73,93.34) v2(236.73,92.58) v2(236.73,91.82) v2(236.82,204.93) v2(236.95,110.57) v2(237.17,159.84) v2(237.2,37.46) v2(237.33,202.26) v2(237.33,201.63) v2(237.46,205.69) v2(237.46,204.93) v2(237.49,94.11) v2(237.49,93.34) v2(237.49,92.58) v2(237.49,91.82) v2(237.46,89.15) v2(237.46,88.01) v2(237.71,199.85) v2(237.71,198.96) v2(237.97,198.07) v2(238.22,205.69) v2(238.45,76.91) v2(238.47,199.85) v2(238.47,198.96) v2(238.47,37.46) v2(238.73,198.07) v2(238.98,205.69) v2(239.24,199.85) v2(239.24,198.96) v2(239.36,198.07) v2(239.36,92.54) v2(239.36,91.9) v2(239.36,89.15) v2(239.36,88.01) v2(239.49,75.64) v2(239.74,205.69) v2(239.77,37.46) v2(240.3,199.72) v2(240.3,198.83) v2(240.3,197.95) v2(240.25,178.9) v2(240.51,205.69) v2(241.04,37.46) v2(241.07,199.72) v2(241.07,198.83) v2(241.07,197.95) v2(241.27,205.69) v2(241.83,199.72) v2(241.83,198.83) v2(241.83,197.95) v2(242.03,205.69) v2(242.28,104.35) v2(242.28,103.71) v2(242.31,37.46) v2(242.54,79.07) v2(242.59,199.72) v2(242.59,198.83) v2(242.59,197.95) v2(242.79,205.69) v2(243.05,76) v2(243.3,77.8) v2(243.35,199.72) v2(243.35,198.83) v2(243.58,37.46) v2(243.68,205.69) v2(244.16,199.72) v2(244.16,198.83) v2(244.16,197.95) v2(244.44,205.69) v2(244.56,76.06) v2(244.82,79.07) v2(244.85,37.46) v2(244.88,199.72) v2(244.88,198.83) v2(244.88,197.95) v2(245.21,205.69) v2(245.97,205.69) v2(246.12,37.46) v2(246.73,205.69) v2(247.36,204.93) v2(247.39,37.46) v2(247.49,205.69) v2(248,204.93) v2(248.38,205.69) v2(248.39,182.45) v2(248.38,180.17) v2(248.39,179.4) v2(248.63,204.93) v2(248.66,37.46) v2(248.76,180.67) v2(249.16,182.45) v2(249.16,180.17) v2(249.16,179.4) v2(249.16,178.64) v2(249.27,204.93) v2(249.27,202.39) v2(249.27,201.76) v2(249.52,205.69) v2(249.78,199.85) v2(249.78,198.96) v2(249.79,64.33) v2(249.9,84.53) v2(249.93,37.46) v2(250.29,205.69) v2(250.29,198.07) v2(250.54,199.85) v2(250.54,198.96) v2(250.86,84.47) v2(250.92,67.52) v2(251.05,205.69) v2(251.05,198.07) v2(251.2,37.46) v2(251.3,199.85) v2(251.3,198.96) v2(251.81,205.69) v2(252.44,37.46) v2(252.5,199.72) v2(252.5,198.83) v2(252.5,197.95) v2(252.57,205.69) v2(253.33,205.69) v2(253.26,199.72) v2(253.26,198.83) v2(253.26,197.95) v2(253.71,37.46) v2(254.02,199.72) v2(254.02,198.83) v2(254.02,197.95) v2(254.1,205.69) v2(254.1,178.64) v2(254.1,177.9) v2(254.1,73.87) v2(254.1,71.96) v2(254.6,68.91) v2(254.78,199.72) v2(254.78,198.83) v2(254.78,197.95) v2(254.98,37.46) v2(255.11,77.17) v2(255.11,62.31) v2(255.54,199.72) v2(255.54,198.83) v2(255.62,73.87) v2(255.62,71.96) v2(256,205.69) v2(256.13,62.31) v2(256.25,37.46) v2(256.36,199.72) v2(256.36,198.83) v2(256.36,197.95) v2(256.76,205.69) v2(256.76,68.91) v2(257.07,199.72) v2(257.07,198.83) v2(257.07,197.95) v2(257.27,73.87) v2(257.27,71.96) v2(257.4,77.17) v2(257.52,205.69) v2(257.52,37.46) v2(258.29,205.69) v2(258.29,83.77) v2(258.54,49.99) v2(258.54,49.36) v2(258.64,50.63) v2(259.05,205.69) v2(259.18,49.99) v2(259.18,49.36) v2(259.28,50.63) v2(259.81,204.93) v2(259.81,49.99) v2(259.81,49.36) v2(259.94,205.69) v2(259.91,50.63) v2(260.22,61.93) v2(260.22,61.14) v2(260.22,60.4) v2(260.22,59.49) v2(260.45,204.93) v2(260.57,67.9) v2(261.08,204.93) v2(261.21,205.69) v2(261.59,44.91) v2(261.72,204.93) v2(261.72,202.39) v2(261.72,201.76) v2(261.97,205.69) v2(262.05,181.69) v2(262.05,180.93) v2(262.05,180.29) v2(262.05,179.4) v2(262.05,178.64) v2(262.1,199.72) v2(262.1,198.83) v2(262.22,67.9) v2(262.48,197.95) v2(262.48,44.91) v2(262.73,205.69) v2(262.81,181.69) v2(262.81,180.93) v2(262.81,180.29) v2(262.81,179.4) v2(262.81,178.64) v2(262.86,199.72) v2(262.86,198.83) v2(263.24,44.91) v2(263.37,197.95) v2(263.49,205.69) v2(263.62,199.72) v2(263.62,198.83) v2(264,27.51) v2(264,26.62) v2(264.26,205.69) v2(264.51,178.64) v2(264.64,177.12) v2(264.64,174.58) v2(264.69,199.72) v2(264.69,198.83) v2(264.69,197.95) v2(264.89,173.31) v2(264.89,172.6) v2(265.02,205.69) v2(265.27,174.61) v2(265.27,171.02) v2(265.45,199.72) v2(265.45,198.83) v2(265.45,197.95) v2(265.78,205.69) v2(265.83,62.34) v2(265.83,61.67) v2(265.81,60.05) v2(265.83,58.96) v2(265.91,63.43) v2(265.88,57.94) v2(265.88,57.03) v2(266.1,172.24) v2(266.21,199.72) v2(266.21,198.83) v2(266.21,197.95) v2(266.92,63.43) v2(266.97,199.72) v2(266.97,198.83) v2(266.97,197.95) v2(267.08,33.4) v2(267.74,199.72) v2(267.74,198.83) v2(268.55,199.72) v2(268.55,198.83) v2(268.55,197.95) v2(268.55,69.42) v2(269.18,69.42) v2(269.26,199.72) v2(269.26,198.83) v2(269.26,197.95) v2(269.46,74.12) v2(269.72,60.1) v2(269.82,69.42) v2(270.43,60.13) v2(270.45,69.42) v2(271.11,35.51) v2(271.11,34.24) v2(271.11,32.97) v2(271.11,31.7) v2(271.11,30.43) v2(271.11,29.16) v2(271.11,27.89) v2(271.88,62.82) v2(271.88,62.06) v2(272.38,77.04) v2(272.38,76.15) v2(272.38,37.54) v2(272.38,36.53) v2(272.38,35.51) v2(272.38,34.24) v2(272.38,32.97) v2(272.38,31.7) v2(272.38,30.43) v2(272.38,29.16) v2(272.38,27.89) v2(272.36,18.41) v2(272.76,62.82) v2(272.76,62.06) v2(272.92,10.54) v2(272.92,9.53) v2(273.65,62.82) v2(273.65,62.06) v2(273.65,35.51) v2(273.65,34.24) v2(273.65,32.97) v2(273.65,31.7) v2(273.65,30.43) v2(273.65,29.16) v2(273.65,27.89) v2(273.94,9.53) v2(274.29,70.69) v2(274.9,62.41) v2(274.92,29.16) v2(274.95,9.53) v2(275.05,179.53) v2(275.05,178.77) v2(275.05,177.88) v2(275.05,90.76) v2(275.08,90.04) v2(275.05,21.67) v2(275.05,20.4) v2(275.56,83.65) v2(275.56,74.76) v2(275.56,74.12) v2(275.81,182.58) v2(275.81,181.05) v2(275.81,180.17) v2(275.81,179.53) v2(275.81,178.77) v2(275.91,62.39) v2(275.97,9.53) v2(276.22,75.04) v2(276.57,182.58) v2(276.57,180.17) v2(276.57,179.53) v2(276.57,178.77) v2(276.57,63.71) v2(276.83,107.85) v2(276.85,106.96) v2(276.99,10.54) v2(276.99,9.53) v2(277.21,67.01) v2(277.21,64.6) v2(277.26,105.85) v2(277.27,104.95) v2(278.48,88.85) v2(278.48,88.09) v2(278.48,87.33) v2(278.48,86.69) v2(278.53,85.02) v2(278.53,84.38) v2(278.53,83.62) v2(278.53,82.99) v2(278.61,67.26) v2(279.11,34.62) v2(279.53,22.61) v2(280.67,22.61) v2(281.27,175.59) v2(281.53,65.48) v2(281.53,63.96) v2(281.81,22.35) v2(282.29,64.72) v2(282.29,52.53) v2(282.29,51.26) v2(282.29,49.99) v2(282.29,48.72) v2(282.29,47.45) v2(282.83,159.29) v2(283.01,158.13) v2(283.05,65.48) v2(283.05,63.96) v2(283.08,22.35) v2(283.56,52.53) v2(283.56,51.26) v2(283.56,49.99) v2(283.56,48.72) v2(283.56,47.45) v2(284.23,14.48) v2(284.23,13.46) v2(284.23,12.45) v2(284.63,11.28) v2(285.24,14.48) v2(285.24,13.46) v2(285.24,12.45) v2(285.46,202.39) v2(285.46,200.36) v2(285.46,198.45) v2(286.23,35.51) v2(286.23,34.24) v2(286.23,32.97) v2(286.23,31.7) v2(287.5,35.51) v2(287.5,34.24) v2(287.5,32.97) v2(287.5,31.7) v2(287.88,66.31) v2(288.04,99.95) v2(288.04,99.06) v2(288.04,98.17) v2(288.04,97.41) v2(288,64.47) v2(287.95,62.69) v2(288.8,99.95) v2(288.8,99.06) v2(288.8,98.17) v2(288.8,97.41) v2(288.77,35.51) v2(288.77,34.24) v2(288.77,32.97) v2(288.77,31.7) v2(288.89,55.83) v2(289.18,19.81) v2(289.18,18.8) v2(289.69,99.95) v2(289.69,99.06) v2(289.69,98.17) v2(289.66,91.14) v2(289.66,88.85) v2(290.04,35.51) v2(290.04,34.24) v2(290.04,32.97) v2(290.04,31.7) v2(290.32,15.49) v2(290.32,14.61) v2(290.32,13.72) v2(290.58,99.95) v2(290.58,99.06) v2(290.58,98.17) v2(290.58,86.49) v2(290.58,22.35) v2(290.93,184.23) v2(290.93,182.96) v2(291.18,67.64) v2(291.18,44.66) v2(291.18,43.39) v2(291.46,99.95) v2(291.46,99.06) v2(291.46,98.17) v2(291.56,79.96) v2(292.2,185.5) v2(292.2,184.23) v2(292.2,182.96) v2(292.35,103.76) v2(292.35,103) v2(292.35,102.23) v2(292.35,101.47) v2(292.35,99.95) v2(292.35,99.06) v2(292.35,95.89) v2(292.35,95.12) v2(292.35,94.36) v2(292.35,93.6) v2(292.35,92.84) v2(293.12,105.28) v2(293.12,104.52) v2(293.12,103.76) v2(293.12,103) v2(293.12,102.23) v2(293.12,101.47) v2(293.12,99.95) v2(293.12,96.65) v2(293.12,95.89) v2(293.12,95.12) v2(293.12,94.36) v2(293.12,93.6) v2(293.12,92.84) v2(293.12,92.08) v2(293.37,86.87) v2(293.47,184.23) v2(293.47,182.96) v2(293.88,105.28) v2(293.88,104.52) v2(293.88,103.76) v2(293.88,103) v2(293.88,102.23) v2(293.88,101.47) v2(293.88,96.65) v2(293.88,95.89) v2(293.88,95.12) v2(293.88,94.36) v2(293.88,93.6) v2(293.88,92.84) v2(293.88,92.08) v2(294.1,79.96) v2(294.99,43.39) v2(294.99,42.12) v2(295.12,38.05) v2(295.5,143.11) v2(295.45,142.47) v2(295.55,48.59) v2(295.66,86.87) v2(295.75,53.95) v2(296.04,83.69) v2(296.13,89.23) v2(296.39,38.05) v2(296.93,65.41) v2(296.93,64.52) v2(296.93,62.87) v2(296.93,61.98) v2(296.93,61.09) v2(297.18,83.69) v2(297.31,90.93) v2(297.28,10.87) v2(298.16,10.87) v2(298.45,90.93) v2(299.04,49.94) v2(299.18,10.87) v2(299.43,169.37) v2(299.43,168.74) v2(299.43,168.1) v2(299.43,167.47) v2(299.82,182.07) v2(299.85,22.61) v2(299.85,21.84) v2(299.85,21.08) v2(299.85,20.32) v2(300.07,169.37) v2(300.07,168.74) v2(300.07,168.1) v2(300.07,167.47) v2(300.07,10.87) v2(300.07,9.99) v2(300.56,49.81) v2(300.7,142.83) v2(300.96,12.53) v2(300.96,11.76) v2(300.96,10.87) v2(301.34,142.83) v2(301.34,98.12) v2(301.5,22.61) v2(301.5,21.84) v2(301.5,21.08) v2(301.96,152.85) v2(301.97,97.49) v2(302.1,107.26) v2(302.1,105.48) v2(302.24,136.49) v2(302.35,199.69) v2(302.35,198.17) v2(302.26,22.61) v2(302.26,21.84) v2(302.26,21.08) v2(302.61,98.12) v2(302.61,96.85) v2(303.24,117.68) v2(303.28,46.1) v2(303.4,13.46) v2(303.87,199.69) v2(303.87,198.17) v2(304.29,46.1) v2(304.42,13.46) v2(304.51,27.33) v2(305.28,30.51) v2(305.28,10.24) v2(305.4,35.21) v2(305.4,33.68) v2(305.43,13.46) v2(305.43,12.57) v2(306.04,28.86) v2(306.17,10.24) v2(306.17,9.1) v2(306.29,31.01) v2(307.82,29.62) v2(308.07,75.39) v2(308.2,31.78) v2(308.71,73.99) v2(308.96,77.04) v2(309.59,104.98) v2(309.59,103.95) v2(309.72,107.27) v2(310.23,77.3) v2(310.23,62.06) v2(310.23,60.53) v2(310.61,202.64) v2(310.61,201.88) v2(310.61,200.61) v2(310.61,199.34) v2(310.61,198.07) v2(310.61,196.8) v2(310.61,195.53) v2(310.61,194.26) v2(310.61,192.99) v2(310.61,191.72) v2(310.61,190.45) v2(310.61,189.18) v2(310.61,187.91) v2(310.61,186.64) v2(310.61,185.37) v2(310.61,184.1) v2(310.61,182.83) v2(310.61,172.04) v2(310.61,170.77) v2(310.61,169.5) v2(310.61,168.23) v2(310.61,166.96) v2(310.61,165.69) v2(310.61,164.42) v2(310.61,162.51) v2(310.61,161.24) v2(310.61,159.97) v2(310.61,158.7) v2(310.61,157.43) v2(310.61,156.16) v2(310.61,154.89) v2(310.61,153.62) v2(310.61,152.35) v2(310.61,151.08) v2(310.61,149.81) v2(310.61,148.54) v2(310.61,144.73) v2(310.61,143.46) v2(310.61,142.19) v2(310.61,140.92) v2(310.61,139.65) v2(310.61,138.38) v2(310.61,137.11) v2(310.61,135.84) v2(310.61,134.57) v2(310.61,133.3) v2(310.61,132.03) v2(310.61,130.76) v2(310.61,129.49) v2(310.61,125.68) v2(310.61,124.41) v2(310.61,123.14) v2(310.61,121.87) v2(311.12,113.11) v2(311.12,111.84) v2(311.12,95.96) v2(311.12,94.44) v2(311.12,93.17) v2(311.12,91.9) v2(311.12,90.63) v2(311.12,89.36) v2(311.12,88.09) v2(311.12,86.82) v2(311.12,85.55) v2(311.12,83.9) v2(311.12,82.63) v2(311.12,80.85) v2(311.12,79.58) v2(311.12,78.18) v2(311.12,73.49) v2(311.12,71.07) v2(311.12,68.28) v2(311.12,65.99) v2(311.13,42.34) v2(311.13,40.84) v2(311.13,39.34) v2(311.13,37.84) v2(311.13,36.34) v2(311.13,34.84) v2(311.13,33.34) v2(311.13,31.84) v2(311.13,30.34) v2(311.13,28.84) v2(311.12,26.75) v2(311.09,25.1) v2(311.09,23.83) v2(311.12,22.43) v2(311.12,21.29) v3(19.15,161.75) v3(19.27,157.15) v3(19.27,155.32) v3(19.27,153.5) v3(19.27,151.46) v3(192.63,150.45) v3(199.13,192.74) v3(200.25,192.71) v3(201.59,194.77) v3(211.3,166.07) v3(211.3,165.31) v3(211.3,164.54) v3(211.3,60.66) v3(211.3,59.39) v3(211.93,166.07) v3(211.93,165.31) v3(211.93,164.54) v3(212.57,166.58) v3(212.57,165.94) v3(212.57,165.18) v3(212.57,164.42) v3(212.69,115.24) v3(213.2,165.94) v3(213.2,165.18) v3(213.33,115.24) v3(214.22,115.24) v3(214.47,114.35) v3(215.11,115.24) v3(215.11,114.35) v3(215.11,113.72) v3(215.11,65.1) v3(215.11,63.71) v3(215.49,68.91) v3(215.61,66.88) v3(215.61,65.61) v3(216.38,74.63) v3(216.76,72.47) v3(216.76,70.95) v3(216.88,69.17) v3(218.41,74.76) v3(224.99,70.92) v3(225.77,50.88) v3(226.54,50.85) v3(230.14,69.65) v3(230.22,61.04) v3(230.27,57.48) v3(230.47,67.77) v3(230.58,71.2) v3(231.54,69.22) v3(231.49,59.9) v3(231.72,117.05) v3(231.74,57.48) v3(231.9,68.13) v3(232.51,67.52) v3(232.51,66.75) v3(232.51,63.33) v3(232.51,61.04) v3(232.51,59.9) v3(232.51,58.63) v3(232.51,57.48) v3(232.63,64.47) v3(232.66,71.15) v3(232.89,120.48) v3(233.14,65.61) v3(233.14,63.33) v3(233.39,64.47) v3(233.39,59.9) v3(233.39,58.63) v3(233.47,128.29) v3(233.65,57.48) v3(233.65,56.59) v3(233.78,61.04) v3(234.06,130.97) v3(234.54,64.09) v3(234.54,61.04) v3(234.54,60.28) v3(234.54,59.52) v3(234.66,58.63) v3(234.66,57.48) v3(234.92,120.48) v3(235.3,64.09) v3(235.3,60.28) v3(235.3,59.52) v3(236.06,61.04) v3(236.06,60.28) v3(236.06,59.52) v3(236.16,67.69) v3(237.04,142.57) v3(237.01,140.39) v3(237.02,138.33) v3(237.02,136.21) v3(237.02,132.04) v3(237.01,129.85) v3(237.02,125.65) v3(237.02,121.45) v3(236.95,57.48) v3(237.28,69.14) v3(237.53,140.57) v3(237.56,138.25) v3(237.56,136.15) v3(237.56,134.05) v3(237.56,131.95) v3(237.57,129.75) v3(237.56,127.75) v3(237.58,125.65) v3(237.59,64.85) v3(237.59,60.28) v3(237.69,142.17) v3(238.35,64.09) v3(238.35,63.33) v3(238.35,61.04) v3(238.35,60.28) v3(238.35,59.52) v3(238.43,152.97) v3(238.41,142.27) v3(238.4,66.63) v3(238.36,64.81) v3(238.47,67.77) v3(238.47,58.12) v3(238.47,56.87) v3(238.99,142.27) v3(239.11,64.09) v3(239.11,63.33) v3(239.11,62.56) v3(239.11,61.04) v3(239.11,60.28) v3(239.49,58.12) v3(239.69,140.77) v3(239.85,59.49) v3(239.87,64.85) v3(239.87,60.28) v3(239.99,177.24) v3(239.99,151.72) v3(240.39,140.87) v3(240.48,140.17) v3(240.87,177.15) v3(240.89,58.75) v3(241.01,66.75) v3(240.98,59.89) v3(241.29,74.22) v3(241.34,65.61) v3(241.27,63.33) v3(241.62,59.87) v3(241.68,151.65) v3(241.7,74.78) v3(241.77,151.1) v3(241.79,138.77) v3(241.78,67.77) v3(242.13,117.42) v3(242.71,65.52) v3(242.71,64.34) v3(242.68,63.33) v3(242.88,138.37) v3(242.97,74.78) v3(243.05,68.79) v3(243.05,67.77) v3(243.43,63.33) v3(243.43,58.5) v3(244.06,66.75) v3(244.14,57.73) v3(244.17,67.66) v3(244.19,63.33) v3(244.47,96.72) v3(244.58,145.07) v3(244.6,70.95) v3(244.69,144.37) v3(244.82,57.74) v3(244.82,55.83) v3(245.08,63.33) v3(245.29,139.42) v3(245.29,135.92) v3(245.29,134.52) v3(245.29,133.12) v3(245.29,132.42) v3(245.29,131.02) v3(245.29,129.62) v3(245.29,128.92) v3(245.29,127.52) v3(245.29,126.12) v3(245.29,124.72) v3(245.29,123.32) v3(245.36,70.49) v3(245.47,55.7) v3(245.59,56.47) v3(245.82,69.42) v3(246.08,117.07) v3(246.35,66.75) v3(246.48,64.47) v3(246.63,69.55) v3(246.69,139.42) v3(246.69,137.32) v3(246.69,133.12) v3(246.69,129.62) v3(246.69,128.92) v3(246.69,127.52) v3(246.69,126.12) v3(246.69,124.72) v3(246.69,123.32) v3(246.69,122.62) v3(246.87,86.32) v3(247.03,67.8) v3(247.05,65.64) v3(247.34,73.46) v3(247.79,150.61) v3(248.09,137.32) v3(248.09,132.42) v3(248.09,129.62) v3(248.09,128.92) v3(248.09,127.52) v3(248.09,126.12) v3(248.09,124.72) v3(248.09,123.32) v3(248.09,122.62) v3(248.51,53.17) v3(248.51,52.15) v3(248.79,119.03) v3(249.02,73.74) v3(249.48,139.42) v3(249.48,138.72) v3(249.48,135.92) v3(249.48,134.52) v3(249.48,129.62) v3(249.48,128.92) v3(249.48,127.52) v3(249.48,126.12) v3(249.48,124.72) v3(249.48,123.32) v3(249.48,122.62) v3(250.32,115.75) v3(250.51,111.48) v3(250.72,87.52) v3(250.91,167.55) v3(250.88,139.42) v3(250.88,138.72) v3(250.88,135.92) v3(250.88,132.42) v3(250.88,131.02) v3(250.88,129.62) v3(250.88,128.92) v3(250.88,127.52) v3(250.88,126.12) v3(250.88,124.72) v3(250.88,123.32) v3(250.88,122.62) v3(250.87,85.52) v3(251.3,110.29) v3(251.3,109.12) v3(251.71,167.55) v3(251.67,87.93) v3(251.67,87.12) v3(251.67,86.32) v3(252.23,137.32) v3(252.28,139.42) v3(252.31,138.72) v3(252.28,135.92) v3(252.28,134.52) v3(252.28,133.12) v3(252.28,132.42) v3(252.28,129.62) v3(252.28,128.92) v3(252.28,127.52) v3(252.28,126.12) v3(252.28,124.72) v3(252.44,116.32) v3(252.47,86.32) v3(252.47,85.52) v3(252.99,116.37) v3(253.09,124.72) v3(253.09,123.32) v3(253.09,122.62) v3(253.27,87.12) v3(253.54,108.31) v3(253.69,128.97) v3(254.11,173.95) v3(254.09,110.96) v3(254.09,109.8) v3(254.39,126.82) v3(255.18,139.42) v3(255.18,138.72) v3(255.18,137.32) v3(255.18,135.92) v3(255.18,134.52) v3(255.18,133.12) v3(255.18,132.42) v3(255.18,131.02) v3(255.18,128.92) v3(255.18,127.52) v3(255.18,126.12) v3(255.23,124.72) v3(255.18,123.32) v3(255.18,122.62) v3(256.62,144.32) v3(256.58,139.42) v3(256.58,138.72) v3(256.58,137.32) v3(256.58,135.92) v3(256.58,134.52) v3(256.58,133.12) v3(256.58,132.42) v3(256.58,131.02) v3(256.58,129.62) v3(256.58,128.92) v3(256.58,127.52) v3(256.58,123.32) v3(256.58,122.62) v3(256.69,146.21) v3(257.2,145.71) v3(257.99,137.32) v3(257.99,135.92) v3(257.99,134.52) v3(257.99,133.12) v3(257.99,132.42) v3(257.99,131.02) v3(257.99,129.62) v3(257.99,128.92) v3(257.99,127.52) v3(257.99,123.32) v3(257.99,122.62) v3(259.39,137.32) v3(259.39,135.92) v3(259.39,134.52) v3(259.39,133.12) v3(259.39,132.42) v3(259.39,131.02) v3(259.39,129.62) v3(259.39,128.92) v3(259.39,124.72) v3(259.39,123.32) v3(259.39,122.62) v3(259.56,150.19) v3(259.68,178.9) v3(259.71,174.75) v3(259.82,154.15) v3(259.8,152.18) v3(260.51,174.75) v3(260.79,139.42) v3(260.79,138.72) v3(260.79,137.32) v3(260.79,135.92) v3(260.79,134.52) v3(260.79,133.12) v3(260.79,132.42) v3(260.79,131.02) v3(260.79,129.62) v3(260.79,128.92) v3(260.79,124.72) v3(260.79,123.32) v3(260.79,122.62) v3(261.31,173.95) v3(261.79,154.2) v3(261.79,152.37) v3(262.11,174.75) v3(262.18,139.42) v3(262.18,138.72) v3(262.18,137.32) v3(262.18,135.92) v3(262.18,134.52) v3(262.18,133.12) v3(262.18,132.42) v3(262.18,131.02) v3(262.18,129.62) v3(262.18,128.92) v3(262.18,124.72) v3(262.18,123.32) v3(262.18,122.62) v3(263.87,150.57) v3(265.98,110.85) v3(267.55,151.51) v3(267.93,174.75) v3(268.44,144.34) v3(269.09,111.83) v3(269.09,110.08) v3(269.87,84.71) v3(271.93,173.95) v3(271.93,173.15) v3(272.62,135.72) v3(272.84,118.84) v3(273.03,84.72) v3(273.22,132.77) v3(273.42,135.72) v3(273.56,117) v3(273.83,130.71) v3(273.78,115.01) v3(273.88,134.87) v3(274.58,135.72) v3(274.97,132.77) v3(275.63,134.87) v3(277.39,134.87) v3(278.33,173.95) v3(278.33,169.95) v3(278.33,167.55) v3(278.33,165.95) v3(279.13,177.95) v3(296.1,153.74) v3(297.03,135.92) v3(298.62,121.08) v3(299.49,108.11) v3(300.58,134.7) v3(301.34,158.96) v3(301.59,136.5) v3(301.85,110.7) v3(302.74,152.86) v3(302.74,144.86) v3(302.74,144.22) v3(302.99,154) v3(303.24,121.11) v3(303.75,148.16) v3(303.75,147.53) v3(303.75,130.13) v3(303.75,129.49) v3(310.61,147.27) v3(310.61,146) v3(310.61,128.22) v3(310.61,126.95) v3(311.12,110.57) v3(311.12,109.55)
