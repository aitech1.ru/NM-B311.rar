# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_PRX_GTX_N3: length 40.8
  TOP w0.076: v3(187.67,138.68) 187.92,138.93 187.92,138.95 188.2,139.22 189.29,139.22 189.62,138.89 190.81,138.89 191.03,138.68 191.1,138.6 191.17,138.6 191.18,138.59
  TOP w0.104: 191.18,138.59 191.26,138.52 191.84,137.94 v2(203.93,137.94) 209.94,137.94 213.55,134.32 221.08,134.32 221.33,134.07 223.49,134.07 224.07,133.49 224.87,133.49 C671.2
  BOTTOM w0.104: U1.E13 187.35,139 v3(187.67,138.68)
PEG_PRX_GTX_N4: length 37.5
  TOP w0.076: 191.53,139.08 191.3,139.08 190.98,139.4 190.41,139.4 190.08,139.72 188.09,139.72 187.93,139.88 187.46,139.88 187.39,139.81 187.39,139.56 187.48,139.46 v3(187.67,139.46)
  TOP w0.104: C673.2 221.45,135.27 214.14,135.27 210.33,139.08 v2(205.96,139.08) 191.53,139.08
  BOTTOM w0.104: v3(187.67,139.46) 187.35,139.79 U1.E14
PEG_PRX_GTX_N5: length 40.3
  TOP w0.076: v3(187.67,140.25) 188.04,140.62 188.88,140.62 188.96,140.54 190.68,140.54 191.24,139.98 191.55,139.98 191.6,140.04 191.61,140.04
  TOP w0.104: C675.2 224.87,135.91 224.14,135.91 223.57,136.48 214.54,136.48 210.98,140.04 v2(200.88,140.04) 191.61,140.04
  BOTTOM w0.104: v3(187.67,140.25) 187.35,140.58 U1.E15
PEG_PRX_GTX_N6: length 37.1
  TOP w0.076: 192.07,140.93 192.05,140.93 192,140.87 191.05,140.87 190.9,141.02 188.23,141.02 187.83,141.43 187.55,141.43 187.45,141.33 187.45,141.12 187.52,141.04 v3(187.67,141.04)
  TOP w0.104: C680.2 221.45,137.69 214.95,137.69 211.72,140.93 v2(206.72,140.93) 192.07,140.93
  BOTTOM w0.104: v3(187.67,141.04) 187.35,141.37 U1.E16
PEG_PRX_GTX_N7: length 40.8
  TOP w0.076: 191.37,141.58 191.36,141.59 191.29,141.59 190.91,141.96 189.01,141.96 188.6,142.37 187.95,142.37 187.83,142.24 187.44,142.24 v3(187.02,141.83)
  TOP w0.104: 191.37,141.58 191.44,141.51 191.83,141.51 192.14,141.81 v2(208.93,141.81) 209.37,141.81 209.37,141.81 212.63,141.81 215.55,138.89 223.32,138.89 223.65,138.56 225.12,138.56 C682.2
  BOTTOM w0.104: U1.E17 187.35,142.15 v3(187.02,141.83)
PEG_PRX_GTX_N8: length 36.8
  TOP w0.076: 190.51,142.52 190.5,142.52 190.45,142.47 189.49,142.47 188.98,142.98 187.39,142.98 v3(187.02,142.62)
  TOP w0.104: C868.2 221.66,140.31 215.62,140.31 213.23,142.7 v2(206.47,142.7) 191.38,142.7 191.2,142.52 190.51,142.52
  BOTTOM w0.104: v3(187.02,142.62) 186.7,142.94 U1.F18
PEG_PRX_GTX_N9: length 40.2
  TOP w0.076: 192.26,143.29 192.25,143.29 192.2,143.35 190.28,143.35 190.19,143.26 189.72,143.26 189.63,143.35 189.06,143.35 188.63,143.78 187.97,143.78 187.67,143.48 v3(187.67,143.4)
  TOP w0.104: C870.2 224.85,140.16 224.75,140.26 224.75,140.69 224.64,140.79 223.59,140.79 223.41,140.97 216.2,140.97 213.76,143.42 v2(201.77,143.42) 193.6,143.42 193.48,143.29 192.26,143.29
  BOTTOM w0.104: U1.D19 188,143.73 v3(187.67,143.4)
PEG_PRX_GTX_N10: length 36.6
  TOP w0.076: v3(187.02,144.19) 187.02,144.21 187.42,144.61 189.33,144.61 189.82,144.12 191.75,144.12 192.13,144.5 192.35,144.5 192.4,144.56 192.42,144.56
  TOP w0.104: C875.2 216.36,142.7 214.5,144.56 v2(204.82,144.56) 192.42,144.56
  BOTTOM w0.104: v3(187.02,144.19) 186.7,144.52 U1.F20
PEG_PRX_GTX_N11: length 40
  TOP w0.076: v3(187.67,144.98) 187.6,145.05 187.6,145.19 187.67,145.27 188.03,145.27 188.13,145.37 188.49,145.37 188.88,144.98 192.18,144.98 192.44,145.25 192.52,145.25 192.53,145.26
  TOP w0.104: C877.2 225.19,142.89 225.09,142.99 224.85,142.99 224.63,143.21 223.76,143.21 223.63,143.34 216.65,143.34 214.72,145.26 v2(198.6,145.26) 192.53,145.26
  BOTTOM w0.104: v3(187.67,144.98) 188,145.3 U1.D21
PEG_PRX_GTX_N12: length 36.7
  TOP w0.076: v3(187.02,145.76) 187.27,146.01 187.28,146.01 187.44,146.18 189.93,146.18 190.46,145.65 191.82,145.65 191.9,145.73 191.9,145.8 191.91,145.82
  TOP w0.104: 191.91,145.82 192.54,146.44 192.54,146.44 192.67,146.57 v2(205.78,146.57) 215.35,146.57 216.8,145.12 221.64,145.12 C879.2
  BOTTOM w0.104: U1.F22 186.7,146.09 v3(187.02,145.76)
PEG_PRX_GTX_N13: length 39.9
  TOP w0.076: v3(187.67,146.55) 187.67,146.7 187.77,146.8 187.97,146.8 188.13,146.97 188.77,146.97 188.92,147.12 188.99,147.12 189,147.13
  TOP w0.104: 189,147.13 189.15,147.27 190.09,147.27 190.34,147.02 190.55,147.02 190.65,146.92 191.12,146.92 191.22,147.02 191.79,147.02 192.13,147.35 v2(201.9,147.35) 215.63,147.35 217.24,145.74 224.65,145.74 224.76,145.64 224.76,145.23 224.87,145.11 C881.2
  BOTTOM w0.104: U1.D23 188,146.88 v3(187.67,146.55)
PEG_PRX_GTX_N14: length 36.4
  TOP w0.076: 189.05,148.29 189.03,148.27 189.03,148.2 188.59,147.76 187.69,147.76 187.61,147.68 187.46,147.68 187.12,147.34 v3(187.02,147.34)
  TOP w0.104: 189.05,148.29 189.38,148.62 v2(199.49,148.62) 216.24,148.62 217.28,147.58 221.56,147.58 C884.2
  BOTTOM w0.104: U1.F24 186.7,147.66 v3(187.02,147.34)
PEG_PRX_GTX_N15: length 39.6
  TOP w0.076: 189.37,149.05 189.35,149.05 189.3,149.1 188.72,149.1 188.31,148.69 188.3,148.68 188.01,148.39 187.75,148.39 187.67,148.31 v3(187.67,148.13)
  TOP w0.104: 189.37,149.05 191.34,149.05 191.54,149.25 v2(207.49,149.25) 217.07,149.25 217.65,148.67 223.1,148.67 223.61,148.16 224.55,148.16 224.66,148.06 224.66,147.63 224.76,147.53 C885.2
  BOTTOM w0.104: v3(187.67,148.13) 188,148.45 U1.D25
PEG_PRX_GTX_P0: length 38.1
  TOP w0.104: C650.2 221.45,130.19 212.65,130.19 207.83,135.01 v2(198.6,135.01) 190.07,135.01 188.99,136.1 188.11,136.1 187.96,135.95 187.39,135.95 v3(187.02,136.32)
  BOTTOM w0.104: v3(187.02,136.32) 186.7,136.64 U1.F10
PEG_PRX_GTX_P1: length 41.6
  TOP w0.076: 189.83,136.6 189.83,136.62 189.88,136.68 189.88,136.79 189.17,137.51 188.21,137.51 188.07,137.37 188.07,137.2 188.17,137.1 v3(188.32,137.1)
  TOP w0.104: C663.2 224.87,130.82 223.88,130.82 223.3,131.4 221.22,131.4 221.1,131.27 212.95,131.27 208.32,135.89 v2(203.68,135.89) 190.09,135.89 189.83,136.15 189.83,136.6
  BOTTOM w0.104: v3(188.32,137.1) 188,137.43 U1.D11
PEG_PRX_GTX_P2: length 37.6
  TOP w0.076: 190.74,137.68 190.72,137.68 190.67,137.63 190.49,137.63 189.84,138.28 187.52,138.28 187.13,137.89 v3(187.02,137.89)
  TOP w0.104: C653.2 221.24,133.18 221.24,133.18 220.82,133.18 220.57,133.43 212.79,133.43 209.19,137.04 v2(201.64,137.04) 191.61,137.04 190.97,137.68 190.74,137.68
  BOTTOM w0.104: U1.F12 186.7,138.22 v3(187.02,137.89)
PEG_PRX_GTX_P3: length 40.7
  TOP w0.076: v3(188.32,138.68) 188.15,138.68 188.11,138.72 188.11,138.92 188.26,139.07 189.22,139.07 189.55,138.74 190.75,138.74 190.92,138.57 190.99,138.5 190.99,138.42 191,138.41
  TOP w0.104: C670.2 224.87,133.24 223.96,133.24 223.39,133.81 221.22,133.81 220.97,134.06 213.45,134.06 209.83,137.68 v2(208.12,137.68) 191.73,137.68 191.08,138.34 191,138.41
  BOTTOM w0.104: v3(188.32,138.68) 188,139 U1.D13
PEG_PRX_GTX_P4: length 37.6
  TOP w0.076: 191.53,138.82 191.51,138.82 191.46,138.87 191.29,138.87 190.91,139.25 190.34,139.25 190.02,139.57 188.3,139.57 187.85,139.12 187.37,139.12 v3(187.02,139.46)
  TOP w0.104: C672.2 221.45,135.02 214.03,135.02 210.23,138.82 v2(198.72,138.82) 191.53,138.82
  BOTTOM w0.104: v3(187.02,139.46) 186.7,139.79 U1.F14
PEG_PRX_GTX_P5: length 40.3
  TOP w0.076: 191.61,139.78 191.59,139.78 191.54,139.83 191.18,139.83 190.62,140.39 188.77,140.39 188.69,140.31 188.69,139.98 188.61,139.91 188.34,139.91 188.24,140 188.24,140.17 v3(188.32,140.25)
  TOP w0.104: C674.2 224.87,135.65 224.04,135.65 223.46,136.22 214.43,136.22 210.88,139.78 v2(209.9,139.78) 191.61,139.78
  BOTTOM w0.104: U1.D15 188,140.58 v3(188.32,140.25)
PEG_PRX_GTX_P6: length 37
  TOP w0.076: v3(187.02,141.04) 187.37,140.69 187.85,140.69 188.03,140.87 190.84,140.87 190.99,140.72 192,140.72 192.05,140.67 192.07,140.67 ; 192.3,140.67 192.3,140.67
  TOP w0.104: 192.07,140.67 192.3,140.67 ; C679.2 221.45,137.43 214.85,137.43 211.61,140.67 v2(198.6,140.67) 192.3,140.67
  BOTTOM w0.104: v3(187.02,141.04) 186.7,141.37 U1.F16
PEG_PRX_GTX_P7: length 40.7
  TOP w0.076: v3(187.67,141.83) 187.63,141.87 187.63,142.01 187.71,142.09 187.9,142.09 188.03,142.22 188.54,142.22 188.94,141.81 190.85,141.81 191.18,141.48 191.18,141.41 191.19,141.4
  TOP w0.104: 191.19,141.4 191.34,141.25 191.94,141.25 192.24,141.56 v2(200.93,141.56) 209.14,141.56 209.14,141.56 212.52,141.56 215.45,138.64 223.21,138.64 223.54,138.31 224.6,138.31 224.71,138.2 224.71,137.85 224.81,137.75 C681.2
  BOTTOM w0.104: v3(187.67,141.83) 188,142.15 U1.D17
PEG_PRX_GTX_P8: length 36.7
  TOP w0.076: 190.51,142.27 190.5,142.27 190.45,142.32 189.43,142.32 188.92,142.83 188.74,142.83 188.67,142.75 188.23,142.75 188.16,142.83 187.77,142.83 187.67,142.73 v3(187.67,142.62)
  TOP w0.104: C869.2 221.3,139.53 221.2,139.63 221.2,139.93 221.08,140.06 215.51,140.06 213.12,142.45 v2(203.55,142.45) 193.07,142.45 192.94,142.32 192.65,142.32 192.52,142.45 192.23,142.45 192.11,142.32 191.82,142.32 191.69,142.45 191.48,142.45 191.31,142.27 190.51,142.27
  BOTTOM w0.104: U1.E18 187.35,142.94 v3(187.67,142.62)
PEG_PRX_GTX_P9: length 40.3
  TOP w0.076: 192.26,143.55 192.24,143.55 192.19,143.5 189.12,143.5 188.69,143.93 187.9,143.93 187.79,143.82 187.44,143.82 v3(187.02,143.4)
  TOP w0.104: 192.26,143.55 193.37,143.55 193.49,143.67 v2(209.77,143.67) 213.86,143.67 216.31,141.23 223.52,141.23 223.7,141.05 224.8,141.05 C874.2
  BOTTOM w0.104: v3(187.02,143.4) 187.35,143.73 U1.E19
PEG_PRX_GTX_P10: length 36.5
  TOP w0.076: v3(187.67,144.19) 187.64,144.22 187.64,144.33 187.75,144.44 188.11,144.44 188.17,144.38 188.69,144.38 188.76,144.44 189.28,144.44 189.75,143.97 191.81,143.97 192.19,144.35 192.35,144.35 192.4,144.3 192.42,144.3
  TOP w0.104: 192.42,144.3 v2(212.82,144.3) 214.4,144.3 216.25,142.44 221.23,142.44 221.33,142.34 221.33,141.97 221.43,141.86 221.71,141.86 C876.2
  BOTTOM w0.104: v3(187.67,144.19) 187.35,144.52 U1.E20
PEG_PRX_GTX_P11: length 40.1
  TOP w0.076: v3(187.02,144.98) 187.46,145.42 187.97,145.42 188.07,145.52 188.55,145.52 188.94,145.13 192.11,145.13 192.5,145.52 192.53,145.52
  TOP w0.104: 192.53,145.52 v2(209.26,145.52) 214.83,145.52 216.76,143.59 223.74,143.59 223.87,143.46 C878.2
  BOTTOM w0.104: U1.E21 187.35,145.3 v3(187.02,144.98)
PEG_PRX_GTX_P12: length 36.7
  TOP w0.076: v3(187.67,145.76) 187.67,145.94 187.75,146.01 188.27,146.01 188.36,145.93 188.72,145.93 188.8,146.01 189.15,146.01 189.24,145.93 189.63,145.93 189.72,146.01 189.88,146.01 190.39,145.5 191.89,145.5 192.01,145.62 192.08,145.62 192.09,145.63
  TOP w0.104: C880.2 221.63,144.22 221.34,144.22 221.23,144.34 221.23,144.76 221.12,144.86 216.7,144.86 215.25,146.31 v2(214.03,146.31) 192.77,146.31 192.09,145.63
  BOTTOM w0.104: v3(187.67,145.76) 187.35,146.09 U1.E22
PEG_PRX_GTX_P13: length 40.1
  TOP w0.076: 188.82,147.31 188.81,147.3 188.81,147.22 188.7,147.12 188.03,147.12 187.87,146.96 187.49,146.96 187.08,146.55 v3(187.02,146.55)
  TOP w0.104: 188.82,147.31 189.04,147.53 190.19,147.53 190.45,147.28 191.68,147.28 192.02,147.61 v2(210.41,147.61) 215.74,147.61 217.35,146 224.74,146 224.74,146 C882.2
  BOTTOM w0.104: v3(187.02,146.55) 187.35,146.88 U1.E23
PEG_PRX_GTX_P14: length 36.3
  TOP w0.076: v3(187.67,147.34) 187.67,147.44 187.75,147.52 187.89,147.52 188.11,147.3 188.23,147.3 188.31,147.37 188.31,147.53 188.39,147.6 188.65,147.6 189.14,148.09 189.22,148.09 189.23,148.11
  TOP w0.104: 189.23,148.11 189.48,148.36 v2(205.07,148.36) 216.13,148.36 217.17,147.32 221.76,147.32 221.86,147.22 221.86,146.99 C883.2
  BOTTOM w0.104: v3(187.67,147.34) 187.35,147.66 U1.E24
PEG_PRX_GTX_P15: length 39.7
  TOP w0.076: v3(187.02,148.13) 187.44,148.54 187.95,148.54 188.19,148.78 188.19,148.79 188.66,149.25 189.3,149.25 189.35,149.31 189.37,149.31
  TOP w0.104: 189.37,149.31 191.23,149.31 191.43,149.5 v2(201.9,149.5) 217.18,149.5 217.75,148.93 223.2,148.93 223.71,148.42 C886.2
  BOTTOM w0.104: v3(187.02,148.13) 187.35,148.45 U1.E25
PEG_PTX_C_GRX_N0: length 37.1
  BOTTOM w0.104: C32.1 204.31,133.18 205.94,134.81 208.33,134.81 v2(210.6,134.81) 210.61,134.81 218.22,134.81 218.23,134.81 220.54,134.81 220.93,134.81 224.59,131.15 233.29,131.15 234.09,131.95 236.12,131.95 236.37,131.7 236.79,131.7 237.13,131.37 G2.BK27
PEG_PTX_C_GRX_N1: length 40.6
  BOTTOM w0.104: G2.BL29 236.4,132.95 236.26,132.95 236.19,132.87 236.19,132.59 236.04,132.45 235.12,132.45 234.94,132.62 233.87,132.62 233.16,131.91 229.12,131.91 228.97,132.06 224.99,132.06 221.36,135.69 219.13,135.69 210.71,135.69 v2(208.17,135.69) 205.56,135.69 204.18,134.32 200.2,134.32 200.04,134.47 200.04,134.8 199.92,134.93 199.59,134.93 C30.1
PEG_PTX_C_GRX_N2: length 35.4
  BOTTOM w0.104: C28.1 203.3,135.53 204.02,135.53 205.11,136.63 207.69,136.63 207.69,136.63 v2(210.67,136.63) 219.08,136.63 221.8,136.63 225.48,132.95 229.02,132.95 229.3,132.67 233.03,132.67 233.63,133.26 235.68,133.26 G2.BM30
PEG_PTX_C_GRX_N3: length 40.7
  BOTTOM w0.104: C26.1 199.63,136.92 200.71,136.92 200.9,136.73 204.04,136.73 204.56,137.26 208.98,137.26 v2(215.11,137.26) 222.2,137.26 225.93,133.53 229.12,133.53 229.47,133.17 233.01,133.17 233.55,133.71 235.57,133.71 235.65,133.79 236.06,133.79 236.26,133.59 236.26,133.33 236.44,133.15 236.79,133.15 237.1,133.47 G2.BK30
PEG_PTX_C_GRX_N4: length 36.6
  BOTTOM w0.104: G2.BL32 236.51,134.94 236.31,134.94 236.21,134.84 236.21,134.7 236.04,134.53 235.34,134.53 235.21,134.66 233.24,134.66 232.78,134.19 229.77,134.19 229.2,134.75 226.62,134.75 223.1,138.28 219.08,138.28 219.07,138.28 218.97,138.28 v2(211.68,138.28) 211.68,138.28 207.96,138.28 204.13,138.28 203.73,137.88 203.58,137.88 203.47,137.98 203.47,138.51 203.4,138.59 203.07,138.59 C24.1
PEG_PTX_C_GRX_N5: length 38.9
  BOTTOM w0.104: G2.BM33 235.65,135.33 233.03,135.33 232.65,134.96 229.89,134.96 229.13,135.72 227.17,135.72 223.72,139.17 219.05,139.17 219.05,139.17 218.26,139.17 v2(215.21,139.17) 215.21,139.17 204.27,139.17 204.22,139.22 203.91,139.53 201.62,139.53 201.33,139.82 199.77,139.82 C22.1
PEG_PTX_C_GRX_N6: length 37
  BOTTOM w0.104: C20.1 203.33,140.84 204,140.84 204.75,140.08 v2(210.1,140.08) 212.42,140.08 212.42,140.08 224.31,140.08 227.7,136.68 229.21,136.68 230.17,135.72 232.53,135.72 232.78,135.97 235.42,135.97 235.6,136.15 236.15,136.15 236.37,135.93 236.74,135.93 237.1,135.57 G2.BK33
PEG_PTX_C_GRX_N7: length 40.4
  BOTTOM w0.104: G2.BL35 236.58,137.02 236.48,137.13 236.28,137.13 236.2,137.05 236.2,136.72 236.12,136.64 232.44,136.64 232.27,136.48 230.36,136.48 229.24,137.6 228.15,137.6 224.66,141.08 214.94,141.08 213.01,141.09 212.91,141.09 v2(207.62,141.09) 205.02,141.09 204.04,142.07 200.1,142.07 199.99,142.17 199.99,142.5 199.92,142.57 C18.1
PEG_PTX_C_GRX_N8: length 35.8
  BOTTOM w0.104: C16.1 203.26,143.5 203.88,143.5 205.24,142.14 211.01,142.14 v2(214.82,142.14) 215.25,142.14 215.25,142.14 216.12,142.14 224.99,142.14 228.61,138.51 229.2,138.51 230.47,137.24 235.19,137.24 235.4,137.45 235.67,137.45 G2.BM36
PEG_PTX_C_GRX_N9: length 41.5
  BOTTOM w0.104: G2.BK36 236.97,137.35 236.47,137.35 236.21,137.61 236.21,137.81 236.05,137.98 235.41,137.98 235.17,137.75 230.53,137.75 225.35,142.93 210.88,142.93 v2(210.88,142.93) 210.88,142.93 205.43,142.93 203.42,144.94 199.69,144.94 C14.1
PEG_PTX_C_GRX_N10: length 38.3
  BOTTOM w0.104: C12.1 202.91,146.34 203.17,146.59 203.59,146.59 206.29,143.89 v2(216.63,143.89) 225.62,143.89 231.03,138.48 236.18,138.48 236.4,138.7 236.85,138.7 236.95,138.79 236.95,139.01 236.84,139.11 236.63,139.11 G2.BL38
PEG_PTX_C_GRX_N11: length 40.4
  BOTTOM w0.104: C10.1 199.49,148.92 199.81,148.6 200.8,148.6 201.24,148.16 203.67,148.16 206.78,145.06 208.82,145.06 208.82,145.06 v2(210.85,145.06) 210.85,145.06 226.06,145.06 231.6,139.52 235.64,139.52 G2.BM39
PEG_PTX_C_GRX_N12: length 38.7
  BOTTOM w0.104: G2.BK39 237.07,139.77 236.74,140.09 236.44,140.09 236.37,140.16 236.18,140.35 234.62,140.35 234.56,140.29 232.1,140.29 226.42,145.97 v2(208.47,145.97) 207.26,145.97 204.19,149.05 204.19,149.33 203.58,149.94 C8.1
PEG_PTX_C_GRX_N13: length 44.5
  BOTTOM w0.104: C6.1 199.43,151.02 199.51,150.94 199.75,150.94 199.99,150.7 200.14,150.7 200.88,151.44 200.88,152.08 201.64,152.83 202.42,152.83 204.54,150.71 204.54,150.22 207.81,146.96 220,146.96 v2(220,146.96) 220,146.96 226.69,146.96 232.6,141.05 235.14,141.05 235.33,140.85 236.03,140.85 236.19,141.01 236.19,141.23 236.29,141.33 236.44,141.33 236.58,141.19 G2.BL41
PEG_PTX_C_GRX_N14: length 44.7
  BOTTOM w0.104: G2.BM42 235.67,141.65 235.31,141.65 235.17,141.79 233.11,141.79 226.91,147.99 v2(224.04,147.99) 209.16,147.99 205.33,151.82 205.33,152.29 203.4,154.22 201.75,154.22 200.39,152.86 198.85,152.86 198.52,152.53 197.91,152.53 C4.1
PEG_PTX_C_GRX_N15: length 45.8
  BOTTOM w0.104: G2.BK42 236.98,141.56 236.44,141.56 236.23,141.76 236.23,141.99 235.96,142.27 233.56,142.27 227.19,148.63 v2(212,148.63) 209.48,148.63 206.22,151.89 206.22,152.96 204.93,154.25 204.93,154.98 204.11,155.8 202.3,155.8 200.34,153.83 199.88,153.83 199.81,153.83 199.77,153.83 C2.1
PEG_PTX_C_GRX_P0: length 37
  BOTTOM w0.104: G2.BL27 236.34,131.37 236.02,131.69 235.11,131.69 234.99,131.58 234.58,131.58 234.46,131.69 234.2,131.69 233.4,130.89 232.23,130.89 232.1,130.76 231.69,130.76 231.56,130.89 224.49,130.89 220.83,134.55 v2(218,134.55) 209.47,134.55 208.33,134.55 206.05,134.55 204.42,132.92 203.65,132.92 203.55,132.82 203.55,132.39 203.4,132.24 203.04,132.24 C31.1
PEG_PTX_C_GRX_P1: length 40.6
  BOTTOM w0.104: C29.1 199.96,134.19 200.09,134.06 204.29,134.06 205.66,135.44 210.71,135.44 210.71,135.43 v2(215.57,135.43) 221.25,135.43 224.88,131.8 228.86,131.8 229.02,131.65 233.27,131.65 233.98,132.36 234.84,132.36 235.01,132.19 236.15,132.19 236.39,132.43 236.95,132.43 G2.BK29
PEG_PTX_C_GRX_P2: length 35.5
  BOTTOM w0.104: G2.BM29 235.65,133.01 233.73,133.01 233.14,132.41 229.19,132.41 228.91,132.69 225.37,132.69 221.69,136.37 v2(220.61,136.37) 218.29,136.37 205.22,136.37 204.12,135.27 203.31,135.27 C27.1
PEG_PTX_C_GRX_P3: length 40.7
  BOTTOM w0.104: C25.1 199.43,137.28 199.54,137.18 200.82,137.18 201.01,136.99 203.93,136.99 204.46,137.51 v2(208.98,137.51) 222.31,137.51 226.04,133.79 229.22,133.79 229.58,133.43 232.9,133.43 233.44,133.97 235.46,133.97 235.54,134.05 236.18,134.05 236.42,133.81 236.74,133.81 236.87,133.68 236.87,133.56 236.75,133.45 236.61,133.45 G2.BL30
PEG_PTX_C_GRX_P4: length 36.6
  BOTTOM w0.104: C23.1 203.84,137.62 204.24,138.02 211.68,138.02 218.97,138.02 218.97,138.02 219.07,138.02 v2(219.07,138.02) 219.08,138.02 222.99,138.02 226.52,134.5 229.1,134.5 229.66,133.94 232.88,133.94 233.35,134.4 235.11,134.4 235.23,134.28 236.15,134.28 236.38,134.5 236.71,134.5 237.07,134.87 G2.BK32
PEG_PTX_C_GRX_P5: length 38.8
  BOTTOM w0.104: C21.1 199.73,139.57 201.22,139.57 201.52,139.27 203.8,139.27 204.16,138.91 219.05,138.91 219.05,138.92 v2(222.86,138.92) 223.61,138.92 227.07,135.46 229.02,135.46 229.79,134.7 232.76,134.7 233.14,135.08 235.67,135.08 G2.BM32
PEG_PTX_C_GRX_P6: length 37
  BOTTOM w0.104: G2.BL33 236.66,135.49 236.66,135.3 236.56,135.2 236.32,135.2 236.21,135.3 236.21,135.73 236.04,135.89 235.71,135.89 235.53,135.71 232.88,135.71 232.63,135.46 230.07,135.46 229.1,136.43 227.6,136.43 224.2,139.83 217.93,139.83 v2(217.5,139.83) 212.42,139.83 204.65,139.83 203.89,140.58 203.29,140.58 C19.1
PEG_PTX_C_GRX_P7: length 40.5
  BOTTOM w0.104: G2.BK35 237.12,136.97 236.8,136.64 236.49,136.64 236.23,136.39 232.54,136.39 232.38,136.22 230.25,136.22 229.14,137.34 228.04,137.34 224.55,140.83 214.94,140.83 213.01,140.83 212.91,140.83 v2(212.91,140.83) 212.91,140.83 207.19,140.83 204.91,140.83 203.93,141.81 199.56,141.81 C17.1
PEG_PTX_C_GRX_P8: length 35.9
  BOTTOM w0.104: G2.BM35 235.66,137.2 235.51,137.2 235.3,136.99 230.36,136.99 229.09,138.26 228.51,138.26 224.88,141.88 220.37,141.88 v2(219.93,141.88) 205.13,141.88 203.77,143.24 203.2,143.24 C15.1
PEG_PTX_C_GRX_P9: length 41.5
  BOTTOM w0.104: C13.1 199.49,145.51 199.8,145.2 203.52,145.2 205.53,143.19 v2(208.47,143.19) 225.46,143.19 230.64,138 235.07,138 235.3,138.24 236.15,138.24 236.36,138.03 236.78,138.03 236.94,137.87 236.94,137.71 236.84,137.61 236.65,137.61 G2.BL36
PEG_PTX_C_GRX_P10: length 38.4
  BOTTOM w0.104: C11.1 203.18,146.85 203.7,146.85 206.4,144.15 v2(213.26,144.15) 225.72,144.15 231.13,138.74 236.07,138.74 236.24,138.91 236.24,139.17 236.45,139.38 236.98,139.38 G2.BK38
PEG_PTX_C_GRX_P11: length 40.4
  BOTTOM w0.104: C9.1 199.49,148.04 199.79,148.35 200.7,148.35 201.14,147.91 203.57,147.91 206.67,144.8 v2(219.05,144.8) 225.95,144.8 231.49,139.26 235.69,139.26 G2.BM38
PEG_PTX_C_GRX_P12: length 38.6
  BOTTOM w0.104: G2.BL39 236.41,139.59 236.28,139.59 236.2,139.67 236.2,139.97 236.07,140.09 234.72,140.09 234.66,140.03 234.07,140.03 233.94,139.91 233.53,139.91 233.4,140.03 232.98,140.03 232.86,139.91 232.44,139.91 232.31,140.03 231.99,140.03 226.31,145.72 213.62,145.72 v2(213.62,145.72) 213.61,145.72 207.16,145.72 203.93,148.94 203.93,149.22 203.62,149.53 203.4,149.53 202.99,149.13 C7.1
PEG_PTX_C_GRX_P13: length 44.6
  BOTTOM w0.104: C5.1 200.25,150.45 201.14,151.34 201.14,151.97 201.74,152.58 202.31,152.58 204.29,150.6 204.29,150.12 207.7,146.7 v2(217.47,146.7) 226.59,146.7 232.49,140.79 235.03,140.79 235.23,140.6 236.14,140.6 236.38,140.83 236.72,140.83 236.74,140.85 236.75,140.85 237.07,141.17 G2.BK41
PEG_PTX_C_GRX_P14: length 44.7
  BOTTOM w0.104: C3.1 197.89,152.28 198.63,152.28 198.96,152.6 200.5,152.6 201.86,153.97 203.29,153.97 205.07,152.18 205.07,151.71 209.05,147.73 v2(225.87,147.73) 226.8,147.73 233,141.53 235.07,141.53 235.2,141.4 235.65,141.4 G2.BM41
PEG_PTX_C_GRX_P15: length 45.9
  BOTTOM w0.104: G2.BL42 236.81,141.87 236.91,141.97 236.91,142.12 236.77,142.26 236.45,142.26 236.18,142.52 233.66,142.52 227.3,148.89 209.98,148.89 v2(209.97,148.89) 209.97,148.89 209.58,148.89 206.47,151.99 206.47,153.07 205.19,154.35 205.19,155.08 204.21,156.06 202.2,156.06 200.23,154.09 199.88,154.09 199.82,154.09 199.77,154.09 199.69,154.09 199.56,154.22 C1.1
PEG_PTX_GRX_N0: length 16.4
  BOTTOM w0.076: U1.B10 189.03,136.71 188.92,136.6 188.92,136.49 189.03,136.38 190.32,136.38 190.42,136.27 191.03,136.27 191.08,136.32 191.1,136.32
  BOTTOM w0.104: C32.2 201.82,132.92 199.63,132.92 199.2,132.49 v2(197.84,132.49) 196.49,132.49 195.55,133.43 195.55,134.68 194.18,136.05 192.4,136.05 192.13,136.32 191.1,136.32
PEG_PTX_GRX_N1: length 10.6
  BOTTOM w0.089: U1.B11 189.57,137.77 190.06,137.77 190.3,137.53 191.06,137.53 191.63,136.96 192.7,136.96 192.74,137.01 192.75,137.01
  BOTTOM w0.104: C30.2 198.37,134.93 196.72,134.93 194.64,137.01 192.75,137.01
PEG_PTX_GRX_N2: length 15
  BOTTOM w0.076: 191.1,138.39 191.1,138.39 190.82,138.66 190.37,138.66 190.27,138.56 189.43,138.56 189.3,138.43 U1.B12
  BOTTOM w0.104: 191.1,138.39 191.34,138.39 191.83,137.9 194.89,137.9 196.95,135.84 200.86,135.84 v2(201.06,135.64) 201.26,135.44 202.16,135.44 202.28,135.56 202.28,135.73 202.16,135.84 C28.2
PEG_PTX_GRX_N3: length 10.3
  BOTTOM w0.076: U1.B13 189.6,138.76 190.09,138.76 190.21,138.89 190.85,138.89 190.92,138.82 191.16,138.82 191.21,138.76 191.23,138.76
  BOTTOM w0.104: 191.23,138.76 191.61,138.76 191.85,138.52 195.43,138.52 197.22,136.73 v2(197.47,136.73) 198.52,136.73 C26.2
PEG_PTX_GRX_N4: length 14.5
  BOTTOM w0.076: U1.B14 189.04,139.86 188.97,139.78 188.97,139.65 189.08,139.54 190.18,139.54 190.3,139.42 191.45,139.42 191.63,139.6 191.93,139.6 191.97,139.65 191.99,139.65
  BOTTOM w0.104: C24.2 202.08,138.47 201.82,138.22 201.54,138.22 201.25,138.51 197.2,138.51 v2(196.63,139.08) 196.06,139.65 191.99,139.65
PEG_PTX_GRX_N5: length 9.9
  BOTTOM w0.104: U1.B15 189.62,140.97 190.5,140.97 190.65,140.82 190.81,140.67 196.84,140.67 v2(197.43,140.09) 197.6,139.91 198.25,139.91 198.26,139.91 198.27,139.91 C22.2
PEG_PTX_GRX_N6: length 14.6
  BOTTOM w0.076: U1.B16 189.18,141.32 189.03,141.32 188.93,141.42 188.93,141.72 189,141.79 189.57,141.79 189.69,141.91 190.13,141.91 190.22,142 190.93,142 191.58,141.34 192.3,141.34 192.35,141.4 192.37,141.4
  BOTTOM w0.104: 192.37,141.4 197.72,141.4 198.05,141.07 200.59,141.07 200.74,140.93 201.83,140.93 C20.2
PEG_PTX_GRX_N7: length 9.8
  BOTTOM w0.076: 190.88,142.58 190.86,142.58 190.8,142.52 190.41,142.52 190.23,142.7 189.7,142.7 189.45,142.45 189.45,142.37 U1.B17
  BOTTOM w0.104: 190.88,142.58 191.76,142.58 192.07,142.27 v2(197.2,142.27) 198.21,142.27 C18.2
PEG_PTX_GRX_N8: length 14.1
  BOTTOM w0.076: 193.14,143.13 193.12,143.13 193.06,143.08 191.18,143.08 190.75,143.51 189.62,143.51 189.39,143.29 188.93,143.29 U1.C18
  BOTTOM w0.104: 193.14,143.13 v2(196.11,143.13) 196.87,143.13 197.33,143.59 201.8,143.59 C16.2
PEG_PTX_GRX_N9: length 10.2
  BOTTOM w0.076: 191.1,143.74 191.08,143.74 191.03,143.79 190.38,143.79 190.26,143.92 190.02,143.92 189.95,143.84 U1.A19
  BOTTOM w0.104: 191.1,143.74 192.7,143.74 193.21,144.25 196.84,144.25 v2(197.35,144.76) 197.58,144.99 198.04,144.99 198.14,144.88 198.14,144.4 198.24,144.3 198.42,144.3 198.57,144.45 C14.2
PEG_PTX_GRX_N10: length 14.8
  BOTTOM w0.076: U1.C20 188.91,144.32 189.49,144.32 189.58,144.4 189.75,144.4 189.9,144.25 190.42,144.25 190.52,144.15 190.75,144.15 191.08,144.48 191.26,144.48 191.32,144.43 191.33,144.43
  BOTTOM w0.104: 191.33,144.43 191.89,144.43 192.63,145.16 196.16,145.16 197.53,146.54 v2(200.83,146.54) 201.72,146.54 C12.2
PEG_PTX_GRX_N11: length 10.6
  BOTTOM w0.104: C10.2 198.2,148.92 198.13,148.85 198.13,148.4 198.01,148.29 196.41,148.29 v2(195.92,147.81) 194.22,146.11 193.74,146.11 193.62,146.23 193.2,146.23 193.08,146.11 192.66,146.11 192.54,146.23 192.12,146.23 191.99,146.11 191.71,146.11 191.1,145.5 190.07,145.5 U1.A21
PEG_PTX_GRX_N12: length 15.1
  BOTTOM w0.104: C8.2 201.81,149.68 201.8,149.69 v2(201.01,149.69) 200.23,149.69 200.1,149.82 197.84,149.82 197.33,149.3 195.87,149.3 193.5,146.94 191.53,146.94 191.18,146.59 190.47,146.59 190.34,146.46 188.95,146.46 U1.C22
PEG_PTX_GRX_N13: length 11.2
  BOTTOM w0.104: C6.2 198.24,151.06 197.83,151.06 197.09,150.32 v2(196.06,150.32) 195.65,150.32 192.99,147.66 191.3,147.66 190.88,147.23 190.05,147.23 189.92,147.36 189.75,147.36 189.64,147.24 189.64,147.06 189.75,146.94 U1.A23
PEG_PTX_GRX_N14: length 11.1
  BOTTOM w0.076: 190.88,148.37 190.86,148.37 190.8,148.31 190.24,148.31 190.11,148.19 189.06,148.19 188.84,147.97 188.84,147.83 188.74,147.73 U1.C24
  BOTTOM w0.104: C4.2 196.67,152.76 196.47,152.56 195.22,152.56 194.25,151.59 194.25,150.18 192.44,148.37 190.88,148.37
PEG_PTX_GRX_N15: length 12.8
  BOTTOM w0.076: U1.A25 189.95,148.51 189.85,148.41 189.67,148.41 189.6,148.48 189.6,148.69 189.75,148.84 191.08,148.84 191.25,149.01 191.32,149.01 191.34,149.02
  BOTTOM w0.104: 191.34,149.02 191.41,149.09 191.6,149.28 192.46,149.28 193.62,150.44 193.62,151.94 195.58,153.9 v2(197.48,153.9) 198.37,153.9 C2.2
PEG_PTX_GRX_P0: length 16.4
  BOTTOM w0.076: 191.1,136.06 191.08,136.06 191.03,136.12 190.36,136.12 190.25,136.22 188.97,136.22 188.77,136.43 188.77,136.59 U1.C10
  BOTTOM w0.104: 191.1,136.06 192.03,136.06 192.3,135.79 194.08,135.79 195.29,134.58 195.29,133.32 196.38,132.23 199.3,132.23 199.74,132.67 v2(200.72,132.67) 201.7,132.67 C31.2
PEG_PTX_GRX_P1: length 10.7
  BOTTOM w0.089: U1.A11 189.91,137.53 189.79,137.53 189.71,137.45 189.71,137.31 189.82,137.21 190.08,137.21 190.24,137.37 190.99,137.37 191.56,136.8 192.7,136.8 192.74,136.75 192.75,136.75
  BOTTOM w0.104: C29.2 198.04,134.67 v2(196.87,134.67) 196.61,134.67 194.53,136.75 192.75,136.75
PEG_PTX_GRX_P2: length 15
  BOTTOM w0.076: 191.1,138.13 190.98,138.13 190.72,137.87 190.34,137.87 190.21,138 188.93,138 U1.C12
  BOTTOM w0.104: C27.2 202.07,134.95 201.84,135.18 201.16,135.18 200.76,135.59 196.84,135.59 v2(196.46,135.97) 194.79,137.64 191.72,137.64 191.23,138.13 191.1,138.13
PEG_PTX_GRX_P3: length 10.3
  BOTTOM w0.076: 191.23,139.02 191.21,139.02 191.16,138.97 190.99,138.97 190.91,139.04 189.97,139.04 U1.A13
  BOTTOM w0.104: C25.2 198.34,137.8 198.14,137.8 198.06,137.72 198.06,137.09 197.96,136.99 197.33,136.99 v2(196.56,137.76) 195.53,138.78 191.96,138.78 191.72,139.02 191.23,139.02
PEG_PTX_GRX_P4: length 14.6
  BOTTOM w0.076: U1.C14 188.82,139.69 188.82,139.59 189.02,139.39 190.12,139.39 190.23,139.27 191.53,139.27 191.69,139.44 191.93,139.44 191.97,139.39 191.99,139.39
  BOTTOM w0.104: 191.99,139.39 195.95,139.39 197.09,138.26 v2(200.89,138.26) 201.14,138.26 201.44,137.96 201.71,137.96 202.05,137.62 C23.2
PEG_PTX_GRX_P5: length 9.9
  BOTTOM w0.104: U1.A15 189.83,140.65 189.74,140.55 189.74,140.43 189.85,140.31 190.03,140.31 190.36,140.64 190.47,140.64 190.7,140.41 v2(196.06,140.41) 196.74,140.41 197.5,139.65 198.15,139.65 198.52,139.28 C21.2
PEG_PTX_GRX_P6: length 14.7
  BOTTOM w0.076: U1.C16 188.93,141.15 189.45,141.15 189.66,141.35 189.66,141.66 189.76,141.76 190.19,141.76 190.28,141.85 190.86,141.85 191.52,141.19 192.3,141.19 192.35,141.14 192.37,141.14
  BOTTOM w0.104: 192.37,141.14 197.62,141.14 197.95,140.81 200.49,140.81 200.63,140.67 v2(200.88,140.67) 201.7,140.67 C19.2
PEG_PTX_GRX_P7: length 9.8
  BOTTOM w0.076: 190.88,142.32 190.86,142.32 190.8,142.37 190.34,142.37 190.16,142.55 189.76,142.55 189.6,142.39 189.6,142.27 189.65,142.22 U1.A17
  BOTTOM w0.104: C17.2 198.2,142.01 191.96,142.01 191.65,142.32 190.88,142.32
PEG_PTX_GRX_P8: length 14.1
  BOTTOM w0.076: 193.14,142.88 193.13,142.88 193.07,142.93 191.12,142.93 190.68,143.36 189.76,143.36 189.62,143.22 189.62,142.86 189.5,142.74 189.37,142.74 189.3,142.82 U1.B18
  BOTTOM w0.104: 193.14,142.88 196.98,142.88 197.44,143.34 v2(200.88,143.34) 201.83,143.34 202,143.16 C15.2
PEG_PTX_GRX_P9: length 10.1
  BOTTOM w0.076: 191.1,144 191.08,144 191.03,143.95 190.44,143.95 190.32,144.07 189.81,144.07 189.53,143.79 U1.B19
  BOTTOM w0.104: 191.1,144 192.6,144 193.11,144.51 v2(196.06,144.51) 196.74,144.51 197.5,145.27 198.22,145.27 C13.2
PEG_PTX_GRX_P10: length 14.7
  BOTTOM w0.076: 191.33,144.68 191.31,144.68 191.25,144.63 191.08,144.63 190.76,144.95 190.41,144.95 190.31,144.85 189.46,144.85 189.37,144.95 189.15,144.95 189.04,144.84 189.04,144.66 189.12,144.58 U1.B20
  BOTTOM w0.104: C11.2 201.67,146.79 v2(199.55,146.79) 197.42,146.79 196.05,145.42 192.52,145.42 191.78,144.68 191.33,144.68
PEG_PTX_GRX_P11: length 10.6
  BOTTOM w0.104: C9.2 v2(197.58,148.03) 196.51,148.03 194.33,145.85 191.81,145.85 191.21,145.24 190.37,145.24 190.19,145.06 189.6,145.06 U1.B21
PEG_PTX_GRX_P12: length 15.1
  BOTTOM w0.104: U1.B22 189.24,146.1 189.24,145.85 189.34,145.75 190.85,145.75 191.78,146.68 193.61,146.68 195.98,149.05 v2(196.21,149.05) 197.43,149.05 197.94,149.56 199.99,149.56 200.12,149.43 201.9,149.43 202.08,149.25 C7.2
PEG_PTX_GRX_P13: length 11.2
  BOTTOM w0.076: 190.42,146.94 190.11,146.64 189.6,146.64 U1.B23
  BOTTOM w0.104: 190.42,146.94 190.95,146.94 191.41,147.4 193.09,147.4 195.76,150.06 197.2,150.06 v2(197.58,150.45) 197.93,150.8 198.17,150.8 C5.2
PEG_PTX_GRX_P14: length 11.1
  BOTTOM w0.076: U1.B24 189.3,147.71 189.22,147.64 189.07,147.64 189,147.71 189,147.91 189.12,148.03 190.18,148.03 190.3,148.16 190.8,148.16 190.86,148.11 190.88,148.11
  BOTTOM w0.104: 190.88,148.11 192.55,148.11 194.51,150.07 194.51,151.48 195.33,152.3 196.42,152.3 196.67,152.05 C3.2
PEG_PTX_GRX_P15: length 12.9
  BOTTOM w0.076: 191.16,149.2 191.14,149.19 191.14,149.11 191.02,148.99 189.68,148.99 189.44,148.75 189.44,148.55 189.41,148.52 U1.B25
  BOTTOM w0.104: 191.16,149.2 191.49,149.54 192.35,149.54 193.36,150.55 193.36,152.05 195.47,154.16 v2(195.99,154.16) 198.29,154.16 C1.2
PEG_RCOMP: length 5.5
  BOTTOM w0.305: U1.G2 185.95,131.41 185.95,130.68 188.07,128.55 188.82,128.55 R1.2
PLT_RST_N: length 524.7
  TOP w0.089: 31.97,80.72 R2099.1 31.49,79.84 R2096.1
  TOP w0.097: v2(62.96,89.23) 63.34,89.23 63.85,89.74 63.85,91.6 R2101.2 ; 31.97,80.72 31.64,81.05 v1(31.49,81.05) ; U63.1 303.89,71.31 304.39,70.82 304.39,67.39 298.68,61.68 298.68,60.02 299.05,59.64 v1(299.05,54.44) 299.05,54.31 298.67,53.93 298.67,50.46 298.6,50.39 298.6,49.53 296.65,47.58 v2(293.97,47.58) ; R458.2 v2(256.76,64.85) ; v2(246.48,44.53) 247.03,45.09 R117.2 248.89,45.09 249.09,45.29 252.32,45.29 v2(253.08,46.05) ; R274.1 v2(55.09,69.04)
  IN03 w0.091: v2(301.5,37.85) 299.72,37.85 297.81,39.75 297.81,40.51 296.8,41.53 294.89,41.53 294.44,41.99 294.44,47.11 v2(293.97,47.58) ; v2(94.58,76.15) 95.09,75.64 97.38,75.64 98.14,74.88 98.14,71.71 97.76,71.33 89,71.33 85.31,67.64 81.63,67.64 77.82,71.45 73.37,71.45 73.25,71.33 70.2,71.33 69.56,71.96 v2(69.06,71.96) 63.09,71.96 60.17,69.04 v2(55.09,69.04) ; v2(154.4,40.08) 153.77,40.72 153.77,41.1 146.91,47.96 119.99,47.96 107.67,35.64 v2(96.36,35.64) ; v2(256.76,64.85) 254.58,62.67 254.58,62.41 253.25,61.09 253.25,49.15 249.4,45.29 247.24,45.29 v2(246.48,44.53)
  IN05 w0.091: v2(293.97,47.58) 291.18,47.58 288.26,44.66 286.23,44.66 285.59,45.29 283.31,45.29 282.16,44.15 279.62,44.15 277.21,46.56 275.3,46.56 273.13,48.74 267.28,48.74 265.62,50.41 265.62,54.78 266.56,55.72 266.56,58.94 266.12,59.38 265.18,59.38 264.97,59.59 261.82,59.59 257.77,55.54 257.77,50.62 256.25,49.1 256.25,48.21 254.35,46.31 253.33,46.31 v2(253.08,46.05) ; v2(51.15,57.23) 50.62,56.7 41.27,56.7 39.47,58.5 34.26,58.5 33.62,59.13 33.62,59.77 32.86,60.53 32.73,60.53 v2(32.48,60.79)
  IN08 w0.091: v2(69.06,71.96) 67.79,71.96 66.52,73.23 66.52,75.52 63.39,78.65 63.39,87.16 62.45,88.09 62.45,88.73 v2(62.96,89.23) ; v2(47.97,43.01) 48.86,43.89 48.86,47.7 48.23,48.34 48.23,53.04 48.36,53.17 48.36,57.36 49.12,58.12 50.77,58.12 51.15,57.74 v2(51.15,57.23)
  IN10 w0.089: 31.16,80.72 31.11,80.67 31.11,77.8 30.09,76.79 27.22,76.79 26.97,77.04
  IN10 w0.091: v2(94.58,76.15) 94.58,73.49 93.57,72.47 93.57,67.52 92.3,66.25 92.3,58.88 91.92,58.5 91.92,44.15 96.36,39.7 v2(96.36,35.64) ; v2(246.48,44.53) 246.48,43.39 244.95,41.86 216,41.86 212.45,45.4 206.56,45.4 203.4,42.24 156.56,42.24 v2(154.4,40.08) ; v2(32.48,60.79) 31.97,60.79 25.75,67.01 25.75,69.93 26.26,70.44 26.26,72.47 25.75,72.98 25.75,76.41 26.38,77.04 26.97,77.04 ; v2(51.15,57.23) 51.53,57.61 51.53,67.01 53.56,69.04 v2(55.09,69.04) ; 31.16,80.72 v1(31.49,81.05)
  BOTTOM w0.097: R123.2 246.78,44.22 v2(246.48,44.53) 246.69,44.74 U4.4 ; R840.2 v2(47.97,43.01) ; v2(94.58,76.15) 95.55,75.19 R483.2 ; v2(32.48,60.79) 32.66,60.61 32.71,60.61 32.99,60.33 R478.2 R237.1 ; v2(301.5,37.85) 301.23,37.58 JIO1.17
PM_BATLOW_N: length 4.1
  BOTTOM w0.097: U2.BD13 242.36,51.67 242.23,51.53 242.23,50.44 242.03,50.24 242.03,49.61 v1(241.72,49.3) 241.01,48.59 R139.2
PM_PCH_PWROK: length 254.8
  TOP w0.097: R147.2 244.32,53.8 v3(243.81,53.29)
  IN03 w0.091: v2(150.97,40.08) 150.97,41.95 146.71,46.21 119.55,46.21 107.34,34.01 96.26,34.01 95.6,33.35 87.9,33.35 85.99,31.44 74.01,31.44 71.22,34.24 64.23,34.24 63.6,34.88 48.23,34.88 46.37,36.73 v2(46.37,36.96)
  IN05 w0.091: v2(46.37,36.96) 45.79,37.54 44.55,37.54 43.61,36.6 40.81,36.6 39.42,35.21 29.73,35.21 25.33,39.61 25.33,46.15 25.62,46.43 25.62,46.82 v2(26.13,47.32)
  IN10 w0.091: v2(150.97,40.08) 150.97,40.34 154.27,43.64 202.53,43.64 206.09,47.2 214.09,47.2 216.5,44.78 224.94,44.78 225.45,44.28 235.81,44.28 237.84,46.31 237.84,46.94 238.83,47.93 239.34,47.93 239.62,48.21 240.27,48.21 241.14,49.08 241.14,49.99 241.27,50.12 241.27,51.13 241.9,51.77 243.05,51.77 243.81,52.53 v3(243.81,53.29)
  BOTTOM w0.097: U2.AW11 243.81,53.49 v3(243.81,53.29) ; v2(26.13,47.32) 26.38,47.32 27.02,46.69 R262.2
PM_PCH_PWROK_R: length 6.7
  BOTTOM w0.097: R262.1 28.49,47.2 28.8,47.2 29.43,47.83 29.43,47.98 29.56,48.11 30.14,48.11 v1(30.35,48.32) 30.58,48.54 30.58,49.48 32,50.91 U5.C1
PM_RSMRST_N: length 256.1
  TOP w0.097: R149.2 243.25,54.87 v3(243.68,54.44)
  IN05 w0.089: 37.73,56.59 37.6,56.47 33.62,56.47 32.43,57.66 32.43,58.63
  IN05 w0.091: v2(118.21,35.51) 118.21,36.2 116.96,37.45 113.5,37.45 111.07,35.03 100.63,35.03 97.27,38.38 96.62,39.04 96.62,39.86 92.2,44.28 83.79,44.28 82.9,43.39 74.34,43.39 73.02,44.7 67.99,44.7 66.7,46 59.95,46 55.78,50.16 53.46,50.16 53.04,50.59 51.19,50.59 50.13,51.64 49.75,51.64 46.45,54.94 41.75,54.94 40.98,55.72 39.85,55.72 38.72,56.85 37.98,56.85 37.73,56.59 ; v2(31.19,59.13) 31.19,59.56 31.28,59.65 32.09,59.65 32.43,59.31 32.43,58.63
  IN08 w0.091: v2(118.21,35.51) 119.6,36.91 119.6,40.32 122.74,43.46 142.26,43.46 143.99,41.74 v2(143.99,38.81)
  IN10 w0.091: v3(243.68,54.44) 242.92,54.44 242.35,53.86 242.35,52.85 241.01,51.51 241.01,50.5 240.76,50.24 240.76,48.97 240.25,48.47 239.36,48.47 239.03,48.14 237.89,48.14 234.47,44.71 225.65,44.71 225.1,45.26 216.79,45.26 214.22,47.83 205.71,47.83 202.26,44.38 153.49,44.38 150.12,41.01 150.12,39.83 149.1,38.81 v2(143.99,38.81)
  BOTTOM w0.097: v2(31.19,59.13) 31.27,59.13 32.8,57.61 32.99,57.61 33.27,57.33 U5.N3 ; U2.BA11 243.27,53.5 242.92,53.85 242.92,54.18 243.1,54.36 243.61,54.36 v3(243.68,54.44) 243.68,54.53 243.43,54.79 U2.AV11
POST_I2C_CLK: length 29.1
  TOP w0.097: U7.12 284.65,31.81 283.28,31.81 v2(282.8,31.32) ; R321.2 R319.2 v2(267.18,27.77) 267.18,28.91 267.72,29.45 U8.17
  IN10 w0.091: v2(282.8,31.32) 282.16,31.32 281.27,30.43 281.27,25.61 279.98,24.31 272.03,24.31 270.99,25.35 269.59,25.35 v2(267.18,27.77)
POST_I2C_DATA: length 28.9
  TOP w0.097: R320.2 R318.2 v2(267.18,29.54) 267.59,29.95 U8.16 ; U7.11 284.07,32.21 284.07,32.21 283.81,32.21 283.69,32.08 283.18,32.08 v2(282.8,32.46)
  IN10 w0.091: v2(267.18,29.54) 270.99,25.73 271.37,25.73 272.41,24.69 276.91,24.69 277.93,25.7 279.83,25.7 280.06,25.48 280.51,25.48 281.02,25.99 281.02,30.69 v2(282.8,32.46)
POST_I2S_BCLK: length 25.2
  TOP w0.097: v2(269.97,24.79) 269.97,25.86 269.38,26.45 U8.23 ; v2(280.51,37.67) 280.51,37.67 R298.1
  IN03 w0.091: v2(280.51,37.67) 277.34,34.5 277.34,26.24 275.43,24.34 270.43,24.34 v2(269.97,24.79)
  BOTTOM w0.097: C336.1 v2(280.51,37.67)
POST_I2S_IN: length 32
  TOP w0.097: R322.1 265.58,24.16 265.99,23.75 v2(268.48,23.75)
  TOP w0.203: v2(283.48,34.75) 283.67,34.75 283.81,34.61 284.65,34.61 U7.5
  IN10 w0.091: v2(283.48,34.75) 284.07,34.16 284.07,30.94 283.94,30.81 282.42,30.81 281.53,29.92 281.53,25.48 280,23.96 268.68,23.96 v2(268.48,23.75)
  BOTTOM w0.254: v2(283.48,34.75) 283.49,34.75 C333.1
POST_I2S_LRCLK: length 17.2
  TOP w0.097: v2(278.1,24.74) 276.89,25.95 U8.25 ; R301.1 280.51,36.78 v2(280.51,36.78)
  IN03 w0.091: v2(280.51,36.78) 277.59,33.86 277.59,25.25 v2(278.1,24.74)
  BOTTOM w0.097: v2(280.51,36.78) C335.1
POST_I2S_MCLK: length 25.7
  TOP w0.097: v2(280.51,38.56) 280.51,38.56 R296.1 ; U8.22 269.51,26.95 270.73,25.73 v2(270.73,24.79)
  IN03 w0.091: v2(280.51,38.56) 276.96,35 276.96,26.24 275.51,24.79 v2(270.73,24.79)
  BOTTOM w0.097: C337.1 v2(280.51,38.56)
POST_I2S_OUT: length 26.6
  TOP w0.097: v2(280.51,35.89) 280.51,35.89 R302.1 ; U8.24 268.99,25.95 269.21,25.73 v2(269.21,24.79)
  IN03 w0.091: v2(280.51,35.89) 280,35.39 280,31.96 280.51,31.45 280.51,29.42 279.11,28.02 279.11,26.69 279.62,26.18 279.62,24.61 278.97,23.96 270.05,23.96 v2(269.21,24.79)
  BOTTOM w0.097: C334.1 v2(280.51,35.89)
PROC_SELECT_N: length 5.4
  BOTTOM w0.097: R21.2 148.54,127.97 151.33,130.76 U1.BN1
PS1_NVVDD_EN: length 2.4
  BOTTOM w0.097: PR30.1 300.2,198.6 PU5.10
PSYS: length 308.9
  TOP w0.097: PU1101.29 130.12,190 130.8,189.31 v2(130.98,189.31) PR1192.1 ; v3(79.47,5.29) 79.09,5.67 79.09,6.35 PR226.1 PR216.1
  IN03 w0.089: 41.5,52.02 40.23,52.02 v1(39.72,51.51)
  IN03 w0.091: 41.5,52.02 41.88,52.02 42.39,52.53 48.99,52.53 51.28,50.24 55.08,50.24 56.23,51.39 58.39,51.39 63.72,56.72 71.72,56.72 v2(72.23,57.23)
  IN08 w0.089: v1(39.72,51.51) 39.72,51.9 40.35,52.53 40.35,53.93 40.86,54.44 40.86,58.63
  IN08 w0.091: 40.86,58.63 40.86,61.42 39.72,62.56 39.72,66.75 41.37,68.41 41.37,69.29 41.12,69.55 41.12,75.52 43.78,78.18 44.29,78.18 44.55,78.44 59.15,78.44 63.85,73.74 v2(63.85,72.47) ; v3(79.47,5.29) 80.11,5.92 80.11,7.06 80.87,7.83 80.87,16.08 78.7,18.25 78.7,29.92 79.61,30.82 79.61,33.11 71.63,41.09 71.63,43.94 71.88,44.2 71.88,45.85 72.75,46.71 72.75,56.72 v2(72.23,57.23)
  IN10 w0.091: v2(130.98,189.31) 129.51,187.84 129.51,184.36 128.49,183.34 127.98,183.34 125.57,180.93 119.59,180.93 112.73,174.07 112.73,133.92 109.06,130.25 109.06,120.09 99.79,110.82 97,110.82 86.71,100.54 86.71,94.19 80.36,87.84 80.36,82.5 76.55,78.69 75.66,78.69 70.07,73.1 66.39,73.1 65.75,72.47 v2(63.85,72.47)
  BOTTOM w0.076: U5.F12 37.78,52.41 38.04,52.16 38.58,52.16
  BOTTOM w0.097: v1(39.72,51.51) 39.47,51.51 38.82,52.16 38.58,52.16
PUMP_ON: length 264.7
  TOP w0.097: v2(265.43,22.73) 265.18,22.48 PR3594.1
  IN03 w0.091: v2(73.15,42.29) 73.66,41.78 74.14,41.78 75.21,40.72 82.9,40.72 83.43,41.25 98.12,41.25 100.21,39.16 107.36,39.16 118.87,50.67 151.69,50.67 159.35,43.01 209.52,43.01 214.1,38.43 257.14,38.43 260.19,41.48 262.48,41.48 265.58,38.38 265.58,25.98 265.05,25.45 265.05,23.11 v2(265.43,22.73) ; v2(56.13,48.26) 55.69,48.7 46.34,48.7 46.11,48.47 44.88,48.47 44.58,48.77 44.09,48.77 v2(43.63,49.23)
  IN05 w0.091: v2(73.15,42.29) 72.69,42.75 69.56,42.75 68.81,43.51 67.54,43.51 65.88,45.16 58.06,45.16 56.13,47.09 v2(56.13,48.26)
  BOTTOM w0.089: v1(40.53,48.85) 41.07,48.85 R2348.2 41.45,48.85 41.5,48.8
  BOTTOM w0.097: v2(43.63,49.23) 43.63,49.2 43.07,48.64 41.66,48.64 41.5,48.8 ; U5.D13 38.61,51.41 40.38,49.64 40.38,49 v1(40.53,48.85)
PUMP_VCC:
  vias: v2(288.16,21.97) v2(289.05,21.97)
PWM1_VCC: length 43.9
  TOP w0.203: 130.45,192 130.44,192 PU1101.34
  TOP w0.254: 130.45,192 v2(132.89,192)
  IN05 w0.254: v2(167.1,193.12) 167.1,192.99 164.94,190.83 154.02,190.83 153.64,190.45 135.27,190.45 134.77,189.94 133.62,189.94 133.37,190.2 133.37,190.83 132.99,191.21 132.99,191.9 v2(132.89,192)
  BOTTOM w0.254: v2(167.1,193.12) 167.05,193.07 167.05,190.73 PR1599.2
PWM1A_ICCMAX: length 107.6
  TOP w0.203: PU1101.30 130.2,190.4
  TOP w0.254: 130.65,190.07 130.52,190.07 130.2,190.4
  TOP w0.381: 130.65,190.07 130.78,189.94 133.32,189.94 v2(133.95,190.58)
  IN03 w0.254: v2(211.55,191.72) 212.06,191.72 212.57,192.23 212.57,197.77 211.81,198.53 208.03,198.53 207.06,197.56 200.25,197.56 199.36,196.68 197.83,196.68 195.29,194.14 192.25,194.14 191.61,194.77 189.96,194.77 189.33,194.14 185.77,194.14 185.52,193.88 171.04,193.88 169.26,195.66 166.51,195.66 164.56,193.71 164.56,192.87 162.66,190.96 154.27,190.96 153.82,191.42 141.37,191.42 141.19,191.6 134.97,191.6 v2(133.95,190.58)
  BOTTOM w0.254: PR1193.1 130.14,190.58 130.75,189.97 133.34,189.97 v2(133.95,190.58)
  BOTTOM w0.356: v2(211.55,191.72) 211.55,190.58 212.47,189.67 212.47,188.07 211.93,187.53 211.07,187.53 210.69,187.15 PR1632.2
PWM2_VCC: length 53
  TOP w0.203: PU1101.33 130.27,191.6
  TOP w0.254: v2(134.26,191.98) 133.62,191.34 131.92,191.34 131.67,191.6 130.27,191.6
  IN05 w0.254: v2(134.26,191.98) 134.33,191.98 134.46,192.1 153.13,192.1 153.64,192.61 164.15,192.61 165.83,194.29 165.83,195.02 166.34,195.53 170.02,195.53 171.42,194.14 173.45,194.14 v2(177.26,190.33)
  BOTTOM w0.254: PR1622.2 177.13,190.2 v2(177.26,190.33)
PWM3_VCC: length 77.2
  TOP w0.203: PU1101.32 130.52,191.2
  TOP w0.254: 130.52,191.2 131.31,191.2 131.92,190.58 v2(132.68,190.58)
  IN03 w0.254: v2(200.37,187.4) 198.98,187.4 195.42,190.96 195.42,191.72 194.53,192.61 190.21,192.61 189.07,193.75 186.4,193.75 185.25,192.6 165.96,192.6 163.94,190.58 154.02,190.58 153.69,190.91 135.5,190.91 134.54,189.94 133.32,189.94 v2(132.68,190.58)
  BOTTOM w0.356: PR1623.2 200.12,187.15 v2(200.37,187.4)
PWM4_VCC: length 63.2
  TOP w0.203: PU1101.31 130.44,190.8
  TOP w0.254: v2(131.13,190.55) 130.89,190.8 130.44,190.8
  IN03 w0.254: v2(131.13,190.55) 133.06,188.62 134.28,188.62 136.06,190.4 151.66,190.4 152.75,189.31 163.52,189.31 166.34,192.13 184.22,192.13 185.39,190.96 187.52,190.96 v2(188.06,190.43)
  BOTTOM w0.254: PR1629.2 v2(188.06,190.43)
PWR_LED_W: length 322.7
  IN05 w0.089: 41.5,57.99 41.12,58.37 41.12,58.63
  IN05 w0.091: v2(34.39,61.04) 34.77,61.04 36.04,59.77 36.67,59.77 37.81,60.91 39.59,60.91 41.12,59.39 41.12,58.63 ; v2(302.89,24.03) 302.44,23.57 300.4,23.57 299.93,24.05 299.93,35.15 296.59,38.48 296.14,38.48 293.34,41.28 287.81,41.28 287.09,41.99 278.71,41.99 276.93,43.77 275.33,43.77 273.55,41.99 270.2,41.99 267.41,44.78 264.13,44.78 263.61,44.27 258.61,44.27 257.88,43.54 256.61,43.54 v2(256.21,43.13) ; 41.5,57.99 41.81,57.68 45.38,57.68 46.5,58.8 52.11,58.8 53.05,57.86 53.05,55.2 55.21,53.04 55.6,53.04 61.54,47.09 72.46,47.09 72.82,46.74 89.4,46.74 90.25,45.88 94.25,45.88 98.14,41.99 98.14,39.93 101.97,36.1 110.53,36.1 113.35,38.92 v2(114.52,38.92)
  IN08 w0.091: v2(114.52,38.92) 114.14,39.3 114.14,42.15 119.37,47.38 168.82,47.38 170.71,45.49 190.21,45.49 192.99,42.72 199.83,42.72 202.66,45.55 212.79,45.55 215.83,42.5 222.78,42.5 223.77,43.49 235.2,43.49 235.81,42.88 254.83,42.88 255.01,42.7 255.78,42.7 256.21,43.13 v2(256.21,43.13)
  BOTTOM w0.076: U5.M5 34.27,55.42 34.53,55.67 34.53,56.21
  BOTTOM w0.097: v2(34.39,61.04) 33.96,60.61 33.96,58.55 34.53,57.98 34.53,56.21 ; JIO1.52 302.45,23.58 v2(302.89,24.03)
PWR_LEVEL: length 285.3
  TOP w0.097: D2011.1 238.5,116.92 v3(238.35,117.07)
  IN03 w0.091: v2(26,57.48) v1(26.64,58.12) 27.27,58.12 32.1,62.94 44.67,62.94 45.05,63.33 49.12,63.33 49.63,62.82 51.15,62.82 51.78,62.18 55.59,62.18 59.81,66.39 66.02,66.39 v2(66.14,66.28)
  IN05 w0.091: v2(66.14,66.28) 67.41,65.01 67.41,64.21 67.74,63.88 68.88,63.88 71.85,60.91 71.85,59.9 72.61,59.13 74.14,59.13 74.99,59.99 91.58,59.99 93.52,61.93 93.52,63.17 96.14,65.8 96.14,67.55 100.3,71.71 100.97,71.71 103.64,74.37 104.67,74.37 105.3,75.01 108.43,75.01 109.66,76.24 123.77,76.24 127.96,80.44 127.96,86.67 129.25,87.96 133.06,87.96 133.7,88.6 133.7,90.63 135.35,92.28 135.35,93.42 138.4,96.47 204.24,96.47 204.75,96.98 210.28,96.98 213.33,93.93 213.33,93.17 213.66,92.84 216.58,92.84 218.33,91.09 237.69,91.09 238.09,91.5 238.09,104.54 239.11,105.56 239.11,108.03 239.74,108.66 239.74,112.87 239.99,113.11 240.51,113.11 240.89,113.49 240.89,116.54 240.43,116.99 238.43,116.99 v3(238.35,117.07)
  BOTTOM w0.089: U5.N1 32.27,56.93 31.08,58.12 29.81,58.12
  BOTTOM w0.097: 29.81,58.12 29.18,58.12 28.67,58.63 R255.1 28.11,58.12 v1(26.64,58.12) v2(26,57.48)
PWR_LEVEL_R: length 257.1
  TOP w0.097: v2(73.63,60.02) 73.12,59.52 71.22,59.52 70.45,58.75 70.45,56.21 v2(70.96,55.71) ; R983.1 252.19,112.6 251.58,113.21 250.99,113.21 250.89,113.11 248.76,113.11 248.51,113.36 245.97,113.36 245.41,113.92 243.64,113.92 243.43,114.13 241.49,114.13 240.77,114.85 240.77,114.87 240.37,115.27 240.23,115.27 240.01,115.49 240.01,115.81 240.39,116.19 v3(240.39,116.27) 239.73,116.92 D2011.2
  IN03 w0.091: v2(70.96,55.71) 63.8,55.71 58.59,50.5 56.48,50.5 55.47,49.48 v2(45.56,49.48)
  IN05 w0.091: v2(73.63,60.02) 74.03,60.43 91.3,60.43 93.09,62.21 93.09,63.39 95.67,65.98 95.67,67.8 100.09,72.22 100.76,72.22 104.33,75.79 108.41,75.79 109.37,76.75 123.61,76.75 127.46,80.6 127.46,86.88 129.04,88.47 132.85,88.47 133.19,88.81 133.19,90.84 134.84,92.49 134.84,93.64 138.19,96.98 200.6,96.98 201.87,98.25 207.66,98.25 208.15,98.73 208.15,99.29 211.17,102.31 217.39,102.31 219.76,104.68 232.71,104.68 233.57,105.54 233.57,107.11 236.22,109.77 236.22,111.08 236.56,111.42 237.42,111.42 238.22,112.22 238.47,112.22 238.86,112.6 238.86,114.76 239.49,115.4 239.49,115.78 239.24,116.03 239.24,116.28 239.62,116.67 239.99,116.67 v3(240.39,116.27)
  BOTTOM w0.097: D2016.2 v2(45.56,49.48) ; G2.BE6 v3(240.39,116.27)
PWR_SRC_CRTCAL_N: length 6.4
  BOTTOM w0.097: PU5.9 300.43,197.95 300.17,197.69 v1(300.17,195.28) 299.75,194.87 PR35.1 PR25.1 PR27.1
PWR_SRC_WARN_N: length 2.8
  BOTTOM w0.097: PU5.8 302.14,195.15 PR32.1 PR31.1
REGN: length 21
  TOP w0.254: 88.67,9.1 88.36,9.4 PU201.20 ; PR222.2 v2(82.95,4.02) ; PR223.2 v2(90.14,3.64)
  TOP w0.508: 88.67,9.1 v1(89.66,9.1) 89.95,9.1 90.14,9.29 PR214.2 91.92,9.29 PC215.1 91.98,8.4 v2(91.79,8.21)
  IN03 w0.254: v2(82.95,4.02) 83.71,4.78 86.58,4.78 87.22,4.14 89.63,4.14 v2(90.14,3.64) 91.79,5.29 v2(91.79,8.21)
REMOTE1_N: length 136.4
  BOTTOM w0.254: U25.3 206.09,115.64 206.04,115.69 C634.1 206.04,117.12 205.84,117.33 v1(205.78,117.33) 204.97,117.33 202.91,115.27 199.74,115.27 197.33,112.86 133.95,112.86 129.51,117.3 129.51,129.87 134.46,134.83 138.65,134.83 140.56,136.73 140.56,145.75 142.46,147.65 142.46,157.31 143.22,158.07 143.22,160.02 143.55,160.35 C635.2 143.55,161.75 Q10.3
REMOTE1_P: length 140.2
  BOTTOM w0.254: U25.2 205.59,115.39 205.12,115.85 C634.2 204.57,116.28 203.04,114.76 199.87,114.76 197.45,112.35 133.7,112.35 129.13,116.92 129.13,130.13 134.21,135.21 138.4,135.21 140.18,136.99 140.18,146 142.08,147.91 142.08,157.56 142.82,158.3 142.82,160.23 142.64,160.4 C635.1 142.64,161.45 141.89,162.19 Q10.1 141.32,163.21 v1(141.32,163.83) 143.25,163.83 Q10.2
REMOTE2_N: length 9
  TOP w0.254: Q24.3 206.77,120.63 C638.2 207.28,120.42 207.61,120.09 v1(207.61,118.57) 207.19,118.14 v2(207.11,118.14)
  BOTTOM w0.254: U25.5 207.09,114.84 207.94,115.7 C636.1 207.94,117.56 207.36,118.14 v2(207.11,118.14)
REMOTE2_P: length 9
  TOP w0.254: v2(207.11,117.43) 206.98,117.43 v1(206.6,117.81) 206.6,118.7 206.98,119.08 C638.1 206.11,119.51 Q24.2 204.98,119.33 Q24.1
  BOTTOM w0.254: U25.4 206.59,114.92 206.59,114.93 206.59,115.09 207.03,115.52 C636.2 207.03,117.35 v2(207.11,117.43)
RF_KILL_BT_N: length 40.2
  TOP w0.097: R484.2 v2(256.76,66.12)
  IN03 w0.091: v2(256.76,66.12) 256.38,66.12 256.11,65.85 256.11,65.59 252.95,62.44 252.95,62.06 252.32,61.42 252.32,49.1 v3(251.56,48.34)
  IN05 w0.091: v3(251.56,48.34) 251.56,48.85 249.27,51.13 245.04,51.13 244.29,50.37 240.38,50.37 239.62,51.13 238.47,51.13 237.08,52.53 v3(237.08,53.04)
  BOTTOM w0.097: R102.1 251.43,48.21 v3(251.56,48.34) ; U2.BC23 237.3,52.82 v3(237.08,53.04)
RF_KILL_WIFI_N: length 39.7
  TOP w0.097: R517.2 v2(256.76,67.39)
  IN03 w0.091: v2(256.76,67.39) 255.8,66.42 255.8,65.74 252.7,62.64 252.7,62.18 252.06,61.55 252.06,50.12 v2(250.29,48.34)
  IN05 w0.091: v3(236.82,51.13) 237.46,51.13 239.11,49.48 244.57,49.48 245.33,50.24 248.94,50.24 250.29,48.9 v2(250.29,48.34)
  BOTTOM w0.097: U2.BD24 236.82,51.14 v3(236.82,51.13) ; R99.1 250.54,48.09 v2(250.29,48.34)
ROM_CS: length 86.2
  TOP w0.097: v3(237.69,114.97) 237.69,114.28 237.84,114.13 237.84,112.6 238.35,112.09 238.86,112.09 239.87,111.08 241.8,111.08 242.92,109.96 242.92,106.73 243.3,106.34 243.3,105.29 242.71,104.7 242.71,103.28 242.84,103.16 242.84,102.36 v2(242.41,101.93)
  IN10 w0.091: v2(273.65,80.72) 273.65,80.22 273.22,79.78 259.37,79.78 258.94,79.35 251.09,79.35 249.33,81.11 241.65,81.11 240.06,82.69 238.73,84.03 238.73,98.12 242.41,101.81 v2(242.41,101.93)
  BOTTOM w0.097: R2168.2 280.26,84.23 280.26,81.23 v1(279.88,80.85) 278.86,79.84 274.54,79.84 v2(273.65,80.72) ; G2.BJ4 v3(237.69,114.97)
