# Allegro board NM-B311.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N18346842: length 2.1
  BOTTOM w0.254: PR902.2 257.4,201.88 256.91,201.4 PU901.30
N18346852: length 1.3
  BOTTOM w0.508: PR902.1 PC906.2
N18349561: length 1.1
  BOTTOM w0.254: PT1001.1 219.54,201.74 PU1001.28
N18349775: length 4.1
  BOTTOM w0.254: PU1001.29 219.94,201.5 219.96,201.53 219.96,202.17 PC1006.1 219.14,202.17 PU1001.27
N18349779: length 2.1
  BOTTOM w0.254: PR1001.2 220.82,201.88 220.34,201.4 PU1001.30
N18349781: length 1.3
  BOTTOM w0.508: PC1006.2 PR1001.1
N18350194: length 4.1
  BOTTOM w0.254: PU1002.27 231.33,202.17 PC1007.1 232.15,202.17 232.15,201.53 232.13,201.5 PU1002.29
N18350200: length 2.1
  BOTTOM w0.254: PU1002.30 232.53,201.4 233.01,201.88 PR1008.2
N18421582: length 1.3
  BOTTOM w0.508: PC1007.2 PR1008.1
N19686618: length 1
  BOTTOM w0.457: C175.1 164.54,58.93 R96.2
N19687681: length 1.1
  BOTTOM w0.457: C172.1 161,94.52 R92.2
N20070704: length 4.7
  BOTTOM w0.254: PC972.2 257.31,196.69 PU901.7
  BOTTOM w0.508: PC972.2 258.34,195.18 258.56,194.96 259.37,194.96 260.13,194.2 PR904.1
N20070817: length 1.6
  BOTTOM w0.254: PR909.1 259.2,199.72 258.51,199.03 PU901.3
N20070821: length 2.6
  BOTTOM w0.254: PR910.2 258.54,202.39 257.31,201.16 PU901.31
N20070823: length 2.2
  BOTTOM w0.254: PU901.2 258.35,199.43 258.59,199.67 258.59,200.28 258.97,200.66 PR906.2
N20071127: length 1.3
  BOTTOM w0.254: PR908.1 259.03,198.63 PU901.4
N20073306: length 1.1
  BOTTOM w0.254: PTP901.1 256.11,201.74 PU901.28
N20073337: length 0.8
  BOTTOM w0.356: PTP902.1 257.4,195.79 256.89,196.29
N20074453: length 0.9
  BOTTOM w0.356: PTP904.1 269.59,195.79 269.06,196.32
N20074727: length 2
  BOTTOM w0.254: PR919.2 269.46,201.76 269.1,201.4 PU902.30
N20074738: length 4.1
  BOTTOM w0.254: PU902.27 267.9,202.29 PC23.1 268.73,202.04 268.73,201.53 268.7,201.5 PU902.29
N20076374: length 0.8
  BOTTOM w0.356: 220.31,196.29 220.82,195.79 PTP905.1
N20077877: length 0.8
  BOTTOM w0.356: PTP906.1 233.01,195.79 232.51,196.29
N20137254: length 1
  BOTTOM w0.254: PR429.2 208.91,113.67 208.83,113.74 PC435.1
N20137290: length 1.3
  BOTTOM w0.508: PC428.1 213.38,112.32 PR418.2
N20137326: length 1
  BOTTOM w0.508: PR428.2 PC424.1
N20137941: length 2.5
  TOP w0.254: PR405.2 108.67,86.77 PC411.1 110.06,87.26 PU401.12
N20137996: length 1.3
  TOP w0.254: PU401.13 110.46,86.8 PR404.1
N20138007: length 4
  TOP w0.254: 109.35,87.38 109.66,87.69 PU401.11
  TOP w0.381: 109.35,87.38 107.95,87.38 107.65,87.07 PR407.1 107.11,86.24 PR406.1
N20153824: length 15.2
  TOP w0.254: 270.99,64.72 272.64,64.72 272.76,64.6 PU603.3 ; PQ904.5 269.72,49.36 270.22,48.85 274.16,48.85 274.8,49.48 PC230.2
  TOP w0.457: 270.99,64.72 269.84,64.72 268.36,63.24
  BOTTOM w0.508: v2(268.62,60.13) 269.4,60.9 PR608.2
  vias: v1(268.5,64.67)
N20153845: length 4.9
  TOP w0.254: PU603.9 273.26,60.54 273.65,60.15 273.78,60.15 v2(273.91,60.02)
  BOTTOM w0.457: v2(273.91,60.02) 273.73,60.2 PC666.1
  BOTTOM w0.508: PR608.1 271.56,60.2 PC666.1
N20154004: length 1.4
  BOTTOM w0.508: PR417.1 272.21,57.48 v2(272.18,57.51)
N20154042: length 2.6
  TOP w0.254: PR609.2 PR612.1 273.6,65.1 273.26,64.77 PU603.2
N20154060: length 1.6
  TOP w0.254: PU603.10 273.76,60.85 274.09,60.53 274.87,60.53 PC678.2
N20154066: length 2.9
  TOP w0.254: PR611.1 274.54,65.23 275.05,64.72 v1(275.05,64.26) 274.83,64.04 PU603.1
N20154076: length 0.9
  TOP w0.254: PC677.1 PR611.2
N20157139: length 2
  BOTTOM w0.508: PR1225.2 PC1271.1 135,147.45 v1(135.43,147.02)
N20157150: length 2.2
  BOTTOM w0.508: PC1275.1 128.19,150.37 PR1222.2 v1(126.97,149.5)
N20171191: length 1.3
  BOTTOM w0.508: PR1501.2 PC1510.2
N20171267: length 2.3
  BOTTOM w0.305: PU1501.30 164.02,189.48 164.21,189.67 164.21,190.77 PR1501.1
N20172372: length 1.2
  BOTTOM w0.508: PR1508.2 PC1530.2
N20172448: length 2.3
  BOTTOM w0.305: PR1508.1 175.33,190.62 174.82,190.11 PU1502.30
N20172556:
  vias: v1(173.83,184.31)
N20172566:
  vias: v1(168.24,184.99)
N20172586: length 4.6
  BOTTOM w0.305: PU1502.29 174.42,190.82 PC1530.1 173.62,190.68 PU1502.27
N20172640: length 8.3
  BOTTOM w0.203: PL1502.3 169.34,177.04 168.62,177.75 166.29,177.75 PR1511.1 v1(164.15,176.53)
N20172665: length 8.2
  BOTTOM w0.203: PL1502.2 169.34,178.84 168.62,178.13 166.16,178.13 PR1513.1 v1(164.15,179.23)
N20172725:
  vias: v1(151.79,180.97)
N20172742: length 7.5
  BOTTOM w0.203: PL1501.3 156.11,177.47 155.83,177.75 153.59,177.75 152.37,176.53 PR1505.1 151.26,175.88 v1(151.26,175.59)
N20172758: length 9.7
  BOTTOM w0.203: PL1501.2 156.11,178.33 155.91,178.13 153.46,178.13 152.37,179.23 PR1504.1 v1(151,179.23)
N20172788: length 4.6
  BOTTOM w0.305: PU1501.27 162.82,189.65 162.8,189.67 162.8,190.63 PC1510.1 163.72,190.59 163.72,189.77 163.62,189.67 PU1501.29
N20172887:
  vias: v1(151.31,184.38)
N20172906: length 2.8
  BOTTOM w0.508: PC1541.1 165.12,184.15 164.47,183.51 PR1514.2
N20233119: length 1.6
  TOP w0.254: PQ1401.3 108.68,66.37 PR1412.1
N20234305: length 1.3
  BOTTOM w0.097: PU1501.28 163.22,190.26 PT1501.1
N20234840: length 1.1
  BOTTOM w0.097: PU1502.28 174.02,190.06 PT1503.1
N21283256: length 3.6
  TOP w0.457: v3(242.67,58.63) 243.12,59.08 R226.2 243.81,59.26 244.06,59.01 R224.2
  BOTTOM w0.254: R223.2 v1(255.82,64.66)
  vias: v3(253.59,62.18)
N21871531:
  vias: v1(79.72,21.8)
N21871557: length 7.1
  TOP w0.508: R571.2 73.81,18.67 74.2,19.07 Q11.3 v1(76.52,19.07) 77.25,19.07 77.85,19.67 D38.1 78.61,19.64 D39.1
N21871764: length 2.4
  TOP w0.097: v1(75.66,21.92) 75.66,20.98 Q11.2
  TOP w0.508: Q11.2 76.07,20.58 R569.1
N22215424: length 2.1
  BOTTOM w0.097: Q7.6 74.05,98.5 R395.1 72.94,98.45 v1(72.87,98.38)
N22216469: length 1.1
  BOTTOM w0.097: Q7.3 76.85,97.5 R396.1
N22751697: length 2.7
  TOP w0.097: PU1304.4 20.86,18.07 20.7,18.24 20.7,19 v1(21.08,19.38) PR1306.1
N22751755:
  vias: v1(183.99,194.52)
N22751764: length 1.3
  BOTTOM w0.097: PU1306.8 184.15,196.55 PR1310.2
N22751770: length 1.3
  BOTTOM w0.097: PU1306.5 178.5,197.55 PR1314.2
N22751809: length 3.2
  BOTTOM w0.305: 179.04,196.55 PU1306.3
  BOTTOM w0.356: PR1309.1 177.29,195.15 178.48,196.35 PC1312.1 178.61,196.55 179.04,196.55
N22751813: length 3.5
  BOTTOM w0.097: PU1306.4 176.88,197.05 176.7,197.23 PR1312.2
N22751871: length 1.5
  BOTTOM w0.097: PU1307.2 194.79,194.39 194.53,194.14 PR1311.1
N22751880: length 2.5
  TOP w0.356: PC1313.2 196.62,194.34 197.12,194.34 v2(197.33,194.14) 197.5,194.31 PC1311.2
  BOTTOM w0.254: PU1307.5 197.07,194.39 v2(197.33,194.14)
N22752556: length 2.9
  BOTTOM w0.097: PR1302.1 60.37,44.4 60.42,44.45 v1(61.11,44.45) 61.11,43.44 60.89,43.22 PU1301.4
N22806469: length 4.5
  TOP w0.356: PR106.2 79.17,93.65 PR108.1 ; PQ101.2 80.62,93.42 80.85,93.2 80.85,93 80.62,92.77 PQ101.3 79.18,92.77 PR108.1 ; PR108.1 v1(79.17,91.88)
N22806481: length 4.7
  TOP w0.305: PR107.2 82.09,94.87 82.26,94.69 82.26,94.31 82.03,94.07 PQ101.6
  TOP w0.356: PR107.2 82.15,95.27 83.41,95.27 PR105.2
  TOP w0.381: PR105.2 v1(85.13,94.76)
N22806527:
  vias: v1(24.99,21.42)
N22807451:
  vias: v1(92.58,21.59)
N22864850: length 4.4
  TOP w0.097: v1(101.82,83.26) 101.82,83.82 PR409.2 102.79,84.79 103.09,84.79 103.35,85.04 PR433.2 103.28,85.32 PU402.2
N22864858: length 1.6
  TOP w0.097: PU402.4 104.58,85.46 PR426.2
N22864873: length 6.5
  TOP w0.097: PU402.5 104.58,88 105,87.58 105,85.5 PR430.2 105.45,85.04 106.03,85.04 106.27,84.81 v1(106.27,83.9)
N22875618: length 3.6
  TOP w0.254: PR1414.1 56.03,9.98 PQ1402.3 ; PR1414.1 PQ1402.2 ; PR1414.1 56.76,9.25 v1(56.76,8.56)
N23003437: length 4
  TOP w0.381: PR610.2 PC676.1 275.41,39.55 274.95,40.01 273.96,40.01 PQ206.2
N23054269: length 1.8
  BOTTOM w0.254: PR506.2 266.62,48.95 PC515.1 v1(267.53,48.09)
N23054303: length 1.1
  TOP w0.457: PR504.2 PC514.1
N23054336: length 1.3
  TOP w0.508: PR502.2 266.41,50.69 PC504.1
N23056736: length 1.1
  TOP w0.254: PU1254.5 187.55,129.04 PC1259.1
N23057133: length 3.5
  TOP w0.254: PR1251.2 PC1251.1 205.66,153.57 206.09,154 206.6,154 206.84,154.25 PU1252.1
N23057736: length 1.3
  TOP w0.254: PU1252.5 205.15,155.71 PC1254.1
N23081959:
  vias: v1(189.17,181.18)
N23081971: length 8.3
  BOTTOM w0.203: PL1601.3 193.47,177.04 192.75,177.75 190.42,177.75 PR1605.1 v1(188.28,176.53)
N23081985: length 8.2
  BOTTOM w0.203: PL1601.2 193.47,178.84 192.75,178.13 190.29,178.13 PR1604.1 v1(188.28,179.23)
N23082001: length 4.4
  BOTTOM w0.305: PU1601.27 195.21,189.65 195.18,189.67 195.18,190.34 195.42,190.58 196.37,190.58 PC1608.1 196.44,190.2 196.01,189.77 PU1601.29
N23082126: length 1.3
  BOTTOM w0.508: PR1601.2 PC1608.2
N23082214: length 2.4
  BOTTOM w0.305: PR1601.1 197.71,190.07 197.45,189.82 196.82,189.82 196.41,189.41 PU1601.30
N23082223: length 1.3
  BOTTOM w0.508: PC1619.1 188.93,184.27 PR1607.2
N23083331:
  vias: v1(177.08,181.23)
N23083348: length 8.4
  BOTTOM w0.203: PL1602.3 181.4,177.04 180.69,177.75 178.35,177.75 PR1613.1 176.35,176.53 v1(176.22,176.66)
N23083362: length 8.2
  BOTTOM w0.203: v1(176.22,179.23) PR1612.1 178.23,178.13 180.69,178.13 181.4,178.84 PL1602.2
N23083378: length 4.6
  BOTTOM w0.305: PU1602.29 185.21,190.82 PC1627.1 184.39,190.66 184.39,189.67 184.41,189.65 PU1602.27
N23083503: length 1.3
  BOTTOM w0.508: PR1608.2 PC1627.2
N23083591: length 2.4
  BOTTOM w0.305: PU1602.30 185.61,189.41 185.71,189.5 185.71,190.71 PR1608.1
N23083597: length 1.6
  BOTTOM w0.508: PR1614.2 177.69,184.32 177.18,184.83 PC1638.1
N23089662:
  vias: v1(200.07,181.56)
N23089674: length 8.3
  BOTTOM w0.203: PL1603.3 204.39,177.04 203.68,177.75 201.34,177.75 PR1619.1 v1(199.21,176.53)
N23089690: length 8.2
  BOTTOM w0.203: PL1603.2 204.39,178.84 203.68,178.13 201.21,178.13 PR1618.1 v1(199.21,179.23)
N23089696: length 4.3
  BOTTOM w0.305: PU1603.27 206.13,189.65 206.11,189.67 206.11,190.21 206.47,190.58 207.3,190.58 PC1650.1 207.36,190.2 206.93,189.77 PU1603.29
N23089821: length 2.9
  BOTTOM w0.508: v1(210.03,191.34) 209.46,191.91 PR1615.2 PC1650.2
N23089907: length 2.4
  BOTTOM w0.305: PR1615.1 208.63,190.07 208.38,189.82 207.74,189.82 207.33,189.41 PU1603.30
N23163323: length 1.5
  BOTTOM w0.254: PR920.1 271.24,199.03 PU902.3
N23163349: length 4.6
  BOTTOM w0.254: 269.84,196.42 269.5,196.76 PU902.7
  BOTTOM w0.508: 269.84,196.42 270.53,195.74 PC973.2 270.53,195.1 271.05,194.58 PR918.1
N23163371: length 2.6
  BOTTOM w0.254: PR915.2 270.61,202.26 269.5,201.16 PU902.31
N23163373: length 1.7
  BOTTOM w0.254: PR922.2 271.49,200.23 270.7,199.43 PU902.2
N23163385: length 1.5
  BOTTOM w0.254: PR992.1 271.36,198.63 PU902.4
N23164129: length 1.6
  BOTTOM w0.254: PR1009.1 222.63,199.72 221.94,199.03 PU1001.3
N23164159: length 4.9
  BOTTOM w0.254: 221.08,196.42 220.74,196.76 PU1001.7
  BOTTOM w0.356: 221.08,196.42 221.08,196.35 PC1074.2
  BOTTOM w0.508: PR1053.1 223.87,194.14 223.17,194.83 222.03,194.83 221.76,195.1 PC1074.2
N23164181: length 2.6
  BOTTOM w0.254: PU1001.31 220.74,201.16 221.96,202.39 PR1020.2
N23164183: length 2.1
  BOTTOM w0.254: PU1001.2 221.78,199.43 222.02,199.67 222.02,200.28 222.4,200.66 PR1007.2
N23164187: length 1.3
  BOTTOM w0.254: PR1005.1 222.45,198.63 PU1001.4
N23165109: length 1.8
  BOTTOM w0.254: PR1014.1 234.79,199.6 234.23,199.03 PU1002.3
N23165131: length 4.8
  BOTTOM w0.254: PU1002.7 232.93,196.66 233.17,196.42
  BOTTOM w0.381: 233.17,196.42 233.17,196.42 PC1081.2
  BOTTOM w0.508: PC1081.2 233.93,195.26 234.31,194.87 235.27,194.87 PR1022.1
N23165157: length 2.6
  BOTTOM w0.254: PU1002.31 232.93,201.16 234.16,202.39 PR1023.2
N23165159: length 1.9
  BOTTOM w0.254: PU1002.2 233.97,199.43 234.66,200.13 234.66,200.28 PR1024.2
N23165163: length 1.5
  BOTTOM w0.254: PU1002.4 235.02,198.63 PR1025.1
N23165920: length 2.4
  TOP w0.356: PR1597.1 166.57,188.52 v2(166.21,188.17)
  BOTTOM w0.305: v2(166.21,188.17) 166.21,187.91 165.66,187.36 PU1501.3
N23165924: length 1.4
  BOTTOM w0.254: PU1501.6 165.29,186.16 165.47,185.98 165.47,185.52 v2(165.17,185.22)
N23165942: length 3.6
  BOTTOM w0.305: PC1512.2 v1(164.36,184.33) 164.43,184.41 164.43,185.3 PU1501.7
  BOTTOM w0.381: PR1503.1 163.16,182.58 163.49,182.91 PC1512.2
N23165976: length 2.7
  BOTTOM w0.305: PR1598.2 165.58,190.96 165.09,190.48 164.99,190.48 164.74,190.22 164.74,189.5 164.42,189.18 PU1501.31
N23165978: length 4.6
  BOTTOM w0.203: PR1506.2 165.91,190.58 165.83,190.58 v1(165.25,190) 165.25,189 165.7,188.55 165.7,188.04 165.43,187.76 PU1501.2
N23165982: length 3.5
  BOTTOM w0.203: PU1501.4 165.82,186.96 166.69,187.84 166.69,188.57 166.47,188.8 PR1599.1
N23166837: length 2.5
  TOP w0.356: v2(177.08,187.96) 176.83,187.71 PR1595.1
  BOTTOM w0.305: PU1502.3 176.48,187.36 v2(177.08,187.96)
N23166841: length 0.9
  BOTTOM w0.254: v2(176.24,185.53) 176.24,186.01 176.09,186.16 PU1502.6
N23166859: length 3.6
  BOTTOM w0.305: PU1502.7 175.22,184.6 174.26,183.65 PC1532.2
  BOTTOM w0.381: PR1510.1 174.28,183.33 PC1532.2
N23166885: length 2.6
  BOTTOM w0.305: PU1502.31 175.22,189.78 v1(175.48,190.05) 176.37,190.94 PR1596.2
N23166887: length 4.2
  BOTTOM w0.203: PU1502.2 176.22,187.76 176.5,188.04 176.5,190.33 177.26,191.09 PR1512.2
N23166891: length 3.3
  BOTTOM w0.305: PR1622.1 177.62,188.24 177.62,187.73 176.97,187.09 v1(176.94,187.09) 176.82,186.96 PU1502.4
N23167680: length 1.6
  BOTTOM w0.305: PR1624.1 198.72,188.04 198.05,187.36 PU1601.3
N23167702: length 2.7
  BOTTOM w0.305: PC1610.2 197,184.56 196.81,184.75 PU1601.7
  BOTTOM w0.356: PC1610.2 197.01,183.96 PR1603.1
N23167736: length 2.4
  BOTTOM w0.305: 197.33,189.35 196.98,189.35 196.81,189.18 PU1601.31
  BOTTOM w0.356: PR1625.2 198.43,189.82 197.96,189.35 197.33,189.35
N23167738: length 2
  BOTTOM w0.203: PR1606.2 198.6,188.93 198.09,188.42 198.09,188.04 197.81,187.76 PU1601.2
N23167742: length 1.4
  BOTTOM w0.305: PR1623.1 198.59,186.96 PU1601.4
N23168679: length 2.4
  TOP w0.356: PR1631.1 187.7,188.09 v2(187.78,188.17)
  BOTTOM w0.305: PU1602.3 187.23,187.36 187.78,187.91 v2(187.78,188.17)
N23168701: length 2.7
  BOTTOM w0.305: PC1629.2 186.2,184.56 186.01,184.75 PU1602.7
  BOTTOM w0.356: PC1629.2 186.21,183.96 PR1610.1
N23168727: length 2.6
  BOTTOM w0.305: PR1628.2 187.19,190.99 186.28,190.07 186.28,189.45 186.01,189.18 PU1602.31
N23168729: length 4.2
  BOTTOM w0.203: PR1611.2 187.52,190.58 187.52,188.9 187.29,188.67 187.29,188.04 187.02,187.76 PU1602.2
N23168733: length 3.1
  BOTTOM w0.254: PU1602.4 187.41,186.96 188.28,187.84 188.28,188.62 PR1629.1
N23169663: length 1.6
  BOTTOM w0.305: PU1603.3 208.97,187.36 209.65,188.04 PR1633.1
N23169685: length 2.7
  BOTTOM w0.305: PC1648.2 207.92,184.56 207.73,184.75 PU1603.7
  BOTTOM w0.356: PR1617.1 207.93,183.96 PC1648.2
N23170380: length 2.4
  BOTTOM w0.305: 208.25,189.35 207.9,189.35 207.73,189.18 PU1603.31
  BOTTOM w0.356: 208.25,189.35 208.88,189.35 209.35,189.82 PR1630.2
N23170382: length 1.4
  BOTTOM w0.305: PU1603.4 209.51,186.96 PR1632.1
N23170384: length 2
  BOTTOM w0.203: PR1620.2 209.52,188.93 209.01,188.42 209.01,188.04 208.73,187.76 PU1603.2
N24008107: length 1.1
  BOTTOM w0.097: PT1601.1 195.61,190.06 PU1601.28
N24010016: length 2.4
  BOTTOM w0.305: PC1609.1 198.34,186.26 198.24,186.16 PU1601.6
  BOTTOM w0.356: PR1602.2 198.98,185.63 198.77,185.83 PC1609.1
N24010249: length 2.6
  TOP w0.356: PC1628.1 v2(187.04,185.5) 187.43,185.5 PR1609.2
  BOTTOM w0.254: v2(187.04,185.5) 187.04,185.88 186.76,186.16 PU1602.6
N24011067: length 2.4
  BOTTOM w0.305: PC1647.1 209.26,186.26 209.17,186.16 PU1603.6
  BOTTOM w0.356: PR1616.2 209.9,185.63 209.7,185.83 PC1647.1
N24022243: length 2.6
  BOTTOM w0.254: PU901.6 258.14,197.83 258.46,197.51 PC907.1
  BOTTOM w0.508: PR903.2 260.05,197.76 259.81,197.51 PC907.1
N24022700: length 2.8
  BOTTOM w0.254: PU902.6 270.34,197.83 270.66,197.51 PC1542.1
  BOTTOM w0.508: PC1542.1 271.93,197.51 272.45,196.99 PR911.2
N24023177: length 2.6
  BOTTOM w0.254: PC1072.1 221.89,197.51 221.57,197.83 PU1001.6
  BOTTOM w0.508: PC1072.1 223.32,197.51 PR1002.2
N24023662: length 2.5
  BOTTOM w0.254: PC1082.1 234.16,197.51 233.84,197.83 PU1002.6
  BOTTOM w0.508: PC1082.1 235.03,197.76 PR1021.2
N24034924: length 1.6
  TOP w0.203: PU1308.5 199.81,153.17 199.41,153.57 PC1327.2
N24579709: length 9
  BOTTOM w0.076: 33.03,56.21 33.03,55.31 33.18,55.16
  BOTTOM w0.089: 31.46,58.63 30.58,58.63 ; 33.18,55.16 33.75,55.16 33.92,54.99 33.92,54.77 34.27,54.42 U5.K5
  BOTTOM w0.097: 30.58,58.63 v1(29.84,59.36) 29.69,59.52 C310.1 ; 33.03,56.21 33.03,57.19 32.86,57.36 32.73,57.36 31.46,58.63
N24733526: length 1.9
  BOTTOM w0.254: R872.1 62.19,11.45 U50.2
N25031555: length 4.7
  BOTTOM w0.097: U58.2 47.68,38.25 47.42,38.51 45.75,38.51 45.34,38.1 C699.1 R300.1
N25091766: length 1.1
  BOTTOM w0.097: R521.2 46.12,41.1 U61.2
N25091772: length 2
  BOTTOM w0.097: R61.1 C572.2 46.01,41.75 U61.1
N25389389: length 41.6
  TOP w0.203: PR233.2 80.11,18.11 80.11,18.36 v2(79.98,18.49)
  TOP w0.254: v2(48.1,29.67) 48.1,30.17 47.58,30.69 PR201.1
  IN03 w0.254: v2(48.1,29.67) 48.3,29.47 48.3,29.01 48.66,28.65 50.13,28.65 50.51,29.04 55.98,29.04 57.63,27.38 69.06,27.38 75.53,20.91 78.3,20.91 80.11,19.1 80.11,18.62 v2(79.98,18.49)
  vias: v1(44.16,34.37)
N25440711: length 3.7
  TOP w0.254: v1(120.95,183.34) PR1169.2 121.91,183.39 PC1143.1 PC1141.1 PR1177.1
N25456253: length 7.7
  TOP w0.203: PR233.1 79.55,15.13 PC224.1 79.74,14.32 79.72,14.3 PC205.1 80.68,12.55 81.96,12.55 v1(82.06,12.45) 82.62,11.89 83.53,11.89 83.79,11.64 PU201.32
N25456262: length 7.8
  TOP w0.203: PU201.31 84.19,12 83.92,12.27 83.03,12.27 82.39,12.91 80.87,12.91 80.68,13.1 PC206.1 80.68,13.99 81.13,14.44 PC224.2 80.82,15.26 PR232.1
N25470408: length 6.1
  IN03 w0.508: v2(153.32,200.54) 152.37,199.59 152.37,197.67 152.88,197.17 v2(152.94,197.17)
  BOTTOM w0.305: v2(152.94,197.17) 152.69,197.17 152.3,197.55 PU1303.A1
  BOTTOM w0.33: PU1303.A4 152.3,199.45 152.43,199.58
  BOTTOM w0.508: PC1307.1 152.43,199.58
N25470498: length 5.3
  BOTTOM w0.097: PU1303.B3 151.16,198.69 150.78,198.31 149.08,198.31 148.43,198.96 v1(148.18,198.96) 148.18,198.2 148.3,198.07 148.3,198.07 PR1305.1
N25470530: length 1.6
  BOTTOM w0.33: PU1303.B2 151.17,198.19 150.78,197.8 150.38,197.8 PC1317.2
N25541282: length 12
  TOP w0.097: R484.1 v2(259.18,66.12)
  BOTTOM w0.097: JWLAN1.54 267.5,70.13 263.49,66.12 v2(259.18,66.12)
N25541303: length 11.3
  TOP w0.097: R517.1 v2(259.18,67.39)
  BOTTOM w0.097: v2(259.18,67.39) 259.56,67.01 264,67.01 267,70.01 JWLAN1.56
N25547911: length 1.2
  TOP w0.457: R849.2 295.9,34.22 C510.2
N25547913: length 1.2
  TOP w0.457: C511.2 296.02,31.58 R850.2
N25547935: length 1.9
  BOTTOM w0.508: v1(295.47,31.55) 295.23,31.8 R847.1 295.21,32.48 D9.1
N25547941: length 1.8
  BOTTOM w0.508: v1(295.42,34.5) 295.22,34.3 R848.1 294.43,33.58 D10.1
N25681410: length 2.8
  BOTTOM w0.097: U50.4 59,10.8 59.23,10.57 59.23,10.06 58.85,9.68 58.74,9.68 ; 58.74,9.68 v1(58.74,9.67) ; 58.74,9.68 R873.2
N25683019: length 6.9
  TOP w0.076: 72.85,7.06 72.85,8.34 72.6,8.59 U19.J4
  TOP w0.089: 72.85,7.06 72.85,6.65 73.96,5.54
  TOP w0.097: v1(74.06,3.23) 73.63,3.66 73.63,5.19 73.81,5.36 R930.2 73.96,5.54
N25683144: length 11.4
  TOP w0.097: C320.1 v3(77.69,6)
  TOP w0.102: U19.K5 v1(73.63,9.37)
  BOTTOM w0.097: v3(77.69,6) 77.11,5.41 72.49,5.41 v1(72.36,5.54) 72.36,5.92 73.88,7.45 73.88,9.11 v1(73.63,9.37)
N25685333: length 9.5
  TOP w0.076: 69.84,15.07 69.84,13.12 U19.D12
  TOP w0.097: 69.84,15.07 69.84,15.3 68.75,16.39 68.75,20.96 v1(68.93,21.14) 68.93,21.16 69.06,21.29 TP143.1
N25685335: length 8.8
  TOP w0.097: U19.D13 70.1,15.43 68.98,16.54 68.98,18.7 v1(69.15,18.88) 69.15,20.32 69.43,20.6 69.88,20.6 TP155.1
N25685337: length 7.5
  TOP w0.076: U19.E12 70.34,13.12 70.34,13.47
  TOP w0.097: 70.34,13.47 70.33,13.49 70.33,15.58 69.36,16.54 v1(69.36,17.35) 69.75,17.35 70.33,17.93 TP161.1
N25691111: length 1.3
  BOTTOM w0.097: U50.3 62.4,10.8 v1(62.45,10.75)
N25940457: length 1.3
  BOTTOM w0.097: R537.1 137,149.84 137.26,149.58 U59.4
N27165992: length 3.8
  BOTTOM w0.089: v1(37.21,58.55) R257.1 36.05,58.31 36.05,57.09
  BOTTOM w0.097: U5.N8 35.77,56.82 36.05,57.09
N27176542: length 5.7
  BOTTOM w0.089: v1(40.76,52.02) 41.5,52.02 ; 38.69,51.91 39.47,51.13 39.97,51.13 40.1,51.26 40.61,51.26 40.86,51.01
  BOTTOM w0.097: 41.5,52.02 41.55,52.02 R777.2 R546.2 40.86,51.01 ; U5.E13 38.69,51.91
N27536412: length 1.8
  TOP w0.097: U21.5 22.56,41.99 22.83,42.26 22.83,43.06 R498.2
N27707657: length 2.1
  BOTTOM w0.097: R832.1 54.11,41.77 U22.2
N27707680: length 2.1
  BOTTOM w0.097: U22.3 53.71,41.72 54.07,41.35 R833.1
N27707693: length 1.9
  BOTTOM w0.097: U22.4 53.31,41.48 53.18,41.35 R834.1
N27707695: length 1.2
  BOTTOM w0.097: R834.2 53.18,38.94 TP138.1
N27707716: length 2.1
  BOTTOM w0.097: U22.5 52.91,41.54 R835.1
N27707880: length 2.2
  BOTTOM w0.097: R836.1 51.4,40.97 52.51,42.08 U22.6
N27707929: length 3.7
  BOTTOM w0.097: v1(49.58,40.51) 49.99,40.92 R837.1 51.45,41.86 51.91,41.86 52.11,42.06 U22.7
N27708322: length 2.1
  TOP w0.097: v1(109.06,98.5) 109.14,98.43 R57.2 108.86,97.21 U56.2
N27708482: length 2.9
  BOTTOM w0.097: U22.10 51.38,44.17 51.18,44.38 v1(51.18,44.83) 51.15,44.86 50.46,44.86 50.08,44.48 R838.1
N27708566: length 2.5
  BOTTOM w0.097: U22.8 51.33,43.37 51.02,43.06 v1(51.02,42.73) 50.29,41.99 R839.1
N27708610: length 2
  BOTTOM w0.097: R840.1 50.39,43.01 51.15,43.77 U22.9
N27708793: length 5.8
  BOTTOM w0.097: U22.12 52.51,45.84 51.73,46.61 R841.2 52.17,47.12 52.17,47.8 52.01,47.96 50.13,47.96 v1(50.01,47.83)
N27708827: length 1.9
  BOTTOM w0.097: U22.13 52.91,46.59 R842.2
N27708900: length 2.1
  BOTTOM w0.097: R843.2 53.31,45.98 U22.14
N27709001: length 2.1
  BOTTOM w0.097: U22.20 v1(56,43.37) 56.72,43.37 TP132.1
N27709027: length 2.3
  BOTTOM w0.097: U22.19 56.23,43.77 v1(56.86,44.4)
N27709052: length 1.4
  BOTTOM w0.097: U22.18 55.87,44.17 TP144.1
N27709061: length 3.8
  BOTTOM w0.097: v1(56.86,46.82) 56.86,46.18 56.23,45.55 54.71,45.55 54.51,45.35 U22.17
N27709088: length 2.3
  BOTTOM w0.097: TP182.1 54.71,45.93 54.11,45.33 U22.16
N27794221: length 3.5
  BOTTOM w0.097: U22.15 53.71,45.82 53.94,46.05 54.4,46.05 55.16,46.82 TP188.1
N28118695: length 1
  TOP w0.097: PR1415.2 53.26,9.48 PQ1402.5
N28118785: length 1.1
  TOP w0.254: PQ1402.6 53.95,8.98 53.69,8.72 PR1403.1
N28551818: length 76.1
  TOP w0.508: v2(39.67,25.78) PR236.1 40.53,26.5 PR235.1 ; PC201.1 35.35,39.07 38.13,39.07 PR237.1 38.4,37.56 PC202.2 38.96,37.04 v2(39.08,36.91) ; v2(83.28,19.13) 83.28,17.91 v1(83.9,17.3) 83.28,16.68 PR202.1
  IN03 w0.508: v2(39.08,36.91) 37.69,35.51 37.69,27 38.91,25.78 v2(39.67,25.78) 42.31,25.78 46.96,30.43 56.23,30.43 58.13,28.53 69.82,28.53 72.49,25.86 75.66,25.86 81.58,19.94 82.47,19.94 v2(83.28,19.13)
N28552039: length 2.1
  TOP w0.097: PU201.6 82.35,9 82.06,8.72 PR213.2
N28552088: length 2.3
  TOP w0.097: PU201.7 82.69,8.6 v1(82.26,8.17) 81.91,7.83 PR215.2
N28552117: length 2.5
  TOP w0.097: PR216.2 81.58,6.81 82.97,8.2 PU201.8
N28552363: length 3.5
  TOP w0.254: PU201.9 83.79,7.37 83.61,7.19 82.59,7.19 82.38,6.98 82.38,6.97 v1(82.28,6.88) 81.33,5.92 PR219.2
N28552439: length 1
  TOP w0.254: PC222.2 80.99,4.98 81.07,4.91 PR221.1
N28552547: length 3.1
  TOP w0.254: PU201.11 84.59,6.98 84.42,6.82 84.42,6.81 83.86,6.25 PR224.2 PR222.1
N28554029: length 4.4
  TOP w0.254: PU201.15 86.19,7.16 PC213.1 87.34,6 87.34,5.92 88.05,5.22 PR211.1 88.15,5.23 PC216.1
N28554039: length 4
  TOP w0.254: PC217.1 85.87,5.22 PR212.1 86.87,5.38 86.25,6 PC213.2 85.79,6.64 PU201.14
N28554122: length 2.6
  TOP w0.254: 87.85,11.38 87.47,11 PU201.24
  TOP w0.356: 87.85,11.38 87.85,11.57 PR210.1
N28554284: length 1
  TOP w0.508: PR210.2 PC212.1
N28555638: length 2
  TOP w0.254: 84.93,12.53 84.99,12.47 PU201.29
  TOP w0.356: PR204.2 84.55,12.91 84.93,12.53
N28555679: length 2.9
  TOP w0.254: PU201.28 85.39,12.73 85.29,12.83 85.29,13.59 PC207.2
N28555719: length 1.7
  TOP w0.254: PC207.1 85.82,12.69 85.79,12.65 PU201.27
N28555734: length 3.3
  TOP w0.254: 86.46,12.17 86.19,11.9 PU201.26
  TOP w0.356: PC231.1 86.46,12.47 86.46,12.17
  TOP w0.508: PC231.1 86.76,14.55 PR205.2
N28559619: length 8.5
  TOP w0.508: PR218.2 94.04,6.04 v2(94.2,6.2) 95.5,6.2 PD201.1
  BOTTOM w0.508: v2(94.2,6.2) 94.2,7.41 93.34,8.27 93.34,8.99 93.69,9.35 PD202.1
N28559889: length 5.6
  TOP w0.254: PR217.2 91.15,5.67 91.03,5.79 90.73,5.79 89.43,7.09 88.28,7.09 v1(88.12,7.25) 87.17,8.2 PU201.17
N28559931: length 8.9
  TOP w0.254: PR217.1 v2(91.15,3.64)
  TOP w0.305: v2(97.33,5.54) 97.4,5.62 PH201.2
  IN08 w0.254: v2(91.15,3.64) 92.81,5.29 97.07,5.29 v2(97.33,5.54)
N28563405: length 4.9
  TOP w0.254: PU201.16 86.59,7.44 87.32,6.71 88.92,6.71 PR225.2 89.71,5.92 89.71,5.67 PR223.1
N28563583: length 2.2
  TOP w0.254: PR220.2 84.8,6.53 v1(84.88,6.6) 84.99,6.71 PU201.12
N28615744: length 1.3
  BOTTOM w0.508: PR919.1 PC23.2
N28664348: length 4.9
  TOP w0.097: PR208.2 84.93,3.25 85.31,3.64 85.31,6.18 85.39,6.25 PU201.13
N29688421: length 1.5
  TOP w0.097: PU605.3 73.51,51.76 PT602.1
N29688423: length 1.4
  TOP w0.097: PT603.1 73.38,51.26 PU605.4
N29688473: length 1.9
  TOP w0.254: PR624.2 79.58,47.8 PU605.15
N29688500: length 5.8
  TOP w0.203: v1(78.86,45.24) PR648.1 77.95,47.2 78.4,47.65 PR647.1
  TOP w0.254: PU605.14 79.08,48.02 PR647.1
N29688522: length 2.2
  TOP w0.254: PR649.2 80.66,47.65 79.97,48.34 79.97,48.72 80.08,48.82 PU605.16
N29884571: length 6.6
  TOP w0.097: R184.2 4.93,169.84 v2(4.93,170.01) C168.1 4.93,171.34 4.76,171.51 LD1.3
  BOTTOM w0.097: v2(4.93,170.01) 4.93,168.34 v1(6.32,166.96)
N29884573: length 13.1
  TOP w0.097: LD1.1 5.28,174.31 5.33,174.35 C169.1 ; C169.1 5.67,174.44 6.06,174.83 10.64,174.83 v1(11.78,173.69) ; C169.1 5.89,174.13 5.89,172.27 5.43,171.81 5.43,169.62 5.3,169.5 R191.2
N29961497: length 2.6
  TOP w0.097: U18.2 18.32,67.45 18.64,67.14 19.96,67.14 R495.1
N29961526: length 3.4
  TOP w0.097: R496.2 20.21,71.02 19.91,71.33 v1(19.78,71.33) 19.65,71.33 18.97,70.64 U18.4
N30237927: length 7
  TOP w0.097: R854.2 C509.2 106.46,3.01 D55.1 107.41,3.51 v2(107.79,3.89)
  BOTTOM w0.097: v2(107.79,3.89) 107.56,3.66 SWPWR2.1 SWPWR2.3
N30678816: length 0.8
  TOP w0.356: PC601.2 PR605.1
N31577862: length 3.2
  BOTTOM w0.097: R894.2 205.89,197.56 205.45,197.56 v1(205.2,197.82) 204.57,198.45 JEDP1.5
N31743879: length 1.5
  BOTTOM w0.097: U26.4 44.72,45.11 44.72,46.4 R580.2
N33040713: length 3.9
  TOP w0.097: C407.2 R152.2 v1(19.07,47.88) ; C407.2 19.15,45.98 Q52.2 ; C407.2 R791.2
N33040971: length 5.6
  TOP w0.097: Q52.6 19.65,44.03 v2(19.27,44.4)
  BOTTOM w0.097: v1(18.28,45.8) 18.08,45.6 C406.2 ; R377.2 19.32,44.35 v2(19.27,44.4) 18.89,44.78 C406.2 ; C406.2 18.03,44.73 Q29.2
N33486178: length 3.9
  TOP w0.089: v1(39.72,52.78) 39.9,52.61 R523.2
  IN03 w0.089: v1(37.43,52.66) 39.59,52.66 v1(39.72,52.78)
  BOTTOM w0.089: v1(37.43,52.66) 37.03,52.66 U5.G10
N33525072: length 3.3
  BOTTOM w0.254: PQ1409.5 PQ1409.6 v1(306.79,109.8) 307.24,109.8 PR712.2 PR3551.2
N33525121: length 4.9
  BOTTOM w0.097: PQ1409.2 306.29,108.03 306.04,108.28 305.53,108.28 304.82,107.57 PR416.1 304.06,107.57 303.75,107.27 v1(303.75,107.01) 304.06,106.71 PR414.2
N33525138: length 3
  BOTTOM w0.254: PR703.2 PR704.1 302.1,95.08 301.97,95.2 PU701.13
N33525142: length 1
  BOTTOM w0.254: PC721.1 219.17,166.02 PR717.2
N33525205:
  vias: v1(210.03,160.73)
N33525247: length 1
  TOP w0.508: PC712.1 PR714.2
N33525265: length 2.9
  TOP w0.097: PR722.2 PR720.2 217.65,166.07 v2(217.39,165.81)
  BOTTOM w0.097: v2(217.39,165.81) 216.96,166.24 PU702.2
N33525329: length 13.1
  BOTTOM w0.254: PQ1409.3 305.79,106.75 v1(306.04,106.51) 306.04,105.92 305.02,104.91 305.02,100.92 305.4,100.54 306.42,100.54 306.8,100.16 306.8,100.03 309.16,97.67 PR415.2
N33525740: length 1.3
  BOTTOM w0.508: PC3409.1 PR3404.2
N33525746: length 1.3
  BOTTOM w0.508: PC3425.1 PR3409.2
N33525779: length 5.8
  BOTTOM w0.254: PC3436.2 306.06,94.82 PR3421.1 306.98,94.52 307.26,94.24 308.73,94.24 PR3420.2 ; PR3420.2 PC3438.2 ; PR3420.2 310.15,93.68 PR3422.1
N33533058: length 0.9
  TOP w0.508: D39.2 80.46,19.76 R570.1
N33547696: length 4.3
  BOTTOM w0.097: PU1604.13 214.22,101.17 214.6,101.55 v1(215.23,101.55) 215.36,101.68 PR3449.2 PR3426.1
N33548040: length 1.3
  BOTTOM w0.508: PR3434.2 PC3515.1
N33548052: length 1.2
  BOTTOM w0.508: PC3519.1 PR3445.2
N33548085: length 3.8
  BOTTOM w0.254: PC3514.2 PR3438.2 210.71,102.44 210.66,102.39 PC3506.2 ; PC3514.2 209.82,103.46 PR3437.1 ; PC3514.2 210.74,103.48 PR3435.1
N33548178: length 11.8
  BOTTOM w0.254: PR3433.1 210.38,96.02 PR3540.1 PC3518.1 209.57,95.15 209.85,94.87 209.85,93.88 209.34,93.37 v1(209.34,92.99) 208.43,92.99 207.79,93.63 207.79,97.54 208.38,98.12 PR3431.2
N33575839: length 0.9
  BOTTOM w0.254: PC3528.1 126.2,133.71 PR3459.2
N33575872: length 1.4
  BOTTOM w0.508: PC3538.1 119.37,126.91 PR3460.2
N33575908: length 1.4
  TOP w0.356: PR3462.2 122.72,133.74 PC3533.1
N33575935: length 4.3
  BOTTOM w0.254: PU1309.2 123.9,133.13 124.13,132.9 124.13,131.88 124.54,131.47 124.54,130.53 124.84,130.22 PR3464.2
N33583518: length 30.3
  TOP w0.254: PR1449.1 PR1446.2 290.09,177.42 289.91,177.24 287.85,177.24 286.96,176.36 282.96,176.36 282.16,177.15 282.16,180.83 277.97,185.02 277.97,186.39 276.84,187.52 276.84,188.56 v2(276.96,188.67)
  BOTTOM w0.254: PH1108.1 272.71,191.47 275.26,191.47 276.83,189.9 276.83,188.8 v2(276.96,188.67)
N33583760: length 1.3
  TOP w0.254: PC1429.2 293.64,177.93 294.48,178.77 PR1461.1
N33583816: length 1.8
  TOP w0.254: PC1431.2 297.4,178.26 297.02,177.88 PR1463.1
N33583836: length 2.1
  TOP w0.097: PU1605.39 295.12,185.63 295.88,186.39 PR1467.2
N33589722: length 5.5
  TOP w0.254: 288.64,184.86 288.64,184.61 288.82,184.43 PU1605.15 ; 288.64,184.86 v2(288.64,185.45) 288.82,185.45 289.04,185.23 PU1605.13 ; 288.64,184.86 288.67,184.83 PU1605.14
  BOTTOM w0.254: PR3526.2 v2(288.64,185.45)
N33598415: length 0.8
  BOTTOM w0.356: PT1005.1 245.08,195.91 244.7,196.29
N33598431: length 1.3
  BOTTOM w0.508: PC3547.2 PR3538.1
N33598435: length 2.1
  BOTTOM w0.254: PR3538.2 245.21,201.88 244.72,201.4 PU1606.30
N33598437: length 4.1
  BOTTOM w0.254: PU1606.27 243.52,202.17 PC3547.1 244.35,202.17 244.35,201.53 244.32,201.5 PU1606.29
N33598858: length 1.7
  BOTTOM w0.254: PU1606.3 246.32,199.03 247.01,199.72 PR3536.1
N33598864: length 5.1
  BOTTOM w0.254: PU1606.7 245.12,196.63 245.89,195.86 PC3556.2
  BOTTOM w0.508: PR3539.1 247.56,194.9 246.09,194.9 245.89,195.1 PC3556.2
N33598872: length 2.6
  BOTTOM w0.254: PR3534.2 246.35,202.39 245.12,201.16 PU1606.31
N33598874: length 2
  BOTTOM w0.254: PR3533.2 246.4,200.08 246.4,199.67 246.16,199.43 PU1606.2
N33598878: length 1.5
  BOTTOM w0.254: PU1606.4 246.96,198.63 PR3535.1
N33599032: length 2.6
  BOTTOM w0.254: PU1606.6 245.95,197.83 246.27,197.51 PC3558.1
  BOTTOM w0.508: PC3558.1 247.38,197.91 PR3537.2
N33607325: length 0.9
  BOTTOM w0.254: PR3432.2 PR3541.1
N33610549: length 1
  TOP w0.254: PR3468.1 299.99,187.91 PR3547.2
N33610807: length 11.2
  TOP w0.254: PR3467.2 PC3542.1 297.22,190.66 297.53,190.96 v1(298.16,190.96) 298.8,190.96 299.13,190.63 PR3542.2 299.43,189.69 299.82,190.07 300.58,190.07 300.7,189.94 300.7,187.53 300.2,187.02 PR3466.1
N33675888: length 10.1
  TOP w0.457: PQ205.4 36.16,37.29 36.8,37.93 v2(36.8,38.18) PR237.2
  TOP w0.508: PQ201.4 35.58,31.83 v2(34.8,32.61)
  IN03 w0.508: v2(36.8,38.18) 36.8,34.61 v2(34.8,32.61)
N33675896: length 1.4
  TOP w0.508: PQ202.4 40.48,27.46 PR235.2
N33769583: length 2.3
  BOTTOM w0.254: R827.1 50.09,45.3 Q53.3 48.81,45.3 48.66,45.45 48.66,45.65 48.81,45.8 Q53.2
N33769629: length 4
  BOTTOM w0.097: Q53.5 48.08,45.8 48.48,46.21 v1(48.48,47.32) 48.2,47.32 47.49,46.61 R435.2
N34215558: length 1.6
  BOTTOM w0.097: U2015.20 67.92,84.61 R2314.2
N34263843: length 1.7
  BOTTOM w0.097: R2315.2 73.93,89.01 73.93,89.79 74.12,89.98 U2016.8
N34625001: length 5.1
  TOP w0.097: v3(54.47,87.03) 54.43,86.99 54.43,86.89 54.53,86.78 54.76,86.78 54.95,86.97 v2(56.74,86.97) 57.01,86.97 57.55,87.51 58,87.51 58.1,87.41 58.1,87.22 57.96,87.07 C2153.2
  BOTTOM w0.102: U2005.Y11 v3(54.47,87.03)
N34625004: length 5.1
  TOP w0.097: C2154.2 57.75,87.78 57.44,87.78 56.9,87.24 v2(55.09,87.24) 54.81,87.24 54.76,87.29 54.76,87.29 54.64,87.4 54.32,87.4 53.95,87.03 v3(53.82,87.03)
  BOTTOM w0.102: U2005.W11 v3(53.82,87.03)
N35183294: length 2.7
  BOTTOM w0.097: C1340.1 205.61,131.43 Q13.2 ; C1340.1 206.39,130.64 R1004.2 ; C1340.1 R1003.2
N35184706: length 2.5
  TOP w0.356: v3(243.23,133.72) 243.23,133.37 243.69,132.92 C685.1 R16.2
  BOTTOM w0.3: v3(243.23,133.72) 243.13,133.72 G2.BB30
N35211433: length 1.1
  TOP w0.097: v3(261.48,142.97) 261.66,142.79 R1022.2
  BOTTOM w0.097: G2.R44 261.78,143.27 v3(261.48,142.97)
N35211439: length 2.2
  TOP w0.097: v3(262.79,142.97) 263.17,142.58 263.52,142.58 R1021.2
  BOTTOM w0.097: G2.P44 v3(262.79,142.97)
N35211449: length 1.7
  TOP w0.097: v3(261.48,143.67) 262.17,144.35 R1023.1
  BOTTOM w0.11: G2.R45 v3(261.48,143.67)
N35211451: length 1
  TOP w0.097: TP118.1 262.71,143.59 v3(262.79,143.67)
  BOTTOM w0.097: G2.P45 v3(262.79,143.67)
N35211455: length 12.6
  TOP w0.254: R1024.2 R1025.1 274.54,150.27 274.54,151.08 274.03,151.59 269.97,151.59 268.89,152.67 v3(268.89,152.74)
  BOTTOM w0.097: v3(268.89,152.74) 268.89,152.67 269.34,152.23 269.34,150.45 268.84,149.95 268.84,148.92 G2.E52
N35236381: length 3.3
  TOP w0.097: Q75.5 202.15,129.62 202.41,129.87 R996.2 R998.2 v1(202.84,127.89)
N35237831: length 3
  TOP w0.097: R989.2 245.08,104.27 Q76.2 245.08,103.32 244.91,103.15 244.44,103.15 243.91,102.62 R988.2
N35237855: length 1.8
  TOP w0.097: Q76.5 R991.2 R992.2
N35239365: length 9.1
  TOP w0.097: v1(219.04,112.98) 219.12,113.06 R963.1
  TOP w0.356: R2156.1 R2157.1 ; R2157.1 R2158.1 ; R2157.1 R963.1 219.12,114.46 219.17,114.51 R962.2 220.03,115.19 R2158.1 ; R2158.1 R2159.1 R2160.1 R2161.1
N35242647: length 4
  TOP w0.097: R2171.2 R2172.1 301.09,70.82 300.83,70.56 v1(300.83,70.18) 300.96,70.06 301.72,70.06 301.96,70.3 U63.4
N35243502: length 1.7
  BOTTOM w0.097: G2.BM24 235.81,129.19 235.38,129.19 235.17,128.98 TP113.1
N35243504: length 5.9
  BOTTOM w0.097: G2.BM23 234.78,127.46 232.76,127.46 232.51,127.71 TP116.1 231.74,127.71 231.24,127.21 R2255.2
N35243522: length 6.2
  BOTTOM w0.097: R2254.2 232.56,127.21 233.42,127.21 233.57,127.05 233.57,126.8 233.78,126.6 v1(234.03,126.6) TP117.1 234.94,127.11 236.41,128.57 G2.BL23
N35243524: length 11.5
  BOTTOM w0.097: R2256.2 R2257.1 TP114.1 230.09,128.35 232.65,128.35 233.14,127.86 233.66,127.86 233.9,128.1 233.9,129.03 234.34,129.47 235.4,129.47 235.54,129.61 236.71,129.61 237.05,129.27 G2.BK24
N35243532: length 7.8
  BOTTOM w0.097: G2.BL24 236.28,128.96 235.78,128.96 234.92,128.1 234.49,128.1 234.05,127.66 232.89,127.66 232.45,128.1 231.39,128.1 v1(230.98,127.69) 230.35,127.05 R1019.1
N35243651: length 5.5
  BOTTOM w0.097: R1020.1 233.65,126.14 234.27,126.14 236.35,128.22 236.78,128.22 237.13,128.57 G2.BK23
N35248107: length 2.8
  TOP w0.381: C887.1 248.33,170.01 247.97,169.64 R2219.1 R774.1
N35248159: length 1.9
  BOTTOM w0.381: R2213.2 247.12,173.14 v1(247.12,174.04) 247.12,174.32 246.99,174.45 Q81.6
N35249592: length 3.5
  TOP w0.097: v3(262.31,171.15) v1(262.99,171.15) 263.58,171.15 264.13,171.7 R874.2
  BOTTOM w0.097: U48.J1 v3(262.31,171.15)
N35249617: length 2
  TOP w0.381: R2218.1 R2215.1 246.97,170 C907.1
N35249695: length 1.7
  TOP w0.097: R2216.2 232.55,171.2 v3(232.62,171.12)
  BOTTOM w0.097: v3(232.62,171.12) 232.65,171.15 U2022.J1
N35260582: length 2
  TOP w0.381: R2223.1 R2221.1 C908.1
N35260616: length 1.1
  BOTTOM w0.356: R866.2 282.33,172.55 282.3,172.57 Q82.6
N35261197: length 3.1
  TOP w0.097: C1326.1 283.43,170.38 v1(283.43,170.39)
  TOP w0.381: R2220.1 R871.1 C1326.1
N35261623: length 1.7
  TOP w0.097: R859.2 294.05,145.51 v3(294.1,145.56)
  BOTTOM w0.097: U2023.J1 v3(294.1,145.56)
N35261629: length 1.6
  TOP w0.097: R2222.2 266.8,171.33 267.5,171.33 v3(267.7,171.12)
  BOTTOM w0.097: U55.J1 267.73,171.15 v3(267.7,171.12)
N35266531: length 5.8
  BOTTOM w0.381: Q83.6 301.6,124.92 v1(298.8,124.92) 298.16,124.92 297.53,125.56 R2224.2
N35267092: length 1.7
  TOP w0.097: R900.2 294.18,110.46 v3(294.23,110.51)
  BOTTOM w0.097: U2025.J1 v3(294.23,110.51)
N35267128: length 2
  TOP w0.381: R903.1 R901.1 C2425.1
N35267218: length 1.8
  TOP w0.097: v3(294.23,140.17) 294.66,140.6 R904.2
  BOTTOM w0.097: U2024.J1 v3(294.23,140.17)
N35268749: length 2
  TOP w0.381: C1353.1 R2227.1 R2226.1
N35274430: length 2
  TOP w0.381: R785.1 R906.1 C1373.1
N35274464: length 4.1
  BOTTOM w0.381: R909.2 258.92,85.93 Q84.6
N35275015: length 1.6
  TOP w0.097: R913.2 243.24,91.57 v3(243.29,91.52)
  BOTTOM w0.097: U2026.J1 v3(243.29,91.52)
N35275051: length 2
  TOP w0.381: C2439.1 R914.1 R916.1
N35275141: length 1.9
  TOP w0.097: R2228.2 273.79,92.08 v3(273.28,91.57)
  BOTTOM w0.097: U60.J1 273.23,91.52 v3(273.28,91.57)
N35284510: length 3.3
  TOP w0.097: Q85.5 289.45,173.94 R2184.2 289.71,175.16 v1(289.66,175.21) 289.53,175.21 288.89,174.58 288.89,174.58 Q85.6
N35284626:
  vias: v1(276.57,77.04)
N35284705: length 1.9
  TOP w0.097: Q85.2 286.81,173.94 C2221.1 R2186.2
N35285830: length 4.4
  BOTTOM w0.254: PU5.12 299.94,199.91 299.58,200.26 PC10.1 298.73,200.26 298.41,200.58 PR3553.2 PR29.2
N35285832: length 4.8
  BOTTOM w0.254: PR36.2 300.62,202.96 PC11.2 301.82,203.28 302.56,203.28 302.79,203.06 v1(302.79,202.44) PU5.14
N35285834: length 6.6
  BOTTOM w0.254: PU5.15 303.44,203.09 v1(302.74,203.79) 302.61,203.91 301.94,203.91 PC11.1 300.99,204.35 300.8,204.54 PR3554.2 PR24.2
N35285836: length 3.4
  BOTTOM w0.254: PR26.2 297.92,198.87 PC10.2 299.62,198.87 300.01,199.26 PU5.11
N35285838: length 4.8
  BOTTOM w0.254: PR34.1 304.51,195.88 304.09,196.3 PU5.5 ; PR34.1 PR28.1 ; PR34.1 303.95,195.2 303.75,194.99 303.75,194.49 303.54,194.28 PR23.1
N35285847: length 2.6
  BOTTOM w0.356: PR22.2 PC9.2 306.25,197.86 306.16,197.95 PU5.4
N35285970: length 3.2
  TOP w0.097: 303.92,78.18 303.42,77.68 Q86.5 ; 303.92,78.18 R2188.2 v1(303.93,79.28) ; 303.92,78.18 Q86.6
N35286052: length 3.1
  TOP w0.097: Q86.2 C2222.1 R2189.2 v1(300.78,79.78)
N35290550: length 7.9
  BOTTOM w0.104: R2229.2 279.19,65.87 280.53,65.87 280.91,66.25 v2(282.23,66.25) 283.54,66.25 284.24,65.55 285.71,65.55 R2232.1
N35290561: length 8
  BOTTOM w0.104: R2107.1 285.71,65.29 284.13,65.29 283.43,65.99 281.02,65.99 280.64,65.61 v2(280.26,65.61) 279.19,65.61 R2106.2
N35290569: length 7.9
  BOTTOM w0.104: R2233.2 279.19,63.84 v2(280.1,63.84) 280.51,63.84 281.02,63.33 283.32,63.33 283.77,63.77 285.71,63.77 R2230.1
N35290577: length 7.9
  BOTTOM w0.104: R2110.2 279.19,63.58 280.4,63.58 280.91,63.07 v2(282.17,63.07) 283.43,63.07 283.88,63.51 285.71,63.51 R2231.1
N35291020: length 3.7
  TOP w0.097: v2(284.31,67.63) 284.31,66.92 284.04,66.65 U14.16
  BOTTOM w0.097: v2(284.31,67.63) 284.94,67.63 v1(284.96,67.64) 284.96,68.33 R464.1
N35291238: length 2.3
  TOP w0.097: U14.7 281.79,62.27 R462.2
N36026252: length 4.4
  TOP w0.203: 45.35,12.23 PU301.5
  TOP w0.254: PR306.1 48.1,10.11 47.87,10.34 46.83,10.34 46.49,10.68 v1(46.49,10.85) 46.49,11.09 45.35,12.23
N36026261: length 1.2
  TOP w0.203: PU301.3 44.55,11.59
  TOP w0.381: 44.55,11.26 v1(44.55,11.38) 44.55,11.59
N36026271:
  vias: v1(45.59,19.28)
N36026291: length 3.8
  TOP w0.203: PU301.13 44.55,16.28 44.29,16.54 v1(44.29,16.74)
  TOP w0.508: v1(44.29,16.74) 44.29,17.8 PC316.1 PR312.2
N36026325: length 1.3
  TOP w0.762: PR308.2 PC309.1
N36026360: length 5.4
  TOP w0.203: PU301.1 43.75,12.23 43.53,12.02
  TOP w0.254: 43.53,12.02 43.4,11.89 42.95,11.89 42.59,11.54 42.59,10.54 42.39,10.34 41.7,10.34 41.42,10.62 v1(41.07,10.62) 40.99,10.54 PR307.1
N36026424: length 1.3
  TOP w0.762: PR309.1 PC310.2
N36217862:
  vias: v1(216.25,122.76)
N36341567: length 15
  BOTTOM w0.097: R2251.2 224.58,117.94 226.41,117.94 226.61,117.73 R2252.1 v1(227.68,117.3) 228.87,116.11 232.69,116.11 232.89,116.31 234.05,116.31 234.76,117.02 236.93,117.02 G2.BK6
N36341862: length 1.2
  TOP w0.097: R2253.1 237.66,117 v3(237.69,116.97)
  BOTTOM w0.097: v3(237.69,116.97) 237.99,116.67 G2.BJ6
N36344834: length 3.9
  BOTTOM w0.254: PU5.2 306.34,199.26 306.73,198.87 PC3580.1 307.56,198.87 307.62,198.8 PR3555.2 PR3568.2
N36344836: length 3.1
  BOTTOM w0.254: PU5.1 306.37,199.91 306.73,200.26 PC3580.2 307.24,200.58 PR3569.2
N36354771: length 3.6
  BOTTOM w0.097: PR38.2 PC13.1 208.5,120.65 208.5,122.25 208.24,122.51 PU1607.2
N36355836: length 2.8
  BOTTOM w0.254: PC3578.2 PC3577.2 209.64,122.51 PU1607.5
N36384934: length 1.8
  BOTTOM w0.254: PR3556.2 PR3558.2 277.01,192.36 PR2261.1
N36385245: length 1.9
  BOTTOM w0.097: PR3560.2 PR3561.2 280.89,192.79 Q95.3
N36390914: length 1.8
  TOP w0.097: R808.1 C1332.1 Q88.2
N36390918: length 7.3
  TOP w0.097: Q88.6 304.01,61.79 v1(304.26,61.55) 304.26,61.29 303.88,60.91 303.5,60.91 302.99,60.4 302.99,60.15 302.23,59.39 302.23,58.5 302.47,58.25 Q87.4 303.67,58.25 C1330.1
N36391449: length 3.8
  TOP w0.097: Q97.5 292.83,76.53 292.45,76.91 C2682.1 R2262.1 294.28,77.98 v1(294.48,78.18)
N36493829: length 2
  TOP w0.097: Q91.2 295.45,72.6 C1338.1 R813.2
N36493854: length 1.9
  TOP w0.097: Q92.2 209.52,154.33 R1009.2 C1341.1
N36493878: length 3.8
  TOP w0.356: R1008.1 209.01,156.99 209.01,154.71 209.02,154.71 Q92.3
N36493887: length 3.2
  TOP w0.097: v1(293.97,174.83) 293.54,174.83 R1013.2 C1342.1 Q90.2
N36493900: length 1.9
  TOP w0.356: R1012.1 292.89,172.23 293.47,172.81 Q90.3
N36494579: length 3.4
  TOP w0.097: v1(298.67,83.52) 299.38,82.81 R2259.2 C2680.1 300.88,82.76 Q94.2
N36494588: length 2.5
  TOP w0.254: R2270.1 v1(302.48,81.11) 302.48,81.5 Q94.3
N36494795: length 1.2
  TOP w0.356: R2264.1 206.47,126.44 205.95,125.93 Q100.3
N36494804: length 1.9
  TOP w0.097: R2266.2 C2685.1 206.65,125.43 Q100.2
N36495019: length 2.2
  TOP w0.097: R2267.1 287.67,169.04 v1(287.5,168.86)
  TOP w0.356: Q101.3 287.51,170.05 R2267.1
N36495028: length 3.2
  TOP w0.097: Q101.2 287.06,171.4 C2686.1 R2269.2 284.75,171.86 v1(284.58,172.04)
N36495768: length 1.9
  TOP w0.097: D2015.1 17.32,139.1 17.32,138.28 R565.2
N36495771: length 1.9
  TOP w0.097: D2014.1 17.6,139.15 17.6,138.36 R862.2
N36715737: length 5.7
  BOTTOM w0.097: R781.2 211.68,197.01 211.68,197.63 211.84,197.79 C888.1 211.5,198.71 210.74,198.71 210.66,198.63 210.08,198.63 209.65,198.2 v1(209.65,197.95) 209.65,197.56 209.77,197.44 Q49.2
N36820462: length 182.3
  IN05 w0.081: v3(240.39,126.17) 240.61,126.17 240.7,126.25 240.7,126.43 240.58,126.55 235.83,126.55 235.43,126.95 232.16,126.95 229.61,129.5 222.88,129.5 221.41,130.97 205.4,130.97 204.16,129.72 202.89,129.72 199.94,126.77 196.79,126.77 183.02,113.01 117.61,113.01 111.75,107.14 98.39,107.14 88.86,97.61 88.86,87.99 88.38,87.5 87.16,87.5 86.93,87.28 v2(86.93,87.09)
  BOTTOM w0.081: v2(86.93,87.09) 86.66,87.36 85.51,87.36 C2411.2 ; G2.BF20 v3(240.39,126.17)
N36820464: length 182.3
  IN05 w0.081: v3(241.09,126.17) 241.09,126.39 240.69,126.79 235.94,126.79 235.53,127.2 232.26,127.2 229.71,129.75 222.98,129.75 221.52,131.21 205.3,131.21 204.06,129.97 202.79,129.97 199.84,127.02 196.68,127.02 182.92,113.25 117.51,113.25 111.64,107.39 98.29,107.39 88.61,97.71 88.61,88.09 88.27,87.75 87.14,87.75 v2(86.93,87.95)
  BOTTOM w0.081: C2165.2 85.51,87.67 86.66,87.67 v2(86.93,87.95) ; G2.BE20 v3(241.09,126.17)
N36820466: length 180.2
  IN05 w0.081: v3(238.44,126.09) 238.3,125.95 238.15,125.95 237.81,126.29 235.53,126.29 235.32,126.5 231.91,126.5 229.86,128.55 222.91,128.55 222.19,129.26 215.44,129.26 214.89,129.82 206.03,129.82 205.29,129.08 203.14,129.08 200.24,126.18 197.05,126.18 183.16,112.3 117.8,112.3 111.96,106.46 98.59,106.46 89.77,97.64 89.77,87.84 87.93,86.01 86.26,86.01 86.14,86.12 86.14,86.34 86.23,86.43 v2(86.43,86.43)
  BOTTOM w0.081: v2(86.43,86.43) 86.15,86.15 85.51,86.15 C2413.2 ; G2.BH20 238.44,126.22 v3(238.44,126.09)
N36820468: length 180.2
  IN05 w0.081: v3(239.09,126.17) 238.62,125.71 238.05,125.71 237.71,126.05 235.43,126.05 235.22,126.26 231.8,126.26 229.76,128.3 222.81,128.3 222.09,129.02 215.33,129.02 214.78,129.57 206.13,129.57 205.4,128.83 203.24,128.83 200.34,125.94 197.15,125.94 183.26,112.05 117.9,112.05 112.06,106.22 98.69,106.22 90.01,97.54 90.01,87.74 88.03,85.76 86.62,85.76 v2(86.43,85.56)
  BOTTOM w0.081: v2(86.43,85.56) 86.15,85.84 85.51,85.84 C2412.2 ; v3(239.09,126.17) 239.09,126.26 239.29,126.47 G2.BG20
N36820470: length 180.6
  IN05 w0.081: v3(239.79,125.37) 239.39,124.97 236.47,124.97 236.13,125.31 235.29,125.31 235.07,125.53 231.29,125.53 229.74,127.09 221.7,127.09 220.62,128.17 207.05,128.17 206.14,127.27 202.97,127.27 200.76,125.05 197.44,125.05 183.6,111.2 118.71,111.2 112.85,105.34 99.11,105.34 91.03,97.26 91.03,87.36 87.89,84.22 87,84.22 v2(86.81,84.04)
  BOTTOM w0.081: v3(239.79,125.37) 240.09,125.07 G2.BF18 ; v2(86.81,84.04) 86.53,84.32 85.51,84.32 C2414.2
N36820472: length 180.6
  IN05 w0.081: v2(86.81,84.91) 86.63,84.91 86.51,84.78 86.51,84.59 86.63,84.47 87.79,84.47 90.78,87.46 90.78,97.36 99.01,105.59 112.75,105.59 118.61,111.45 183.49,111.45 197.34,125.29 200.65,125.29 202.87,127.51 206.04,127.51 206.95,128.42 220.72,128.42 221.81,127.33 229.84,127.33 231.4,125.78 235.17,125.78 235.39,125.56 236.23,125.56 236.57,125.22 238.94,125.22 v3(239.09,125.37)
  BOTTOM w0.081: v2(86.81,84.91) 86.53,84.63 85.51,84.63 C2163.2 ; G2.BG18 239.39,125.07 v3(239.09,125.37)
N36820474: length 183.2
  IN05 w0.081: v3(240.39,124.07) 240.48,124.07 240.67,124.27 240.67,124.37 240.59,124.45 236.17,124.45 235.96,124.67 230.89,124.67 229.3,126.25 221.36,126.25 220.68,126.93 209.16,126.93 208.6,126.37 203.57,126.37 201.37,124.17 197.74,124.17 183.89,110.32 119.35,110.32 113.53,104.5 99.54,104.5 95.09,100.05 95.09,98.02 94.05,96.98 92.17,96.98 91.92,96.73 91.92,86.69 88.06,82.84 86.73,82.84 86.62,82.95 86.5,82.95 86.43,82.87 86.43,82.51 v2(86.43,82.51)
  BOTTOM w0.081: C2410.2 85.51,82.79 86.15,82.79 v2(86.43,82.51) ; G2.BF17 v3(240.39,124.07)
N36820476: length 183.2
  IN05 w0.081: v3(241.09,124.07) 240.92,124.23 240.92,124.47 240.7,124.7 236.28,124.7 236.06,124.91 230.99,124.91 229.4,126.5 221.46,126.5 220.78,127.17 209.06,127.17 208.5,126.61 203.47,126.61 201.26,124.41 197.64,124.41 183.79,110.56 119.25,110.56 113.43,104.75 99.44,104.75 94.85,100.15 94.85,98.12 93.95,97.23 92.07,97.23 91.67,96.83 91.67,86.8 87.96,83.08 86.83,83.08 86.72,83.19 86.61,83.19 v2(86.43,83.38)
  BOTTOM w0.081: G2.BE17 v3(241.09,124.07) ; C2164.2 85.51,83.1 86.15,83.1 v2(86.43,83.38)
N36821237: length 1.8
  TOP w0.097: R997.2 R994.2 67.28,77.47 Q74.5
N36821400: length 1.8
  TOP w0.097: R1017.2 R1018.2 67.02,79.84 67.28,79.58 Q74.2
N37204333: length 2.1
  TOP w0.097: v2(77.95,67.52) 77.82,67.39 C525.2
  BOTTOM w0.097: U2013.2 77.53,67.93 v2(77.95,67.52)
N37204567: length 2
  BOTTOM w0.097: R455.1 75.15,67.94 75.03,68.07 U2013.7
N37209952: length 2.2
  BOTTOM w0.097: U2014.7 65.38,57.48 64.99,57.1 R488.1
N37210471: length 2.9
  BOTTOM w0.097: C537.2 68.62,57.23 68.29,57.23 67.88,57.65 U2014.2
N37405187: length 3.8
  BOTTOM w0.097: R440.2 v1(6.83,144.61)
  BOTTOM w0.635: PU1.2 9.05,143.02 R440.2
N37465825: length 3.7
  BOTTOM w0.102: R2287.2 38.58,70.82 37.69,71.71 37.69,72.22 36.52,73.38 U2007.A3
N37465828: length 3.8
  BOTTOM w0.076: 36.74,73.54 36.66,73.62 36.01,73.62 U2007.B4
  BOTTOM w0.102: 36.74,73.54 38.07,72.22 38.12,72.22 R2288.2
N37465831: length 2.9
  BOTTOM w0.102: R2289.2 38.07,72.6 36.78,73.88 U2007.A4
N37465834: length 5.5
  BOTTOM w0.076: U2007.B3 36.01,73.12 36.4,73.12
  BOTTOM w0.102: R2290.2 37.94,69.98 37.94,70.95 37.27,71.62 37.27,72.25 36.4,73.12
N37850508: length 1.5
  TOP w0.254: R2311.2 12.62,146.76 U2030.2
N37850516: length 2.6
  TOP w0.097: U2030.4 16.23,144.93 R2313.1 16.3,143.67 v1(16.22,143.59)
N37851943: length 1.5
  TOP w0.254: U2030.3 12.6,146.11 R2312.1
N37999620: length 1.4
  TOP w0.097: PU1608.4 298.66,86.23 PR3578.2
N37999622: length 2.6
  TOP w0.097: PU1608.5 303.89,86.23 PR3575.2 v1(304.06,87.15)
N37999632: length 2.5
  TOP w0.097: PR3577.2 PR3576.2 299.06,87.53 PU1608.2
N38000060: length 1.6
  BOTTOM w0.097: PR3583.2 216.09,107.18 PU1609.4
N38000062: length 4
  BOTTOM w0.097: PU1609.5 211.46,107.18 211.3,107.01 211.3,106.35 211.39,106.25 v1(212.06,106.25) 213,106.25 PR3580.2
N38000072: length 4.7
  BOTTOM w0.097: PR3582.2 PR3581.2 213.58,109.6 213.58,108.66 213.77,108.48 PU1609.2
N38001025: length 2.4
  TOP w0.097: v1(304.08,172.98) PR3587.2 302.57,173.39 PU1610.4
N38001027: length 3.4
  TOP w0.254: PR3584.2 302.99,176.99 302.48,177.5 v1(302.23,177.5) 302.1,177.5 301.81,177.2 PU1610.5
N38001037: length 4.8
  TOP w0.097: PU1610.2 300.51,172.73 300.27,172.49 PR3588.1 300.27,170.69 v1(300.58,170.39) 301.52,171.33 PR3586.1
N39102963: length 1.8
  TOP w0.254: R2333.2 84.18,75.45 U2031.2
N39102977: length 1.4
  TOP w0.097: U2031.4 87.29,74.05 87.42,73.92 R2328.1
N39102995: length 1.4
  TOP w0.097: U2031.3 84.99,74.3 84.73,74.04 R2327.1
N39709009: length 5.6
  BOTTOM w0.254: Q106.1 81.57,77.75 82.9,79.07 84.17,79.07 84.47,78.77 R2340.2 85.06,79.2 84.98,79.28 R2339.2
N40181492: length 15
  TOP w0.254: PU604.3 v2(287.05,13.46)
  TOP w0.508: PC3594.1 277.18,12.03 278.75,10.45 PR3596.2 281.55,10.45 v2(281.79,10.21)
  IN03 w0.381: v2(287.05,13.46) 287.05,12.52 284.3,9.78 282.22,9.78 v2(281.79,10.21)
N40181496: length 3.1
  TOP w0.305: 282.4,12.85 282.51,12.96 PU604.9
  TOP w0.381: 282.4,12.85 282.07,12.52 PC3595.1 281.06,11.99 PR3596.1
N40181549: length 2.5
  TOP w0.305: PU604.2 286.76,12.96 286.89,12.83 287.5,12.83 PR3595.1 PR3597.2
N40181557: length 2.8
  TOP w0.254: PC3592.2 282.83,11.23 282.83,12.32 282.97,12.46 PU604.10
N40181561: length 1.5
  TOP w0.254: PR3600.1 285.75,12.19 286.02,12.46 PU604.1
N40181563: length 0.9
  TOP w0.254: PR3600.2 PC3593.1
N40181767: length 3.9
  TOP w0.097: PR3594.2 PC3603.1 267.62,20.75 PQ207.2
N410164083: length 2.6
  TOP w0.254: PR410.1 102.96,90.88 v1(102.78,90.7) 102.63,90.55 PU402.8
N410201640: length 13.3
  TOP w0.254: v2(305.78,85.55) 305.78,88.22 v1(305.66,88.34) 304.17,88.34 304.01,88.18 PU1608.8
  BOTTOM w0.254: v2(305.78,85.55) 305.78,85.68 306.55,86.44 PR3574.1
N410221903: length 4.8
  TOP w0.254: v1(297.91,175.47) v2(298.42,175.97) 299.82,175.97 PU1610.8 ; v2(297.02,177.12) 296.89,176.99 PR3585.1
  BOTTOM w0.254: v2(297.02,177.12) 297.28,177.12 v2(298.42,175.97)
